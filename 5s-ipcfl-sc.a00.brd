# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3P3V_LAN: length 52.1
  TOP w0.203: LCB4.1 31.67,215.52 31.77,215.42 U10.16
  TOP w0.254: 35.76,224.89 35.23,224.36 35.23,223.47 LR2.1 LR23.2
  TOP w0.305: LCB4.1 31.32,214.8 v1(31.31,214.78)
  TOP w0.457: v1(33.91,207.52) 33.73,207.34 LR5.1 ; LR1.1 38.23,224.66 ; LR10.2 v1(34.92,209.35)
  TOP w0.508: LR3.2 27.18,222.55 28.27,223.65 v1(28.27,223.93) 28.27,227.53
  TOP w0.762: 28.5,228.78 28.5,230.35 26.11,232.74 24.66,232.74 ; 35.92,225.2 33.12,227.99 29.9,227.99
  BOTTOM w0.508: v1(28.27,223.93) 29.46,223.93 v2(29.92,223.47) 29.92,218.62 30.39,218.15 30.39,217.11 31.31,216.19 v1(31.31,214.78) 31.31,213.22 31.97,212.55 32.32,212.55 33.52,211.36 33.52,207.91 v1(33.91,207.52) 34.92,208.53 v1(34.92,209.35)
+3P3V_UC: length 108.6
  TOP w0.254: v1(104.14,28.07) 103.68,27.61 102.98,27.61 UCR25.1 ; UCR12.1 UCR11.1 115.39,29.44 v1(115.39,29.86) ; 123.46,32.04 122.62,31.2 120.91,31.2 120.79,31.33 UCR28.1 119.6,31.52 119.6,30.98 v1(119.42,30.8) ; UCR39.2 112.9,30.38 v1(112.92,30.4) ; v1(110.88,30.62) 110.17,29.92 UCR34.1 109.27,28.13 v1(109.27,28.05)
  TOP w0.457: 123.82,36.98 124.33,36.46 124.33,33.59 UCR29.1 123.46,32.04 ; 100.63,36.98 99.8,36.14 99.8,29.29 100.94,28.14 UCR25.1 ; UCR3.1 110.3,44.54
  TOP w0.508: 123.82,36.98 123.82,37.44 UCR41.2 ; 102.03,36.96 102.08,36.96 102.79,37.67 102.79,39.4 107.94,44.54 110.3,44.54 ; 123.46,32.04 124.16,31.34 124.16,28.3 124.38,28.09 124.38,28.08 126.27,26.19 128.96,26.19 129.97,25.18 131.18,25.18 137.36,18.99 137.36,18.29 141.29,14.36 UCR48.1 142.29,13 144.27,11.02 150.55,11.02 151.73,9.84 P312.1
  BOTTOM w0.254: v1(119.42,30.8) 119.28,30.66 116.19,30.66 v1(115.39,29.86) 115.2,29.86 114.31,30.75 113.27,30.75 v1(112.92,30.4) 112.7,30.62 v1(110.88,30.62) ; v1(109.27,28.05) 109.03,28.3 104.37,28.3 v1(104.14,28.07)
  BOTTOM w0.508: P311.1 P312.1
+3P3VA: length 676.5
  TOP w0.178: U104.65 221.34,41.43 221.63,41.72 ; U104.104 206.22,36.04 206.15,35.97 ; 221.92,23.98 221.46,23.98 221.34,24.1 U104.32 ; 224.33,36.7 223.95,36.32 223.95,35.46 223.73,35.24 U104.55 ; U104.45 224,31.24 224.13,31.11 224.33,31.11 ; U104.120 206.02,29.64 ; U104.22 217.34,24.04 217.63,23.75 218.01,23.75 v1(218.24,23.52)
  TOP w0.203: 216.81,41.63 216.54,41.36 U104.77 ; v1(166.83,51.97) 167.11,52.25 PCH.Y16 ; U104.60 223.93,37.24 224.66,37.97 ; PCH.BC24 171.18,41.29 v1(170.84,40.94)
  TOP w0.254: v1(157.05,25.62) 157.78,26.36 157.78,26.42 ; 157.78,26.42 157.59,26.61 157.59,27.39 158.39,28.19 SR360.1 SR363.1 158.84,29.5 158.74,29.6 SR365.1 ; 157.78,26.42 158.24,26.42 158.84,27.01 SR375.1 ; v1(199.2,29.58) 199.2,25.94 199.82,25.31 199.82,23.66 201.14,22.34 v1(203.31,22.34) ; OR70.1 204.28,11.22 203.16,12.34 202.44,12.34 201.42,13.36 201.42,16.29 200.69,17.02 v1(200.69,17.4)
  TOP w0.305: O2CB6.1 225.23,38.4 224.76,38.86 v1(224.18,38.86) ; O2CB6.1 O2CB5.1 224.68,37.05 224.33,36.7 ; O2CB6.1 224.66,37.97 ; v1(217.32,41.99) 217.32,42.65 216.92,43.05 ; 221.92,23.98 223.24,23.98 ; 222.38,40.18 222.35,40.21 O2CB3.1 221.95,42.04 221.63,41.72 ; v1(226.29,32.46) 226.29,31.29 226.11,31.11 O2CB20.1 O2CB4.1 224.33,31.11 ; 206.02,29.64 O2CB1.1 204.47,29.9 204.09,30.28
  TOP w0.432: v1(217.32,41.99) 217.17,41.99 216.81,41.63
  TOP w0.457: v1(132.62,42.88) 132.65,42.91 132.65,43.98 136.1,47.44 136.1,54.05 136.47,54.42 SR759.1 ; v1(174.07,34.01) 174.07,33.86 173.63,33.43 SCB31.1 ; 223.24,23.98 224.38,22.83 O2CB16.1 O2CB2.1 225.3,23.24 224.99,23.55 ; v1(219.33,46.44) 219.93,47.03 O2R11.1 ; SR7630.1 145.08,39.17 142.9,36.98 v1(139.19,36.98) ; v1(224.18,40.18) 222.38,40.18 221.41,39.22 221.41,38.1 220.21,36.89 220.21,35.76 219.87,35.42 v1(217.53,35.42) ; 206.15,35.97 205.49,35.97 205.16,35.64 204.97,35.64 AC47.1 ; v1(216.31,49.94) 214.78,49.94 212.14,52.58 209.38,52.58 OR51.1
  TOP w0.508: 204.09,30.28 203.02,30.28 202.51,30.78 v1(202.51,31.11) ; 222.3,151.36 222.8,150.86 222.8,144.52 226.73,140.59 231.04,140.59 232.16,139.47 v1(238.07,139.47) ; 222.3,151.36 222.83,151.89 222.83,163.42 223.3,163.89 223.3,166.87 223.82,167.39 ; 222.3,151.36 221.34,151.36 216.41,146.43 PR70250.1 ; v1(174.29,31.42) 174.29,29.04 174.7,28.64 174.7,26.87 176.95,24.61 v1(177.5,24.61) ; v1(103.34,25.34) 103.38,25.31 103.38,23.29 102.44,22.35 102.44,18.72 101.47,17.75 101.47,17.08 98.31,13.92 95.55,13.92 93.82,12.19 93.82,11.32 90.87,8.37 90.87,6.37 91.83,5.41 93.9,5.41 94.29,5.02 R30.1 ; v1(205.59,35.08) 204.88,35.08 204.65,35.31 AC47.1 ; v1(33.13,29.58) 30.43,29.58 AR57.2 ; UCR41.1 121.9,40.69 UCR26.1 121.68,42.07 v1(121.82,42.21) ; v1(208.46,35.14) 208.74,35.14 209.08,35.48 210.65,35.48 211.21,34.92 v1(212.88,34.92) 216.1,34.92 216.6,35.42 v1(217.53,35.42) ; v1(142.32,22.28) v1(136.14,28.45) 130.73,33.86 v1(130.73,35.66) 130.73,39.57 v1(127.42,42.88) ; 224.99,23.55 223.37,25.17 222.31,25.17 221.58,25.91 220.29,25.91 v1(219.63,26.57) 219.63,27.42 218.66,28.4 214.93,28.4 214.27,29.06 211.23,29.06 v1(210.49,28.32) ; v1(238.07,138.13) 239.65,138.13 240.79,136.98 240.79,88.57 239.03,86.81 237.61,86.8 234.86,86.8 230.8,82.74 230.8,77.28 234.84,73.24 237.93,73.24 240.66,70.51 240.66,40.94 239.65,39.93 238.07,39.93 237.15,40.85 226.32,40.85 225.26,41.91 v1(225.04,41.91)
  TOP w0.635: 226.44,169.31 PC640631.1 ; PC640631.1 227.33,168.42 ; PC640631.1 226.44,167.53
  BOTTOM w0.203: v1(170.84,40.94) 171.16,41.26 171.15,41.27 171.15,41.99 171.36,42.2 171.36,43.27 171.09,43.55 170.62,43.55 170.29,43.22 169.62,43.22 169.06,43.78 169.06,46.53 169.15,46.62 169.15,47.13 167.67,48.62 166.82,48.62 166.18,49.26 166.18,50.28 166.54,50.64 166.54,51.68 v1(166.83,51.97)
  BOTTOM w0.254: v1(203.31,22.34) 203.31,21.25 200.69,18.63 v1(200.69,17.4)
  BOTTOM w0.457: v1(170.84,40.94) 170.97,40.82 170.97,39.9 172.12,38.75 172.12,38.44 172.8,37.77 172.8,36.76 173.07,36.48 173.07,35 v1(174.07,34.01)
  BOTTOM w0.508: v1(136.14,28.45) 134.62,28.45 132.38,26.21 122.45,26.21 121.58,25.34 v1(103.34,25.34) 97.8,25.34 97,26.14 36.56,26.14 33.13,29.57 v1(33.13,29.58) ; v1(174.07,34.01) 173.85,33.8 173.85,31.86 v1(174.29,31.42) 173.66,30.78 173.11,30.78 172.09,29.76 172.09,29.28 170.46,27.66 168.11,27.66 167.26,26.81 166.33,26.81 165.57,26.05 161.93,26.05 161.64,25.76 158.56,25.76 158.42,25.62 v1(157.05,25.62) 156.16,25.62 153.89,23.35 150.2,23.35 149.32,22.48 142.52,22.48 v1(142.32,22.28) ; v1(219.63,26.57) 219.63,25.32 218.24,23.93 v1(218.24,23.52) ; v2(238.07,140.23) v1(238.07,139.47) v1(238.07,138.13) ; v1(225.04,41.91) 225.04,41.05 v1(224.18,40.18) v1(224.18,38.86) 223.79,38.47 223.79,35.19 223.6,35 223.6,34.44 224.79,33.25 225.5,33.25 v1(226.29,32.46) ; v1(177.5,24.61) 179.41,24.61 181.43,26.63 187.85,26.63 188.43,27.22 196.49,27.22 198.85,29.58 v1(199.2,29.58) 199.2,29.58 199.71,29.58 201.24,31.11 v1(202.51,31.11) 202.97,31.57 202.97,34.16 203.89,35.08 v1(205.59,35.08) 206.78,35.08 207.12,34.73 208.05,34.73 v1(208.46,35.14) ; v1(219.33,46.44) 218.93,46.44 218.65,46.15 ; 218.65,46.15 218.65,44.1 217.32,42.77 v1(217.32,41.99) 218.11,41.2 218.11,36 v1(217.53,35.42) ; 218.65,46.15 218.34,46.15 217.09,47.4 217.09,49.15 v1(216.31,49.94) ; v1(210.49,28.32) 210.49,29.13 213.12,31.76 213.12,32.51 212.44,33.19 212.44,34.48 v1(212.88,34.92) ; v1(121.82,42.21) 123.89,42.21 124.55,42.88 v1(127.42,42.88) v1(132.62,42.88) ; v1(139.19,36.98) 139.19,36.83 138.02,35.66 v1(130.73,35.66)
+3P3VA_LED: length 4.1
  TOP w0.102: v1(94.23,9.35) 94.46,9.12 94.46,8.29 CR2.1 R30.2
  BOTTOM w0.102: v1(94.23,9.35) 94.03,9.35 v2(93.62,8.94)
+3P3VSB: length 1480.4
  TOP w0.152: v1(169.44,35.79) 169.72,35.51 170.81,35.51 171.21,35.9 172.19,35.9 173.19,34.9 v1(173.19,33.9) ; PCH.AP5 162.21,45.51 162.44,45.28 162.44,44.79 162.44,44.78 162.44,43.13 v1(162.6,42.96)
  TOP w0.178: O2CB11.1 219.66,22.85 219.66,23.65 219.34,23.97 U104.27
  TOP w0.203: PCH.BC20 168.77,40.97 v1(168.6,40.97) ; PCH.BC31 174.89,41.37 v1(175.34,41.82) ; v1(166.26,40.96) 166.58,41.29 PCH.BC15
  TOP w0.254: SCB118.1 161.76,25.74 162.2,26.19 162.2,28.28 162.58,28.66 162.72,28.66 v1(163.07,29.01) 163.49,29.43 SR115.1 ; v1(214.21,23.33) 214.16,23.28 SR839.1 214.16,21.3 v1(213.82,20.95) ; v1(208.31,92) 208.28,91.97 208.28,90.14 208.31,90.11 208.31,88.11 208.99,87.43 208.99,80.34 208.08,79.43 v1(208.08,75.39) ; RN23.4 202.97,32.41 ; v1(184.35,31.72) 184.09,31.72 SR678.1 ; PR162.1 188.29,92.38 187.97,92.7 PR167.1 187.97,94.21 187.68,94.5 v1(187.68,94.5) ; RN23.8 203.06,33.52 ; 202.31,31.88 201.83,31.39 201.83,26.14 202.1,25.87 OR29.1 ; 142.19,41.86 141.22,40.89 141.22,38.15 140.74,37.67 137.43,37.67 136.94,37.19 136.94,32.67 v1(142.19,27.42) ; 142.19,41.86 141.81,42.24 v1(140.59,42.24) ; 142.19,41.86 SR20.1 ; SR14.2 202.2,53.31 200.2,53.31 199.9,53.01 199.9,52.31 SR129.1 197.33,51.7 SR7698.1 ; SR7698.1 192.47,53.04 SR7697.1 SR7696.1 192.06,54.34 SR7769.1 ; SR7698.1 196.11,49.39 196.11,47.78 195.6,47.27 194.06,47.27 193.5,46.71 ; OR56.1 220.53,43.71 220.15,44.09 220.15,44.48 219.61,45.02 219.1,45.02 219.01,44.93 218.5,44.93 v1(217.96,44.39) 217.86,44.28 O2R20.1 218.36,43.73 218.38,43.71 OR57.1 ; SR7705.1 16.83,231.23 16.61,231.44 SC172.1 17.23,232.08 SR7706.1 MQ23.2 ; v3(190.86,42.11) 191.15,41.82 SR277.1 192.39,41.5 SR254.1 ; v3(194.46,41.81) 194.45,41.82 SR278.1 ; F3R3.2 177.72,9.06 178.93,9.06 179.32,9.45 ; v1(173.05,31.47) 173.05,30.23 v1(173.24,30.04) 173.58,29.69 173.58,28.74 173.98,28.35 173.98,27.08 SCB30.1 173.8,26.45 v1(173.58,26.24) ; SCB28.1 152.48,28.12 156.64,32.28 156.64,33.55 156.8,33.71 SCB10.1 157.23,33.71 v1(157.78,34.26) ; PR70213.1 213.13,227.69 v1(213.36,227.46) 214.5,226.31 PR6506.1 ; 202.69,31.8 203.2,31.29 203.56,30.94 OR22.2 ; v1(227.38,66.6) 228.36,67.58 228.36,70.6 229.39,71.63 238.56,71.63 v1(239.01,71.17) ; v1(173.19,33.9) 172.78,33.49 SR268.1 ; SR54.2 191.02,45.06 SR443.1 190.28,44.56 190.26,44.54 SR275.1 ; v1(178.87,29.98) 178.66,30.19 SR15.1 ; v1(182.09,9.69) F3R10.2 ; RN23.6 202.99,32.91 ; RN23.2 203.06,31.81
  TOP w0.279: RN25.8 203.03,37.94 ; RN25.2 203.06,36.23 ; RN24.6 203.13,39.87 ; RN25.4 202.95,36.83 ; RN25.6 203.08,37.33 ; RN24.2 203.01,38.77 ; 203.07,39.37 203.08,39.37 RN24.4
  TOP w0.305: v1(146.46,27.84) 150.99,27.84 151.78,27.05 SCB28.1 152.48,25.35 153.49,24.33 157.8,24.33 158.46,24.99 v1(158.98,24.99) ; v1(162.48,25.13) 162.14,24.79 SCB118.1 ; PC231.1 229.31,160.78 ; SR70.1 v1(152.08,48.01) ; v1(218.64,21.83) 218.64,21.89 219.27,22.52 O2CB11.1 ; RN26.6 210.82,44.52 ; RN26.2 209.71,44.59 ; RN26.4 210.32,44.57 210.31,44.58 ; RN24.8 203.47,40.48 203.23,40.23 ; 211.42,44.56 RN26.8
  TOP w0.381: 209.17,45.09 209.17,47.5 208.75,47.92 OR65.1 ; SR54.2 193.48,46.73 193.97,46.24 SR7748.1 193.97,45.44 SR7778.1 SR7779.1 195.9,45.07 v1(196.44,44.53) 196.49,44.48 SR7702.1 ; SR250.1 SR251.1 SR255.1 SR252.1 SR253.1 192.39,36.23 191.92,35.76 v3(191.16,35.76) ; v3(195.81,39.75) 195.82,39.74 SR256.1 SR257.1 ; PR70196.1 61.56,114.94 59.44,112.82 v1(59.03,112.82) ; OR53.2 212.29,44.45
  TOP w0.457: 188.81,32.49 SR370.1 187.95,31.97 187.28,31.3 184.78,31.3 v1(184.35,31.72) ; PR70256.1 54.71,124.4 PR234.1 56.22,124.4 ; 42.58,5.84 AR229.1 ; AR229.1 42.58,6.91 ; AR229.1 43.09,6.38 ; F3R6.2 176.97,12.53
  TOP w0.508: PR70256.1 54.5,125.14 54.42,125.22 PC640679.1 54.42,126.81 54.11,127.12 PQ9786.2 52.76,127.12 v1(52.7,127.07) ; R69687.1 R69686.1 R27.1 R31.1 101.72,5.02 v1(101.99,5.29) ; v1(221.3,223.22) 221.92,223.22 222.38,223.67 222.38,228.85 v1(220.75,230.48) 218.97,232.26 v1(210.77,232.26) ; UF6.1 66.69,12.53 66.83,12.39 v1(66.83,11.93) ; ECR105.1 132.98,92.06 133.15,91.9 v1(135.76,91.9) ; 209.82,45.2 209.82,47.61 210.41,48.21 214.93,48.21 v1(215.87,47.27) ; 181.99,38.58 181.99,38.58 182.77,38.58 183.18,38.99 183.18,40.08 ; v1(219.51,36.12) 216.42,36.12 215.85,35.55 213.4,35.55 212.81,36.13 211.37,36.13 v1(211.35,36.14) ; 112.04,3.45 112.06,3.48 v1(112.06,6.93) ; E16.8 182.61,3.23 187.53,3.23 187.81,3.51 188.62,3.51 ; v1(135.76,90.04) 133.31,87.59 133.31,86.09 132.82,85.6 132.82,80.01 123.01,70.21 115.26,70.21 107.31,62.26 107.31,53.69 113.17,47.83 118.68,47.83 119.82,46.68 119.82,45.28 124.93,40.17 124.93,28.41 126.47,26.87 129.16,26.87 130.23,25.8 132.01,25.8 v1(133.68,24.13) ; v1(162.48,25.13) SCB25.1 ; v1(52.02,126.06) 51.3,126.06 50.92,126.44 PR341.1 ; PR432.1 v1(219.25,158.7) ; v1(51.82,234.82) PD1.1 ; OR35.2 202.87,34.39
  TOP w0.635: v3(57.3,65.84) 57.63,66.17 58.47,66.17 61.95,69.65 61.95,73.18 60.86,74.27 57.94,74.27 57.23,74.98 ; SLOT1.B10 55.2,78.33 56.16,77.37 ; v3(191.16,35.76) 191.06,35.86 189.53,35.86 188.81,35.14 188.81,24.89 189.69,24.01 189.69,9.47 189.36,9.14 ; 183.18,40.08 184.81,40.08 186.61,41.88 187.17,41.88 187.32,42.04 ; v3(194.46,41.81) 195.81,40.46 v3(195.81,39.75)
  TOP w0.762: 202.59,40.28 202.59,40.82 203.63,41.86 205.23,41.86 205.69,42.32 206.1,42.32 v1(208.53,44.75) ; v3(34.59,228.68) 32.59,230.68 29.62,230.68 25.04,235.25 SR7707.1 21.31,235.25 20.37,234.31 20.37,233.1 19.85,232.58 MQ23.2 ; 52.07,5.03 52.07,10.52 53.71,12.15 v1(54.59,12.15) 54.77,12.15 55.48,12.86 55.48,14.62 ; v3(54.83,118.66) 55.71,118.66 56.22,119.16 56.22,128 46.94,137.28 46.94,142.9 45.16,144.68 45.16,148.94 47.41,151.19 v3(47.41,162.88) ; v3(57.02,45.75) 58.34,47.07 58.34,52.25 55.24,55.35 55.24,57.21 SLOT2.B10 ; v3(46.46,223.85) 43.43,223.85 41.61,225.68 40.41,225.68 v3(39.66,226.43) ; 54.57,14.95 54.57,17.25 SLOT4.B10
  TOP w1.016: 25.1,98.55 35.5,108.95 44.34,108.95 v3(44.86,109.47) ; 189.53,3.66 189.53,4.62 188.58,5.58 188.58,8.37 188.67,8.46
  TOP w1.778: 72.72,2.21 72.72,2.21 111.81,2.21
  TOP w2.286: 46.58,98.04 44.2,95.66 35.61,95.66 31.91,91.95 31.91,87.59 36.88,82.62
  TOP w3.81: 225.07,147.17 225.07,145.47 227.66,142.88 233.48,142.88
  BOTTOM w0.152: v1(168.6,40.97) 168.8,40.76 168.8,40.01 169.26,39.54 169.26,37.11 169.57,36.8 169.57,35.92 v1(169.44,35.79)
  BOTTOM w0.203: v1(180.01,38.86) 179.17,39.7 177.46,39.7 v1(175.34,41.82) ; v1(166.26,40.96) 166.07,41.14 166.07,43.15 165.62,43.6 165.62,44.12 165.34,44.41 164.81,44.41 164.08,43.68 163.32,43.68 v1(162.6,42.96)
  BOTTOM w0.254: v1(184.35,31.72) 183.92,31.72 183.08,30.89 179.71,30.89 178.87,30.05 v1(178.87,29.98) 178.59,29.7 178.59,29.23 177.9,28.54 175.88,28.54 v1(173.58,26.24) ; v1(162.48,25.13) 162.91,25.55 163.16,25.55 165.78,25.55 166.54,26.31 167.46,26.31 168.3,27.15 170.66,27.15 173.24,29.74 v1(173.24,30.04) ; v1(157.78,34.26) 157.96,34.26 160.29,36.6 v2(160.29,37.85) 160.29,38.64 161.52,39.87 v1(161.57,39.87) ; v1(140.59,42.24) 141.16,42.24 143.41,44.49 146.76,44.49 147.04,44.77 152.63,44.77 153.46,45.6 153.46,46.63 v1(152.08,48.01) ; v1(218.64,21.83) 218.45,22.02 v2(217.55,22.02) 217.12,22.02 215.54,20.45 214.33,20.45 v1(213.82,20.95) ; v1(210.77,232.26) 210.99,232.04 210.99,228.95 211.66,228.27 212.55,228.27 v1(213.36,227.46) ; v1(219.51,36.12) 219.51,35.61 218.29,34.39 218.29,28.19 216.56,26.47 216.56,25.6 214.28,23.33 v1(214.21,23.33) ; v1(227.38,66.6) 226.77,66.6 223.11,70.26 216.81,70.26 214.43,72.64 211.54,72.64 209.22,74.97 208.5,74.97 v1(208.08,75.39) ; v1(173.05,31.47) 172.92,31.47 172.39,32 172.39,33.1 v1(173.19,33.9) ; v1(208.31,92) 207.95,92.36 207.95,94.1 206.84,95.21 202.06,95.21 201.1,96.18 198.02,96.18 196.58,94.74 190.43,94.74 190.12,95.05 188.23,95.05 v1(187.68,94.5) ; v1(217.96,44.39) 218.07,44.5 218.07,45.34 217.79,45.62 217.17,45.62 216.26,46.53 216.26,46.89 v1(215.87,47.27) ; v1(166.26,40.96) 166.26,40.49 165.47,39.7 165.47,37.9 166.65,36.72 166.65,34.04 163.6,30.99 163.6,29.54 v1(163.07,29.01)
  BOTTOM w0.381: v1(59.03,112.82) 58.79,113.06 57.98,113.06 54.89,116.16 54.89,116.28 ; v1(179.71,9.69) v1(182.09,9.69) 184.46,9.69 185.14,10.36 187.35,10.36 188.21,9.5 v1(188.21,9.42)
  BOTTOM w0.406: v3(194.46,41.81) 194.97,41.81 196.44,43.28 v1(196.44,44.53)
  BOTTOM w0.457: v1(211.35,36.14) 211.35,37.8 211.02,38.13 211.02,38.86 211.02,38.86 211.02,39.92 209.2,41.74 209.17,41.74 208.34,42.57 208.34,44.56 v1(208.53,44.75)
  BOTTOM w0.508: v1(112.06,6.93) 107.48,6.93 105.84,5.29 v1(101.99,5.29) ; v3(46.46,223.85) 47.5,224.89 47.5,229.15 47.51,229.17 47.51,229.68 47.5,229.7 47.5,232.05 50.27,234.82 v1(51.82,234.82) ; v1(146.46,27.84) 146.04,27.42 v1(142.19,27.42) 138.37,27.42 137.74,26.8 137.72,26.8 135.05,24.13 v1(133.68,24.13) ; v1(52.7,127.07) 52.7,126.75 v1(52.02,126.06) ; v1(66.83,11.93) 66.69,12.08 61.65,12.08 61.19,11.61 59.41,11.61 58.85,12.17 54.61,12.17 v1(54.59,12.15) ; v1(220.75,230.48) 221.51,231.24 223.77,231.24 231.75,223.26 231.75,221.39 234.12,219.01 234.12,215.13 234.33,214.93 234.33,214.12 232.66,212.45 232.66,209.51 231.95,208.8 231.95,203.64 231.17,202.86 231.17,189.05 231.25,188.97 231.25,184.96 231.8,184.42 231.8,182.65 231.28,182.13 231.28,171.46 230.68,170.86 230.68,161.67 v1(229.11,160.1) ; v1(158.98,24.99) 159.12,25.13 v1(162.48,25.13) ; v1(221.3,223.22) 221.3,221.88 220.7,221.28 220.7,211.92 220.7,211.57 222.66,209.62 222.66,191.3 222.66,191.3 222.66,190.23 221.77,189.34 221.77,189.18 221.77,178.88 221.23,178.34 221.23,172.99 220.55,172.31 220.55,159.99 v1(219.25,158.7) ; v1(135.76,91.9) v1(135.76,90.04)
  BOTTOM w0.635: SLOT3.B10 53.98,37.69 52.92,38.74 52,38.74 51.89,38.64 51,38.64 50.89,38.74 49.95,38.74 49.84,38.64 48.99,38.64 48.89,38.74 48.01,38.74 47.9,38.64 46.99,38.64 46.89,38.74 45.99,38.74 45.89,38.64 45.01,38.64 v3(41.83,41.81) ; v3(41.73,69.39) 45.29,65.84 v3(57.3,65.84) ; v3(195.81,39.75) 195.12,39.07 195.12,37.69 193.62,36.2 191.59,36.2 v3(191.16,35.76) ; v3(190.86,42.11) 193.09,42.11 193.4,41.81 v3(194.46,41.81)
  BOTTOM w0.762: v3(34.59,228.68) 38.86,228.68 39.66,227.88 v3(39.66,226.43) ; v3(47.41,162.88) 47.41,171.8 44.78,174.43 44.78,180.11 45.39,180.72 45.39,180.8 45.4,180.81 45.4,193.97 45.42,193.98 45.42,204.89 46.51,205.98 46.51,206.09 46.52,206.1 46.52,223.79 v3(46.46,223.85) ; v3(195.81,39.75) 201.98,39.75
  BOTTOM w0.889: v3(41.53,48.64) 44.42,45.75 v3(57.02,45.75)
  BOTTOM w1.016: 23.95,114.55 23.95,112.75 23.85,112.65 23.85,107.26 ; 24.23,99.34 23.85,99.72 23.85,105.79
  BOTTOM w1.27: 135,2.18 P217.2
  BOTTOM w1.778: 144.09,2.18 113.28,2.18 ; 191.11,2.18 154.66,2.18
  BOTTOM w2.286: 45.59,110.11 45.85,109.86 45.85,98.3 46.46,97.69 ; 233.65,2.51 193.65,2.51 ; 233.73,85.93 230.71,82.91 230.71,77.24 234.92,73.03 237.16,73.03 v1(239.01,71.17) 241.4,68.78 241.4,4.75 239.17,2.51 238.51,2.51 ; 241.32,96.14 241.32,144.2
  vias: v1(23.85,106.4) v1(23.93,105.64) v1(23.98,115.7) v1(24.28,98.7) v1(24.36,97.94) v1(24.59,115.27) v1(36.98,80.9) v1(36.98,80.14) v1(36.98,79.38) v1(37.72,80.87) v1(37.72,80.11) v1(37.72,79.38) v1(38.32,74.15) v1(38.32,73.38) v1(38.32,72.62) v1(38.32,71.86) v1(38.32,71.1) v1(45.54,97.54) v1(46.13,96.9) v1(46.15,98.17) v1(46.74,97.54) v1(189.38,3.63) v1(190.14,3.66) v1(202.84,39.04) v1(202.82,38.23) v1(202.87,39.8) v3(43.94,2.62) v3(44.83,2.62) v3(45.72,2.62) v3(47.09,113.39) v3(47.52,114.25) v3(48.01,113.41) v3(53.06,117.17) v3(111.23,2.72) v3(111.18,1.8) v3(111.99,2.21) v3(238.51,144.78) v3(238.51,143.89) v3(239.4,144.78) v3(239.4,143.89) v3(240.28,144.78) v3(240.28,143.89)
+BAT_R: length 3.9
  TOP w0.254: v1(133.37,64.58) D20.2
  TOP w0.508: SR100.2 135.4,64.44 135.26,64.58 D20.2
  BOTTOM w0.508: v2(132.57,64.58) v1(133.37,64.58)
+BATT: length 200.5
  TOP w0.178: O2CB7.1 217.93,22.83 216.94,23.83 U104.21
  TOP w0.203: v1(169.65,40.39) 169.92,40.66 169.92,41.1 PCH.BC22
  TOP w0.254: v1(208.78,33.21) 212.89,33.21 213.27,32.83 215.42,32.83 215.64,33.05 217.75,33.05 v1(218.85,34.14) ; v1(155.52,29.04) 156.13,29.04 SR364.1 ; v1(154.47,28.8) SR101.1 SR102.1
  TOP w0.305: O2CB7.1 218.35,22.52 219.07,23.24 v1(219.07,23.5) ; v1(170.21,28.88) 170.21,28.27 170.98,27.5 SCB35.1 170.98,24.4 SCB29.1 171.15,23.85 171.35,23.65 172.31,23.65 172.87,23.09 v1(172.87,22.16)
  TOP w0.508: v1(149.72,26.91) 151.22,25.41 151.39,25.41 155.9,20.9 v1(157.18,20.9) 157.41,20.67 171.79,20.67 172.87,21.75 v1(172.87,22.16) ; v1(147.89,19.17) 147.89,19.2 132.8,34.29 132.8,41.01 127.15,46.66 123.24,46.66 122.73,47.17 122.73,59.98 123.34,60.58 130.22,60.58 131.77,62.14 SC101.1 132.48,62.34 D20.3
  BOTTOM w0.203: v1(169.65,40.39) 169.91,40.12 169.91,37.38 171.02,36.27 171.02,33.14 170.82,32.94 170.82,31.07 170.54,30.78 170.54,29.21 v1(170.21,28.88)
  BOTTOM w0.254: v1(219.07,23.5) 219.07,23.85 220.27,25.04 220.27,26.77 v2(219.12,27.92) 218.85,28.19 v1(218.85,34.14) ; v1(208.78,33.21) 208.67,33.21 206.63,31.17 204.7,31.17 203.45,29.92 201.74,29.92 200.2,28.38 199.34,28.38 196.89,25.93 191.26,25.93 190.77,25.44 181.96,25.44 179.9,23.38 177.18,23.38 175.95,22.16 v1(172.87,22.16) ; v1(149.72,26.91) 150.61,27.8 152.29,27.8 153.29,28.8 v1(154.47,28.8) 154.53,28.8 154.77,29.04 v1(155.52,29.04)
  BOTTOM w0.508: v1(157.18,20.9) 156.25,19.98 154.88,19.98 154.08,19.17 v1(147.89,19.17)
+CPUIO_DRV_D: length 3.9
  TOP w0.635: PU5.5 v1(129.44,96.57) 130.12,97.26 130.12,98.04
  BOTTOM w0.635: v1(129.44,96.57) 129.82,96.19 v2(129.82,95.83)
+CPUIO_DRVR_D: length 0.9
  BOTTOM w0.635: v2(127.47,100.88) v1(126.82,101.52)
+CPUIO_FB_A: length 15.8
  TOP w0.254: PC155.2 131.74,98.62 131.83,98.53 PC158.2 v1(132.63,98.08) ; PR132.2 PC160.2 PR133.1 PR312.1 126.95,98.25 126.79,98.09 126.79,96.33 v1(126.52,96.06) 126.08,95.62 PU5.3
  BOTTOM w0.254: v1(126.52,96.06) 127.58,97.13 129.64,97.13 130.59,98.08 v2(130.61,98.08) v1(132.63,98.08)
+CPUIO_FBR_A: length 4.4
  TOP w0.254: v1(123.53,99.24) 123.71,99.24 PR132.1 ; PR132.1 PC160.1 ; PR132.1 124.21,100.18 124.18,100.2 PR130.2 PR313.1
  BOTTOM w0.254: v2(124.16,99.85) 124.14,99.85 v1(123.53,99.24)
+CPUIO_RC1: length 2.4
  TOP w0.457: v1(132.51,97.24) PC158.1 PR128.2
  BOTTOM w0.508: v2(131.97,96.7) v1(132.51,97.24)
+CPUIO_RC2: length 1.2
  BOTTOM w0.508: v2(131.22,100.76) v1(132.38,100.76)
+CPUIO_SS: length 3.4
  TOP w0.508: PC154.1 129.03,95.63 129.02,95.62 PU5.4 v1(127.21,95.62)
  BOTTOM w0.508: v1(127.21,95.62) 127.93,96.34 v2(127.97,96.34)
+USB_TYPEC: length 10.3
  TOP w0.254: v1(8.44,147.98) 8.25,147.78 6.92,147.78 6.81,147.68 J_TYPEC.A4 J_TYPEC.B9 ; v1(7.77,145.11) 7.09,145.11 7.02,145.18 J_TYPEC.A9 J_TYPEC.B4
  TOP w0.508: v1(7.77,145.11) 7.95,145.11 v1(8.41,145.57)
  TOP w0.635: TUCE1.1 24.97,160.73 ; TUCE1.1 24.11,159.87 ; TUCE1.1 25.84,159.87 ; TUCE1.1 24.97,159
  vias: v1(9.18,147.98) v1(12.65,155.52) v1(12.7,154.76) v1(13.39,155.52) v1(13.44,154.76) v2(9.19,152.68)
+VCORE: length 110.2
  TOP w0.254: PR621.2 v1(81.55,206.77) ; v1(112.21,177.2) XU1.F37
  TOP w0.305: v1(133.17,156.16) 133.63,156.62 XU1.AJ14 ; XU1.AJ13 133.63,155.7 v1(133.17,155.24) 133.63,154.79 XU1.AJ12 ; v1(133.17,153.44) 133.6,153.87 XU1.AJ11
  TOP w0.889: 90.13,163.85 PCE6203.1 ; PCE6203.1 91.07,164.79 ; PCE6203.1 90.13,165.73 ; PCE6203.1 89.2,164.79 ; 75.77,160.69 PL601.2 ; PL601.2 74.95,163.49 ; PL601.2 73.64,161.58 ; PL601.2 77.08,162.59 ; PL592.2 75.77,195.89 ; PL592.2 74.95,198.69 ; PL592.2 77.08,197.8 ; PCE6204.1 90.13,157.56 ; PCE6204.1 91.07,156.62 ; PCE6204.1 89.2,156.62 ; PCE6204.1 90.13,155.68 ; 91.07,172.97 PCE6202.1 ; PCE6202.1 90.13,173.91 ; PCE6202.1 90.13,172.03 ; PCE6202.1 89.2,172.97 ; 84.38,176.8 PCE6205.1 ; PCE6205.1 83.44,175.86 ; PCE6205.1 83.44,177.74 ; PCE6205.1 82.5,176.8 ; PCE6201.1 90.13,181.7 ; PCE6201.1 91.07,180.76 ; PCE6201.1 90.13,179.82 ; PCE6201.1 89.2,180.76 ; 77.2,146.01 PL602.2 ; PL602.2 75.07,146.9 ; PL602.2 75.9,144.1 ; PCE6211.1 83.44,161.74 ; PCE6211.1 84.38,160.8 ; PCE6211.1 82.5,160.8 ; PCE6211.1 83.44,159.86 ; PL591.2 75.77,178.29 ; PL591.2 74.95,181.09 ; PL591.2 77.08,180.19
  BOTTOM w0.254: v1(81.55,206.77) 81.55,205.47 83.79,203.23 83.79,202.26 83.44,201.91 83.44,184.78 86.51,181.71 89.18,181.71 PCE6201.1
  BOTTOM w0.889: 75.92,144.01 PL602.2 ; PL602.2 77.29,146.03 ; PL602.2 75.05,146.99 ; PL602.2 73.68,144.97 ; 84.47,160.8 PCE6211.1 ; PCE6211.1 83.44,161.83 ; PCE6211.1 82.41,160.8 ; PCE6211.1 83.44,159.77 ; 90.13,155.59 PCE6204.1 ; PCE6204.1 91.16,156.62 ; PCE6204.1 89.11,156.62 ; PCE6204.1 90.13,157.65 ; 84.47,176.8 PCE6205.1 ; PCE6205.1 83.44,175.78 ; PCE6205.1 82.41,176.8 ; PCE6205.1 83.44,177.83 ; 91.09,181.71 PCE6201.1 ; PCE6201.1 91.09,179.8 ; PCE6201.1 89.18,179.8 ; PCE6203.1 90.13,163.77 ; PCE6203.1 89.11,164.79 ; PCE6203.1 91.16,164.79 ; PCE6203.1 90.13,165.82 ; PCE6202.1 90.13,174 ; PCE6202.1 90.13,171.94 ; PCE6202.1 89.11,172.97 ; PCE6202.1 91.16,172.97
  vias: v1(104.88,179.01) v1(104.88,177.18) v1(104.88,175.36) v1(104.88,173.53) v1(104.88,171.97) v1(104.88,170.42) v1(104.88,168.59) v1(104.88,166.76) v1(104.88,164.93) v1(105.97,176.28) v1(106.71,177.18) v1(106.71,175.36) v1(106.71,173.53) v1(106.71,171.97) v1(106.71,170.42) v1(106.71,168.59) v1(106.71,166.76) v1(106.71,164.93) v1(107.62,168.58) v1(107.59,166.75) v1(107.62,164.92) v1(108.43,174.42) v1(108.46,172.67) v1(108.54,171.7) v1(108.54,170.42) v1(108.54,168.59) v1(108.54,166.76) v1(108.54,164.93) v1(108.56,176.3) v1(109.45,177.14) v1(109.42,176.25) v1(109.45,174.45) v1(109.45,172.62) v1(109.45,168.58) v1(109.45,166.75) v1(109.45,164.92) v1(110.06,171.05) v1(110.36,177.16) v1(110.36,176.28) v1(110.37,174.37) v1(110.39,172.64) v1(110.37,170.42) v1(110.37,168.59) v1(110.37,166.76) v1(110.37,164.93) v1(110.77,171.04) v1(111.28,176.28) v1(111.28,174.45) v1(111.28,172.62) v1(111.28,168.58) v1(111.28,166.75) v1(111.3,164.92) v1(111.28,163.12) v1(111.84,171.2) v1(112.19,174.45) v1(112.18,172.57) v1(112.2,170.42) v1(112.2,168.59) v1(112.2,166.76) v1(112.2,164.93) v1(112.2,163.1) v1(112.55,171.17) v1(113.12,175.35) v1(113.08,174.42) v1(113.11,172.62) v1(113.11,168.58) v1(113.13,166.75) v1(113.13,164.95) v1(113.11,163.08) v1(114.02,172.62) v1(114.02,170.42) v1(114.02,168.59) v1(114.02,166.76) v1(114.02,164.93) v1(114.02,163.1) v1(114.02,161.26) v1(114.92,174.46) v1(114.94,173.53) v1(114.94,172.59) v1(114.94,168.58) v1(114.94,166.75) v1(114.91,164.92) v1(114.94,163.11) v1(114.94,161.26) v1(114.96,170.66) v1(115.42,171.15) v1(115.84,175.38) v1(115.84,173.55) v1(115.8,169.88) v1(115.85,161.34) v1(115.85,156.7) v1(115.85,174.45) v1(115.85,168.59) v1(115.85,166.76) v1(115.85,164.93) v1(115.85,163.1) v1(115.87,159.46) v1(116.13,171.17) v1(116.74,155.82) v1(116.77,174.45) v1(116.78,172.61) v1(116.76,168.58) v1(116.76,166.75) v1(116.76,164.95) v1(116.76,163.09) v1(116.76,161.34) v1(116.77,159.44) v1(117.68,173.53) v1(117.69,171.69) v1(117.83,156.46) v1(117.75,154.03) v1(118.75,168.91) v1(118.75,168.25) v1(118.75,167.56) v1(118.75,166.9) v1(118.87,165.1) v1(118.87,163.45) v1(119.51,165.1) v1(119.51,163.45) v1(119.66,159.13) v1(120.29,159.13) v1(120.78,165.1) v1(120.78,163.45) v1(121.11,159.13) v1(121.41,165.1) v1(121.41,163.45) v1(121.74,159.13) v1(122.56,163.45) v1(122.81,161.93) v1(122.81,160.53) v1(122.81,159.13) v1(123.19,163.45) v1(123.95,157.48) v1(124.33,163.45) v1(124.59,157.48) v1(124.97,163.45) v1(125.73,157.48) v1(125.98,163.45) v1(126.36,157.48) v1(126.62,163.45) v1(127.51,157.48) v1(127.64,163.45) v1(128.14,157.48) v1(128.27,163.45) v1(128.52,161.93) v1(128.52,160.53) v1(128.52,159.13) v1(129.29,157.48) v1(129.41,163.45) v1(129.92,157.48) v1(130.05,163.45) v1(130.94,163.45) v1(131.19,157.48) v1(131.57,163.45) v1(133.1,163.6) v1(133.1,162.56) v1(133.25,169.85) v1(133.25,168.94) v1(133.25,168.05) v1(133.25,167.13) v1(133.17,161.62) v1(133.17,160.76) v1(133.17,159.82) v1(133.17,158.93) v1(133.17,158.01) v3(73.79,160.02) v3(74.04,142.62) v3(74.3,194.18) v3(74.42,157.48) v3(74.55,177.55) v3(74.63,174.98) v3(74.68,199.39) v3(74.83,169.62) v3(74.75,167.59) v3(74.93,192.79) v3(74.96,171.37) v3(76.23,151.26) v3(76.43,147.93) v3(76.45,164.47) v3(76.45,141.1) v3(76.96,181.74) v3(77.17,155.07) v3(77.72,152.78) v3(78.23,149.86) v3(78.87,145.29) v3(79.76,141.6) v3(81.92,164.97) v3(82.07,172.97) v3(82.07,170.31) v3(82.07,150.75) v3(82.3,168.4) v3(82.3,157.35) v3(82.42,151.64) v3(82.93,154.56) v3(82.93,145.54) v3(84.2,150.5) v3(84.33,144.78) v3(84.58,175.13) v3(84.58,156.97) v3(84.71,171.83) v3(84.71,167.77) v3(85.72,163.7) v3(86.11,147.83) v3(86.49,154.43) v3(86.69,192.43) v3(87,159.26) v3(87.76,170.31) v3(88.27,167.26) v3(88.27,151.51) v3(88.65,185.04) v3(88.93,189.51) v3(89.09,149.54) v3(89.94,192.89) v3(90.04,162.28) v3(90.17,186.69) v3(90.22,176.81) v3(90.17,170.81) v3(92.63,187.22) v3(92.96,192.41) v3(93.22,158.37) v3(93.34,184.28) v3(93.4,167.13) v3(93.47,181.25) v3(93.65,176.78) v3(93.65,172.03) v3(93.73,162.1) v3(94.23,189.36) v3(95.48,181.13) v3(95.76,186.56) v3(96.04,176.68) v3(96.24,167.06) v3(96.16,162.31) v3(96.49,171.96) v3(96.9,183.13) v3(97.7,187.92) v3(98.3,185.67) v3(98.68,180.59) v3(99.03,176.68) v3(99.03,162.56) v3(99.31,172.09) v3(99.42,167.06) v3(99.82,182.75) v3(101.35,176.71) v3(101.35,172.21) v3(101.35,167.26) v3(102.74,181.86) v3(102.87,179.45) v3(102.87,164.97) v3(103,172.09) v3(103.12,167.51)
+VCORE_SENSE+_A: length 44.1
  TOP w0.254: v1(82.38,206.74) PR621.1 82.38,210.12 82.02,210.49 PR5844.1
  BOTTOM w0.254: v1(82.38,206.74) v2(83.16,205.97) 84.48,204.65 88.2,204.65 93.22,199.63 93.22,194.17 107.05,180.34 107.47,180.34 PJP621.1
+VCORE_SENSE-_A: length 47.3
  TOP w0.203: PU581.13 80.64,215.39
  TOP w0.254: 80.64,215.39 80.64,215.32 82.97,212.99 PC5819.2 82.97,212.33 82.93,212.29 PC5815.1 83.52,211.16 83.52,209.55 83.25,209.28 PR622.1 v1(83.25,206.73)
  BOTTOM w0.254: v1(83.25,206.73) v2(84.73,206.73) 84.87,206.73 86.5,205.1 88.27,205.1 93.68,199.69 93.68,194.24 105.93,181.98 PJP622.1
+VTT_DDR: length 9.2
  TOP w0.305: D4CB1.1 174.39,165.26 D4CB2.1 175.09,165.65 CON_XMM3.77
  BOTTOM w0.762: v3(206.83,163.4) v2(207.84,162.39) 207.95,162.28 207.95,158.55 v3(208.71,157.78)
+VTT_DDR_REF: length 17.8
  TOP w0.102: v1(212.24,158.01) 211.91,158.01 211.2,157.3 211.2,156.21 211,156.01 210.62,156.01 210.54,155.93 210.54,155.08 PR125.2 PR126.1 PC485.1 209.14,154.1 208.91,153.87 PU80.3 ; PQ80.3 v1(217.91,154.66)
  BOTTOM w0.102: v1(212.24,158.01) 213.21,158.01 v2(213.9,157.33) 215.11,156.11 215.11,154.88 215.95,154.05 217.29,154.05 v1(217.91,154.66)
A1142_CLKREQ#: length 12.3
  TOP w0.102: SR749.1 172.17,32.3 171.55,32.91 171.55,34.54 171.98,34.98 v1(171.98,35.41) ; PCH.BA19 169.33,42 v1(169.72,42.39)
  BOTTOM w0.089: 171.28,38.34 v2(171.05,38.56) 170.34,39.28 170.34,40.59 170.15,40.77 170.15,41.96 v1(169.72,42.39)
  BOTTOM w0.102: 171.28,38.34 171.98,37.63 v1(171.98,35.41)
ALL_SYS_PWRGD: length 3.5
  TOP w0.102: ECR90.2 PR70238.1 v1(124.64,92.75) 124.66,92.75 125.01,93.09 ECQ12.3
  BOTTOM w0.102: v1(124.64,92.75) 124.9,92.75 v2(125.3,92.35)
AQ11_B: length 3.1
  TOP w0.102: AR50.2 21.68,22.59 v1(22.1,23.01) 21.87,23.24 AQ11.1
  BOTTOM w0.102: v2(22.07,24.03) 22.07,23.04 v1(22.1,23.01)
AQ13_B: length 17.6
  TOP w0.254: v1(26.09,24.11) AQ13.1 AQ11.2 23.77,22.67 AR53.2 ; AQ23.2 v1(30.41,20.08)
  BOTTOM w0.102: v2(25.27,24.69) 25.5,24.69 v1(26.09,24.11)
  BOTTOM w0.254: v1(26.09,24.11) 27.66,24.11 30.41,21.35 v1(30.41,20.08)
AQ13_E: length 3.5
  TOP w0.102: AR1.1 26.7,22.48 v1(26.14,23.04) 26.97,23.87 AQ13.2
  BOTTOM w0.102: v1(26.14,23.04) 25.7,22.61 v2(25.35,22.61)
AQ14_B: length 4.4
  TOP w0.254: v1(26.57,27.3) AQ14.1 27.71,28.08 AR56.1 AR55.2
  BOTTOM w0.254: v2(27.36,26.85) 27.03,26.85 v1(26.57,27.3)
ASM1142_RXN: length 203
  TOP w0.102: v1(167.25,59.72) 167.25,59.65 167.39,59.51 167.54,59.51 167.72,59.7 PCH.E17 ; UC944.2 37.64,135.06 37.64,134.99 37.91,134.72 39.71,134.72 40.28,134.15 40.28,133.15 40.56,132.87 41.11,132.87 41.22,132.98 41.22,133.12 v1(41.01,133.34)
  BOTTOM w0.089: 168.47,61.99 168.64,61.82 168.64,59.3 168.4,59.06 167.78,59.06 167.69,59.15 167.69,59.72 167.56,59.85 167.37,59.85 v1(167.25,59.72)
  BOTTOM w0.102: v1(41.01,133.34) 41.22,133.12 41.22,132.45 44.12,129.55 44.12,120.75 44.6,120.27 44.6,116.93 46.02,115.52 47.92,115.52 48.87,114.57 48.87,99.16 51.36,96.67 51.36,84.18 50.43,83.25 50.43,79.91 51.33,79.01 51.33,77.61 53.79,75.15 73.6,75.15 79.07,69.68 135.77,69.68 139.84,73.75 159.73,73.75 162.92,70.56 162.92,69.99 ; 162.92,69.99 v2(162.62,69.99) ; 162.92,69.99 162.92,67.54 168.47,61.99
ASM1142_RXN_C: length 4.3
  TOP w0.102: UC944.1 37.63,136.68 37.63,137.49 37.44,137.68 37.44,138.68 36.91,139.22 36.91,139.47 37.02,139.58 U4.57
ASM1142_RXP: length 203
  TOP w0.102: PCH.G17 167.41,58.93 v1(167.18,58.93) ; UC943.2 37.44,135.12 37.44,134.9 37.82,134.52 39.62,134.52 40.08,134.06 40.08,133.06 40.48,132.66 41.2,132.66 41.43,132.89 41.43,133.12 v1(41.64,133.34)
  BOTTOM w0.089: v1(167.18,58.93) 167.66,58.93 167.71,58.88 168.47,58.88 168.81,59.23 168.81,61.93 168.67,62.07
  BOTTOM w0.102: v2(163.41,68.33) 163.12,68.33 ; 163.12,68.33 163.12,70.65 159.81,73.95 139.76,73.95 135.69,69.88 79.16,69.88 73.68,75.36 53.88,75.36 51.54,77.7 51.54,79.09 50.64,79.99 50.64,83.17 51.56,84.09 51.56,96.76 49.08,99.24 49.08,114.65 48.01,115.72 46.1,115.72 44.81,117.02 44.81,120.36 44.33,120.83 44.33,129.63 41.43,132.53 41.43,133.12 v1(41.64,133.34) ; 163.12,68.33 163.12,67.62 168.67,62.07
ASM1142_RXP_C: length 4.3
  TOP w0.102: U4.56 36.52,139.61 36.7,139.42 36.7,139.13 37.24,138.6 37.24,137.59 37.43,137.4 37.43,136.6 UC943.1
ASM1142_SMI#: length 304.3
  TOP w0.102: v1(141.51,31.41) 142.06,30.87 142.06,28.78 144.8,26.04 147.04,26.04 147.5,25.59 147.5,25.07 150.51,22.06 v1(150.82,22.06) ; v1(33.3,73.91) 34.3,72.91 34.3,60.94 30.84,57.48 30.38,57.48 25.72,52.82 v1(25.72,39.6) ; v1(163.26,45.14) 163.26,45.14 PCH.AP7 ; v1(35.33,132.69) 35.76,132.69 36.3,132.16 42.47,132.16 42.71,132.39 42.71,134.89 43.4,135.57 43.4,138.79 UR69695.2 42.79,139.4 42.39,139.4 41.78,140 41.78,140.87 41.53,141.13 U4.2
  BOTTOM w0.102: v1(33.3,73.91) 32.21,75.01 32.21,100.28 33.66,101.73 33.66,118.88 32.12,120.41 32.12,132.22 32.59,132.69 v1(35.33,132.69) ; v1(150.82,22.06) 150.13,21.37 143.28,21.37 142.08,20.17 135.01,20.17 132.81,17.97 130.88,17.97 129.47,16.56 89.35,16.56 88.92,16.13 42.18,16.13 41.33,16.98 41.33,17.37 28.88,29.82 v2(28.88,35.74) 28.88,36.44 v1(25.72,39.6) ; v1(163.26,45.14) 162.74,45.14 162.18,44.58 161.25,44.58 161.21,44.54 159.27,44.54 154.64,39.9 152.6,39.9 146.62,33.93 144.03,33.93 v1(141.51,31.41)
ASM1142_TXN: length 202
  TOP w0.089: 168.45,62.49 168.75,62.2 168.78,62.08 168.78,61.85 168.77,61.8 168.64,61.71 168.55,61.62 168.55,61.49 PCH.B19
  TOP w0.102: v1(38.3,133.53) 38.73,133.1 38.73,132.98 38.67,132.91 36.79,132.91 35.69,134.01 35.69,134.39 35.81,134.52 36,134.52 UC87.2 ; v1(160.65,71.11) 160.83,71.3 160.83,71.42 161.05,71.64 161.54,71.64 162.72,70.46 165.07,70.46 168.45,67.07 168.45,66.71 168.45,66.71 168.45,62.49
  BOTTOM w0.102: v2(147.62,72.77) 147.62,73.06 ; 147.62,73.06 158.8,73.06 160.22,71.64 160.22,71.54 v1(160.65,71.11) ; 147.62,73.06 146.2,73.06 145.42,72.29 139.45,72.29 136.16,68.99 78.77,68.99 73.3,74.46 48.51,74.46 44.24,78.73 44.24,95.94 43.76,96.41 43.76,120.11 43.4,120.48 43.4,128.85 39.55,132.7 39.13,132.7 v1(38.3,133.53)
ASM1142_TXN_C: length 4.9
  TOP w0.102: UC87.1 35.86,135.88 35.86,136.63 35.36,137.13 35.36,139.42 35.52,139.58 U4.54
ASM1142_TXP: length 202
  TOP w0.089: 168.84,62.39 168.93,62.25 168.95,62.13 168.96,62.1 168.96,61.82 168.9,61.65 168.88,61.34 168.88,61.15 PCH.C19
  TOP w0.102: v1(38.94,133.53) 38.94,132.89 38.75,132.7 36.71,132.7 35.48,133.93 35.48,134.51 UC86.2 ; 168.84,62.39 168.66,62.58 168.66,66.71 168.66,67.16 165.15,70.66 162.8,70.66 161.62,71.84 v1(160.67,71.84)
  BOTTOM w0.102: v1(38.94,133.53) 38.94,133.18 39.22,132.9 39.63,132.9 43.6,128.93 43.6,120.57 43.97,120.2 43.97,96.5 44.44,96.02 44.44,78.81 48.59,74.66 73.39,74.66 78.85,69.2 136.07,69.2 139.37,72.49 143.59,72.49 ; v1(160.67,71.84) 160.31,71.84 158.88,73.27 146.11,73.27 145.34,72.49 143.59,72.49 ; 143.59,72.49 v2(143.59,72.78)
ASM1142_TXP_C: length 4.9
  TOP w0.102: UC86.1 35.66,135.93 35.66,136.54 35.15,137.05 35.15,139.44 35.02,139.58 U4.53
ATX_PWRGD: length 193.9
  TOP w0.102: P1R4.2 230.72,169.51 231.17,169.95 231.52,169.95 231.52,169.95 v1(231.52,169.95) ; v1(219.94,29.72) 210.87,29.72 209.59,28.44 U104.123 206.57,28.44 206.36,28.24 206.36,28.13 205.85,27.62 205.19,27.62 205.02,27.79 O2CB12.1 ; v1(223.15,43.43) 223.75,42.84 223.75,42.14 225.21,40.68 225.51,40.68 228.45,37.74 228.6,37.74 228.61,37.74 v1(237.39,37.74)
  BOTTOM w0.102: v1(237.39,37.74) 237.62,37.97 237.62,40.03 235.1,42.54 235.1,53.4 237.51,55.81 237.51,57.89 233.01,62.39 233.01,67.54 227.5,73.05 227.5,86.07 228.67,87.24 230.1,87.24 231.05,88.19 231.05,89.38 234.95,93.28 234.95,136.85 233.37,138.44 v2(233.37,139.3) 233.37,148.78 231.52,150.63 v1(231.52,169.95) ; v1(219.94,29.72) 219.68,29.97 219.68,34.07 220.42,34.81 220.42,36.5 221.22,37.31 221.22,41.51 v1(223.15,43.43)
ATX_PWRGD_PWRCORD: length 190.8
  TOP w0.102: v1(229.84,135.53) v1(231.57,137.26) ; PR115.1 138.18,92.2 138.81,92.84 138.81,92.84 140.59,94.61 140.59,95.93 143.47,98.81 152.5,98.81 152.71,98.59 153.2,98.59 153.92,99.31 v1(156.39,99.31) ; v1(218.24,101.52) 218.19,101.57 214.9,101.57 213.51,100.19 213.51,97.63 211.46,95.58 211.06,95.58 209.68,94.2 v1(209.68,92.79) ; v1(230.17,159.05) 230.61,159.49 230.61,161.33 229.54,162.39 229.54,163.19 229.34,163.4 229.34,167.55 229.74,167.96 229.74,168.19 P1R1.2 230.92,168.69 232.08,169.85 232.08,170.23 231.75,170.56 230.76,170.56 230.54,170.35 P1R4.1 EC22.1 230.71,171.32 231.29,171.91 231.29,179.66 CON4.8
  BOTTOM w0.102: v1(231.57,137.26) 232.65,138.34 232.65,140.04 232.91,140.3 232.91,148.63 230.57,150.97 230.57,158.66 v1(230.17,159.05) ; v1(156.39,99.31) 169.3,99.31 173.36,95.26 184.37,95.26 185.07,95.96 190.5,95.96 190.81,95.65 196.2,95.65 197.88,97.33 200.36,97.33 202.18,95.5 206.96,95.5 v1(209.68,92.79) ; v1(218.24,101.52) 218.45,101.74 218.45,106.06 218.47,106.07 218.47,106.2 220.45,108.18 220.45,110.82 220,111.26 220,118.7 222.63,121.32 222.63,124.5 220.92,126.21 220.92,128.49 227.96,135.53 v2(228.42,135.53) v1(229.84,135.53)
AZ_BITCLK: length 150.2
  TOP w0.102: v1(22.45,14.76) 23.1,14.76 AC22.1 22.74,15.32 AU1.6 ; v1(26.95,18.97) 27.3,19.33 28.36,19.33 34.71,25.68 34.71,30.95 v1(35.11,31.36) ; v1(144.6,33.17) 145.8,34.37 147.29,34.37 148.36,35.43 SC81.1 149.1,36.16 152.35,36.16 SR243.1
  BOTTOM w0.102: v1(144.6,33.17) 144.6,32.96 142.1,30.45 133.63,30.45 131.36,28.18 130.29,28.18 129.66,27.56 120.81,27.56 120.55,27.29 120.18,26.92 98.62,26.92 97.83,27.71 38.73,27.71 v1(35.11,31.36) ; v1(22.45,14.76) 23.09,15.4 23.09,15.62 v2(25.85,18.37) 26.45,18.97 v1(26.95,18.97)
AZ_RST#: length 152.7
  TOP w0.102: SR244.1 SC80.1 151.46,34.96 150.15,34.96 149.28,34.09 146.18,34.09 v1(145.29,33.2) ; v1(27.99,18.85) 28.2,18.85 35.18,25.82 v1(35.18,30.61) ; AU1.11 19.49,17.82 19.38,17.93 19.38,18.46 19.61,18.69 19.89,18.69 21.11,19.91 21.11,21.53 AR50.1 21.69,22.11 v1(22.22,22.11)
  BOTTOM w0.102: v1(22.22,22.11) v2(22.99,22.11) 23.66,22.11 24.7,21.07 27.62,21.07 27.99,20.7 v1(27.99,18.85) ; v1(35.18,30.61) 38.3,27.48 97.74,27.48 98.53,26.7 120.27,26.7 120.78,27.2 120.91,27.33 129.76,27.33 130.38,27.95 131.46,27.95 133.73,30.23 142.32,30.23 v1(145.29,33.2)
AZ_SDATA_IN0: length 160
  TOP w0.102: v1(27.36,20.51) 28.58,20.51 34.02,25.96 34.02,31.38 v1(33.54,31.87) ; PCH.BA2 160.8,42.52 160.94,42.52 v1(160.95,42.53) ; AR2.1 v1(24.87,16) ; v1(149.1,35.43) 149.57,35.9 154.6,35.9 156.03,37.34 v1(157.48,37.34)
  BOTTOM w0.102: v1(149.1,35.43) 146.38,32.72 145.77,32.72 142.82,29.77 134.06,29.77 131.16,26.87 121.1,26.87 120.46,26.24 98.24,26.24 97.45,27.03 37.77,27.03 34.09,30.7 34.09,31.31 v1(33.54,31.87) ; v1(160.95,42.53) 160.66,42.53 157.48,39.35 v1(157.48,37.34) ; v1(24.87,16) 27.43,18.56 v2(27.43,19.74) 27.43,20.45 v1(27.36,20.51)
AZ_SDATA_IN_R: length 4.4
  TOP w0.102: AU1.8 21.93,16.32 22.05,16.43 v1(22.3,16.43) 22.77,16.43 AR2.2
  BOTTOM w0.102: v1(22.3,16.43) 21.77,16.97 v2(21.16,16.97)
AZ_SDATA_OUT: length 150.4
  TOP w0.102: v1(26.2,19.55) 26.26,19.61 28.32,19.61 34.48,25.77 34.48,32.19 v1(35.13,32.84) ; v1(143.97,32.92) 143.97,35.44 145.53,37.01 149.47,37.01 SC83.1 150.66,36.58 SR241.1 ; AU1.5 v1(21.59,14.82)
  BOTTOM w0.102: v1(26.2,19.55) 22.96,16.31 22.96,16.08 v2(22.45,15.57) 22.34,15.57 v1(21.59,14.82) ; v1(35.13,32.84) 40.03,27.94 97.97,27.94 98.76,27.15 120.08,27.15 120.72,27.79 129.57,27.79 130.19,28.41 131.26,28.41 133.53,30.68 141.75,30.68 143.97,32.9 v1(143.97,32.92)
AZ_SYNC: length 150.4
  TOP w0.102: v1(22.35,17.58) 21.68,17.58 21.43,17.32 AU1.10 ; v1(25.44,19.59) 25.87,20.02 28.41,20.02 34.25,25.87 34.25,32.03 v1(33.54,32.75) ; SR242.1 SC82.1 151.3,33.86 146.58,33.86 v1(145.92,33.2)
  BOTTOM w0.102: v1(33.54,32.75) 34.34,31.95 34.34,30.78 37.87,27.25 97.54,27.25 98.33,26.47 120.37,26.47 121,27.1 131.07,27.1 133.96,30 142.72,30 v1(145.92,33.2) ; v1(22.35,17.58) v2(23.16,17.58) 23.43,17.58 v1(25.44,19.59)
BAT: length 57.9
  TOP w0.508: v1(142.34,65.28) v1(142.34,67.28) ; v1(153.59,87.44) 153.59,85.5 153.34,85.24 153.34,81.92 149,77.57 149,71.71 147.27,69.99 147.27,69.44 v1(147.02,69.19) ; v1(135.68,65.28) 136.31,65.28 SR100.1
  BOTTOM w0.508: v1(142.34,67.28) 143.73,67.28 145.64,69.19 v1(147.02,69.19) ; v1(142.34,65.28) v1(135.68,65.28) ; CON_CBAT.1 142.1,100.63 142.1,94.6 147.7,89 152.03,89 v1(153.59,87.44)
BEEP: length 3.4
  TOP w0.102: AU1.12 21.2,18.32 v1(21.69,18.8) 21.93,18.8 AC1.2
  BOTTOM w0.102: v2(22.26,19.37) v1(21.69,18.8)
BEEP_R: length 4.5
  TOP w0.102: AR3.2 v1(23.88,21.04) 23.71,21.21 AR4.1 23.15,20.43 AC2.1 AC1.1
  BOTTOM w0.102: v2(24.61,20.52) 24.42,20.72 24.2,20.72 v1(23.88,21.04)
BOARD_ID_D0: length 15.7
  TOP w0.102: PCH.AC42 179.77,50.72 v1(179.76,50.72) ; SR7696.2 190.72,54.85 189.66,54.85 SR712.1 188.74,53.93 188.52,53.93 187.2,52.61 v1(187.2,51.95)
  BOTTOM w0.089: 181.61,50.72 v1(179.76,50.72)
  BOTTOM w0.102: 181.61,50.72 182.07,51.18 183.07,51.18 183.96,50.29 186.44,50.29 v2(187.2,51.05) v1(187.2,51.95)
BOARD_ID_D1: length 18.2
  TOP w0.102: v1(187.98,51.97) 187.98,52.12 SR711.1 188.97,53.07 189.46,52.58 190.77,52.58 SR7697.2 ; v1(176.4,49.5) 176.7,49.81 PCH.AE35
  BOTTOM w0.089: 181.74,51.13 181.74,51.13 178.03,51.13 v1(176.4,49.5)
  BOTTOM w0.102: 181.74,51.13 181.98,51.37 183.58,51.37 v2(184.16,50.79) 185.37,50.79 187,52.42 187.52,52.42 v1(187.98,51.97)
BOARD_ID_D2: length 19.9
  TOP w0.102: PCH.AE36 177.09,49.59 v1(177.09,49.5) ; SR545.1 SR7698.2 194.12,49.33 v1(193.9,49.33)
  BOTTOM w0.089: 180.79,50 177.58,50 v1(177.09,49.5)
  BOTTOM w0.102: 180.79,50 180.96,49.83 v2(182.5,49.83) 182.75,49.58 185.95,49.58 186.21,49.33 v1(193.9,49.33)
BPM_0: length 59.6
  TOP w0.102: v1(88.23,114.99) 88.49,114.99 SR7642.1 ; XU1.D16 109.91,156.23 v1(110.34,155.8) ; v1(94.56,122.48) 96.85,122.48 v1(97.49,123.11)
  BOTTOM w0.102: v1(97.49,123.11) 97.68,123.3 97.68,134.82 101.73,138.87 101.73,143.81 102,144.08 102,151.36 105.38,154.74 106.78,154.74 108.12,156.08 108.95,156.08 109.08,156.21 109.93,156.21 v1(110.34,155.8) ; v1(94.56,122.48) 93.9,121.82 93.9,119.86 89.03,114.99 v1(88.23,114.99) 86,114.99 v2(85.01,114)
BPM_1: length 57.3
  TOP w0.102: XU1.D17 109.91,156.8 109.46,156.35 v1(109.46,155.79) ; SR7643.1 v1(87.78,114.4) ; v1(94.56,121.82) 96.95,121.82 v1(97.59,122.45)
  BOTTOM w0.102: v1(97.59,122.45) 97.9,122.77 97.9,134.74 101.94,138.78 101.94,143.72 102.21,143.99 102.21,151.27 105.47,154.52 106.87,154.52 108.15,155.79 v1(109.46,155.79) ; v2(86.77,114.4) v1(87.78,114.4) 88.77,114.4 94.12,119.75 94.12,121.37 v1(94.56,121.82)
BRT_PWM#: length 180.5
  TOP w0.102: v1(75.51,7.72) 74.6,7.72 73.95,8.37 SR7678.1 AC195.1 AD22.1 76.1,8.58 76.1,7.34 75.49,6.74 P189.11 ; v1(200.69,14.83) 200.08,14.23 200.08,12.17 202.16,10.1 202.16,6.96 v1(201.27,6.07) ; v1(216.83,27.67) 216.83,27.29 217.59,26.53 217.59,26.2 218.14,25.65 U104.24 ; v1(208.46,23.8) 209.04,23.8 209.34,24.1 U104.2
  BOTTOM w0.102: v1(216.83,27.67) 216.14,27.67 212.69,24.23 208.89,24.23 v1(208.46,23.8) 206.12,21.46 v2(206.12,20.57) 206.12,19.09 201.86,14.83 v1(200.69,14.83) ; v1(75.51,7.72) 75.9,7.33 77.06,7.33 77.28,7.54 83.68,7.54 85.5,5.71 101.21,5.71 101.74,6.25 105.55,6.25 107.08,7.78 119.81,7.78 120.84,6.75 139.58,6.75 143.37,10.53 152.73,10.53 156.01,7.25 156.01,6.4 157.78,4.63 173.29,4.63 176.62,7.96 188.67,7.96 190.56,6.07 v1(201.27,6.07)
BT_ON/OFF#: length 104.6
  TOP w0.102: v1(42.79,104.44) 36,104.44 25.85,94.3 25.85,72.5 29.67,68.68 29.67,66.39 25.79,62.52 25.79,58.86 22.66,55.72 v1(22.66,43.05) ; SR714.2 54.49,114.27 52.36,114.27 49.42,111.33 45.21,111.33 43.76,109.88 v1(42.7,109.88) 40.67,111.91 J60.54
  BOTTOM w0.102: v1(42.7,109.88) 42.79,109.79 v1(42.79,104.44) ; v1(22.66,43.05) v2(22.66,41.94)
BUZZ: length 10.8
  TOP w0.254: R36.2 31.47,51.31 P7.1
CA_DET: length 13.6
  TOP w0.102: MQ10.5 33.02,173.61 32.89,173.48 32,173.48 31.88,173.61 31.88,174.52 32.61,175.26 32.89,175.26 33.02,175.39 MQ10.2 33.02,176.61 33.16,176.75 M1R5.2 37.35,176.75 37.39,176.78 MQ8.2 38.84,176.78 38.99,176.63 v1(38.99,176.43) 38.99,176.28 38.85,176.13 MQ8.3
  BOTTOM w0.102: v2(39.32,175.72) 38.99,176.05 v1(38.99,176.43)
CAP1: length 5.4
  TOP w0.178: 206.32,26.19 206.58,26.44 U104.128
  TOP w0.254: C85.1 205.62,23.25 206.32,23.95 v1(206.32,25.3) 206.32,26.19
  BOTTOM w0.102: v1(206.32,25.3) 206.12,25.5 v2(205.52,25.5)
CASE_OPEN_DET#: length 45.1
  TOP w0.102: v1(136.63,15.14) 136.64,15.15 C93.1 PQ9787.3 137.56,12.08 UCR44.1 ; U15.25 111.42,30.89 111.66,30.66 111.66,29.68 UCR34.2 UCR31.1 111.01,27.39 113.03,25.37 117.97,25.37 119.17,24.17 119.17,23.17 120.17,22.17 120.17,21.51 121.14,20.54 121.3,20.54 122.29,19.55 122.29,18.89 123.26,17.93 123.26,16.93 125.81,14.38 129.42,14.38 131.4,12.4 v1(131.4,12.39)
  BOTTOM w0.102: v1(131.4,12.39) 131.4,12.4 134.09,12.4 v2(135.6,13.91) 136.63,14.94 v1(136.63,15.14)
CASE_OPEN_DET#_SMI: length 79.6
  TOP w0.089: PCH.BD13 165.79,41.08 166.01,41.31 166.01,41.53 165.84,41.7 165.72,41.7 165.2,42.21 v1(165.2,42.39)
  TOP w0.102: UCR31.2 110.17,27.6 112.71,25.06 116.61,25.06 117.73,23.94 117.73,23.57 118.73,22.57 118.73,21.57 120.43,19.87 120.43,19.11 v1(120.44,19.1) ; v1(157.41,24.91) 158.86,26.37 159.66,26.37 160.12,26.82 160.12,27.25 160.38,27.51 160.38,28.15 160.45,28.23 160.77,28.54 160.77,29.61 161.66,30.5 161.66,32.33 162.78,33.44 162.99,33.44 163.06,33.44 164.26,34.65 v1(164.26,35.08)
  BOTTOM w0.089: 164.64,40.44 165.54,41.33 165.54,42.06 v1(165.2,42.39)
  BOTTOM w0.102: v1(120.44,19.1) 120.98,18.56 121.79,18.56 121.84,18.61 122.97,18.61 123.02,18.56 123.88,18.56 123.93,18.61 124.97,18.61 125.02,18.56 125.88,18.56 125.93,18.61 127.06,18.61 127.11,18.56 127.88,18.56 127.93,18.61 128.97,18.61 129.17,18.41 132.39,18.41 134.57,20.6 141.9,20.6 143.14,21.84 149.6,21.84 150.45,22.7 154.64,22.7 156.41,24.47 156.7,24.47 157.14,24.91 v1(157.41,24.91) ; v1(164.26,35.08) 164.08,35.26 v2(164.08,36.12) 164.64,36.68 164.64,40.44
CATERR#: length 299.5
  TOP w0.102: v1(108.36,15.09) 108.36,12.05 C5.1 106.77,10.07 106.39,9.69 Q4.1 ; HR25.1 99.97,120.29 v1(99.97,120.88) 99.42,121.44 99.42,124.41 96.53,127.29 92.33,127.29 92.09,127.05 92.09,126.58 92.91,125.76 92.91,124.59 93.01,124.5 93.01,121.26 90.05,118.3 85.05,118.3 84.54,118.81 82.32,118.81 79.84,116.33 76.29,116.33 69.56,109.59 54.34,109.59 51.12,106.38 48.7,106.38 42.7,100.38 34.93,100.38 28.09,93.54 28.09,73.62 31.78,69.93 31.78,65.24 29.66,63.12 29.64,63.12 27.23,60.71 27.23,57.98 24.59,55.34 24.59,39.21 v1(26.01,37.8) ; XU1.D13 109.66,153.5 109.18,153.02 v1(108.58,153.02)
  BOTTOM w0.102: v1(108.58,153.02) 108.05,153.02 107.87,152.84 107.05,152.84 106.39,152.18 105.77,152.18 105.29,151.7 105.29,151.02 105.05,150.78 104.56,150.78 104.08,150.29 104.08,143.22 103.81,142.95 103.81,138.01 102.03,136.23 102.03,135.46 100.38,133.81 100.38,123.9 99.77,123.29 99.77,121.08 v1(99.97,120.88) ; v1(26.01,37.8) 27.81,35.99 v2(27.81,34.06) 27.81,29.81 39.28,18.35 39.28,18.22 42.05,15.44 60.6,15.44 61.02,15.03 61.37,15.03 61.68,15.34 88.32,15.34 88.94,14.72 90.26,14.72 91.09,15.55 107.9,15.55 v1(108.36,15.09)
CC1: length 39.2
  TOP w0.229: 18.18,150.22 18.2,150.21 U5.14 ; v1(17.22,151.82) 17.89,151.14 17.89,151.05 18.6,150.35 U5.13
  TOP w0.254: 18.18,150.22 18.18,150.24 17.22,151.21 v1(17.22,151.82)
  TOP w0.305: J_TYPEC.B5 4.71,145.68 4.37,145.34 3.45,145.34 v1(3.33,145.22)
  BOTTOM w0.305: v1(17.22,151.82) 18.41,153.01 v2(18.41,156.96) 18.41,157.29 17.09,158.61 15.67,158.61 13.82,156.76 11.56,156.76 10.11,155.3 6.1,155.3 2.39,151.59 2.39,146.17 v1(3.33,145.22)
CC2: length 37.7
  TOP w0.229: 19.8,150.24 19.67,150.37 19.51,150.37 19.4,150.26 U5.11 ; 19.8,150.24 U5.10 ; 19.8,150.24 20.41,150.85 21.08,150.85 21.47,151.24
  TOP w0.254: 21.47,151.24 21.55,151.33 21.55,153.11 v1(21.31,153.35)
  TOP w0.305: J_TYPEC.A5 6.89,147.18 6.98,147.27 v1(7.61,147.27)
  BOTTOM w0.305: v1(7.61,147.27) 7.61,148.03 7.87,148.28 7.87,151.43 8.41,151.97 8.41,154.07 9.22,154.88 10.28,154.88 11.74,156.34 14,156.34 15.85,158.19 16.92,158.19 17.68,157.43 v2(17.68,154.58) 17.68,153.44 16.7,152.46 16.7,151.6 17.01,151.3 17.47,151.3 19.93,153.75 20.91,153.75 v1(21.31,153.35)
CC_VCONN: length 11
  TOP w0.254: v1(19.5,151.01) 19,150.5 U5.12
  TOP w0.381: v1(19.5,151.01) 19.77,151.27 20.9,151.27 21.06,151.42 CB4129.1 20.49,151.85 20.32,152.02 PC640682.1 19.85,152.77 19.48,153.14 FC13.1 19.48,153.75 19.79,154.05 M2R52.2
  BOTTOM w0.381: v1(19.5,151.01) 19.5,151.34 v2(19.03,151.81)
CC_VCONN_EN: length 4.1
  TOP w0.229: U5.30 19.4,145.18
  TOP w0.381: v1(21.11,144.07) 20.94,144.23 20.17,144.23 AR243.1 19.98,144.6 19.4,145.18
  BOTTOM w0.381: v2(20.6,144.78) 21.11,144.27 v1(21.11,144.07)
CEN_B: length 40.7
  TOP w0.254: v1(16.64,84.45) 16.61,84.45 16.36,84.2 16.36,71.98 14.95,70.57 AD18.1 14.95,69.09 14.92,69.06 AC178.1 15.17,68.33 AL3.2
  BOTTOM w0.254: J83.42 19.37,103.09 19.37,89.26 17.37,87.27 17.37,85.83 16.64,85.09 v1(16.64,84.45)
CEN_JD: length 108.4
  TOP w0.254: v1(13.94,93.24) 13.94,104.57 J83.43 ; v1(3.28,29.46) 3.24,29.5 3.24,56.42 2.91,56.76 2.91,83.76 3.33,84.18 v1(5.84,84.18) ; v1(9.41,11.68) 9.53,11.8 AR19.2
  BOTTOM w0.254: v1(9.41,11.68) 8.8,12.29 7.97,12.29 5.75,14.52 5.75,18.61 4.2,20.15 4.2,23.96 2.54,25.63 2.54,28.73 3.28,29.46 v1(3.28,29.46) ; v1(5.84,84.18) 6.24,84.18 7.4,85.34 7.55,85.34 8.84,86.63 8.84,87 12.44,90.6 12.44,91.74 v1(13.94,93.24)
CEN_MUTE: length 3.6
  TOP w0.254: AQ1.2 15.95,62.87 v1(15.77,62.69) 15.77,62.28 16,62.05 AR61.2
  BOTTOM w0.254: v1(15.77,62.69) 16.31,63.22 v2(16.31,63.27)
CEN_R: length 7.3
  TOP w0.254: AL3.1 13.83,66.82 13.88,66.77 AR205.1 AR207.2 13.66,65.05 v1(13.66,64.52) 13.66,62.45 13.89,62.22 AQ1.6
  BOTTOM w0.254: v2(14.62,65.48) v1(13.66,64.52)
