# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI_MOSI: length 37.3
  TOP w0.102: SR27.1 178.16,31.98 184.92,25.22 184.92,22.76 184.28,22.11 184.28,21.79 184.16,21.68 F3R7.1 183.85,20.82 v1(180.67,17.64) ; E16.5 183.24,7.73 183.3,7.79 F3R13.1 182.83,9.32 182.83,10.67 184.62,12.45 184.62,17.21 185.36,17.96 v1(185.45,17.96)
  BOTTOM w0.102: v1(180.67,17.64) 180.69,17.64 180.94,17.89 185.38,17.89 v1(185.45,17.96)
SPI_MOSI_XDP: length 299.7
  TOP w0.102: v1(27.75,56.59) 27.75,58.52 28.24,59 28.86,59 30.06,60.2 30.06,61.1 32.78,63.82 32.78,71.11 29.09,74.8 29.09,93.12 35.33,99.37 43.12,99.37 49.13,105.37 51.54,105.37 54.74,108.57 72.51,108.57 75.27,111.33 77.49,111.33 79.75,109.07 83.83,109.07 84.01,108.89 SR164.2 84.89,109.17 v1(85.37,109.17) 85.47,109.17 85.83,108.81 85.83,108.51 XDP2.47 ; v1(171.31,6.3) 171.05,6.55 155.15,6.55 154.4,5.8 154.06,5.8 153.53,6.32 150.32,6.32 150.08,6.57 145.28,6.57 144.75,7.1 137.91,7.1 129.93,15.08 127.41,15.08 125.28,17.21 125.28,17.81 124.41,18.68 124.41,19.56 122.4,21.57 122.4,22.26 121.21,23.46 121.21,24.13 119.07,26.27 115.71,26.27 113.86,28.12 v1(113.86,30.15) ; F3R13.2 184.49,9.69 v1(184.91,9.27)
  BOTTOM w0.102: v1(85.37,109.17) 84.88,109.66 v2(84.88,109.86) ; v1(184.91,9.27) 184.69,9.05 176.16,9.05 172.97,5.85 171.75,5.85 v1(171.31,6.3) ; v1(27.75,56.59) v2(27.75,49.07) 27.75,47.19 34.25,40.69 35.64,40.69 44.15,32.18 60,32.18 60.7,31.47 64.14,31.47 64.47,31.79 88.73,31.79 89.59,30.94 96.92,30.94 97.69,30.18 110.64,30.18 110.99,29.83 111.01,29.84 113.54,29.84 v1(113.86,30.15)
SPKR: length 241.6
  TOP w0.102: v1(121.26,26.44) 123.49,24.21 123.49,23.8 124.7,22.59 130.44,22.59 131.58,21.45 131.63,21.39 131.63,21.3 131.78,21.14 131.78,18.89 v1(133.6,17.07) ; v1(175.51,30.43) 175.51,29.98 HC11.1 176.89,27.5 176.89,26.91 SR366.2 178.94,24.86 178.94,20.04 v1(179.25,19.73) ; AR3.1 26.48,20.45 27.04,21.01 28.75,21.01 33.79,26.06 33.79,30.8 v1(33.54,31.06) ; v1(202.77,25.88) 203.11,25.54 203.25,25.54 ECR97.1 ; v1(172.06,44.2) 171.61,44.2 PCH.AU24
  BOTTOM w0.089: 178.79,38.81 177.83,38.81 177.66,38.65 177,38.65 176.46,39.19 176.46,39.72 174.78,41.4 174.78,44.11 174.41,44.49 172.35,44.49 v1(172.06,44.2)
  BOTTOM w0.102: v1(133.6,17.07) 136.26,19.74 142.26,19.74 143.46,20.94 150.62,20.94 151.67,22 154.85,22 156.68,23.83 160.7,23.83 161.1,24.22 162.88,24.22 163.49,24.83 166.08,24.83 166.78,25.53 167.73,25.53 168.62,26.42 171.14,26.42 172.2,27.48 172.98,27.48 174.72,29.22 174.72,29.63 v1(175.51,30.43) 175.89,30.81 177.2,30.81 179.11,32.71 181.13,32.71 182.79,34.37 182.79,35.23 181.95,36.07 181.53,36.07 178.79,38.81 ; v1(179.25,19.73) 179.52,20 180.31,20 181.18,20 182.85,21.68 188.97,21.68 189.41,21.23 198.95,21.23 200.09,22.38 200.09,25.86 200.36,26.13 202.52,26.13 v1(202.77,25.88) ; v1(33.54,31.06) 33.54,30.47 v2(34.16,29.84) 37.21,26.8 97.35,26.8 98.14,26.01 120.83,26.01 v1(121.26,26.44)
SPKR_B: length 3.8
  TOP w0.102: Q9.1 28.92,39.94 28.17,39.19 R37.2 27.55,38.39 v1(27.53,38.38)
  BOTTOM w0.102: v2(27.18,39.12) 27.18,38.73 v1(27.53,38.38)
SPKR_O: length 6.6
  TOP w0.102: Q9.3 27.2,41.73 27.42,41.95 CB2.1 27.42,44.01 P7.2
SRTCRST#: length 18.4
  TOP w0.089: 162.48,38.27 163.42,39.22 PCH.BF8
  TOP w0.102: 162.48,38.27 162.45,38.24 162.45,37.47 159.51,34.53 159.51,34.03 157.63,32.15 v1(157.63,31.9) 157.39,31.9 154.99,29.51 154.99,28.68 155.12,28.55 155.66,28.55 SR102.2 155.77,27.79 155.64,27.79 155.49,27.63 SC102.1
  BOTTOM w0.102: v1(157.63,31.9) 157.63,32.32 157.94,32.63 v2(157.94,32.77)
SSD_PRST#: length 64.4
  TOP w0.089: PCH.BF30 175.25,38.76 175.25,38.64 175.49,38.39
  TOP w0.102: M2R36.1 211.46,6.25 v1(211.38,6.17) ; v1(188.89,10.49) 188.89,23.9 185.48,27.31 185.48,28.7 183.24,30.94 183.24,31.92 SR7627.2 183.2,32.74 183.2,35.11 181.89,36.42 178.6,36.42 176.8,38.23 175.66,38.23 175.49,38.39
  BOTTOM w0.102: v1(211.38,6.17) 210.76,6.79 207.29,6.79 206.62,7.47 192.93,7.47 v2(192.5,7.9) 191.45,8.95 190.53,8.95 188.99,10.49 v1(188.89,10.49)
SSD_PRST#_R: length 11.4
  TOP w0.102: M2R36.2 211.46,9.29 212.04,9.87 212.04,12.04 211.66,12.42 211.66,13.08 v1(213.77,15.19) 214.86,16.28 SS4.52
  BOTTOM w0.102: v2(214.66,15.19) v1(213.77,15.19)
SSD_SUSCLK: length 11.8
  TOP w0.102: SS4.68 v1(210.86,15.42) 210.86,12.56 211.58,11.84 211.58,10.36 211.15,9.93 210.86,9.93 M2C54.1 M2R33.2
  BOTTOM w0.102: v2(210.86,16.19) v1(210.86,15.42)
SURR-L: length 21.6
  TOP w0.254: AR211.1 12.56,64.59 v1(12.64,64.52) ; v1(10.92,55.63) 9.78,54.48 9.78,53.8 7.24,51.26 AC169.2
  BOTTOM w0.254: v1(12.64,64.52) 11.96,63.84 v2(11.96,63.37) 11.96,61.5 10.88,60.42 10.88,55.66 v1(10.92,55.63)
SURR-L_C: length 51.5
  TOP w0.254: v1(8.23,28.73) 8.79,29.29 12.07,29.29 15.07,32.28 15.07,36.63 AC169.1 ; AU1.39 v1(14.25,9.47)
  BOTTOM w0.254: v1(8.23,28.73) 8.23,19.83 6.81,18.41 6.81,14.9 8.22,13.49 9.1,13.49 11.01,11.57 11.01,9.47 11.84,8.64 13.03,8.64 13.86,9.47 v1(14.25,9.47)
SURR-L_MUTE: length 4.6
  TOP w0.254: AQ2.2 10.41,62.87 10.68,62.6 10.68,61.41 AR63.2 v1(9.18,61.13)
  BOTTOM w0.254: v2(9.74,61.68) v1(9.18,61.13)
SURR-R: length 24.1
  TOP w0.254: v1(10.89,64.51) 10.3,65.1 AR213.1 ; v1(10.92,54.74) 10.92,54.05 8.7,51.83 8.7,47.82 10.55,45.96 AC170.2
  BOTTOM w0.254: v1(10.92,54.74) 10.3,55.36 v2(10.3,59.82) 10.3,60.56 11.39,61.65 11.39,64.01 v1(10.89,64.51)
SURR-R_C: length 51.5
  TOP w0.254: v1(8.93,28.54) 12.05,28.54 15.57,32.06 15.57,37.49 12.45,40.62 AC170.1 ; AU1.41 15.25,12 14.78,12.47 v1(13.39,12.47)
  BOTTOM w0.254: v1(8.93,28.54) 8.93,26.58 8.94,26.57 8.94,19.82 7.32,18.2 7.32,15.11 8.35,14.07 9.23,14.07 11.52,11.79 11.52,9.68 12.05,9.14 12.79,9.14 13.39,9.74 v1(13.39,12.47)
SURR-R_MUTE: length 4.3
  TOP w0.254: v1(13.11,63.04) 12.93,62.87 AQ2.5 11.56,62.87 11.3,62.61 AR64.2
  BOTTOM w0.254: v2(13.97,63.04) v1(13.11,63.04)
SURR_JD: length 89.6
  TOP w0.254: AR17.2 19.56,26.42 v1(19.68,26.54)
  BOTTOM w0.254: v1(19.68,26.54) 19.51,26.72 19.51,29.08 19.02,29.57 19.02,33.43 18.44,34.01 18.44,41.08 16.5,43.02 16.5,56.95 15.93,57.53 15.93,59.26 16.46,59.79 16.46,62.21 16.98,62.73 16.98,76.16 17.5,76.68 17.5,82.23 16.98,82.76 16.98,83.34 15.49,84.83 15.49,86.92 15.88,87.3 16.44,87.3 17.71,88.57 17.71,89.42 18.19,89.9 18.19,91.63 18.69,92.14 18.69,101.4 12.3,107.8 J83.53
SURR_L: length 46.4
  TOP w0.254: AL7.2 12.86,68.33 AC176.1 13.02,68.99 AD16.1 13.02,70.17 13.97,71.12 v1(14.61,71.12)
  BOTTOM w0.254: v1(14.61,71.12) 14.61,71.33 16.47,73.2 16.47,76.37 16.99,76.89 16.99,82.02 16.47,82.54 16.47,83.13 14.92,84.68 14.92,87.19 15.54,87.81 16.23,87.81 17.2,88.78 17.2,89.63 17.68,90.11 17.68,91.85 18.19,92.35 18.19,101.19 14.08,105.3 J83.52
SURR_L_B: length 5.6
  TOP w0.254: AQ2.6 12.11,63.96 11.72,64.35 v1(11.72,64.54) AR211.2 11.72,66.24 AR224.1 11.52,66.44 AL7.1
  BOTTOM w0.254: v2(12.76,65.58) v1(11.72,64.54)
SURR_R: length 54.3
  TOP w0.254: v1(10.5,93.2) 9.95,93.74 9.95,110.59 J83.55 ; AL9.2 10.55,68.33 AC175.1 10.3,69.09 10.33,69.12 AD15.1 10.33,70.14 10.6,70.42 10.6,72.16 8.52,74.24 7.24,74.24 4.15,77.33 v1(4.15,81.38)
  BOTTOM w0.254: v1(10.5,93.2) 10.87,92.82 10.87,90.1 v2(10.2,89.42) 8.59,87.81 6.46,87.81 5.24,86.59 5.24,82.88 4.15,81.8 v1(4.15,81.38)
SURR_R_B: length 7.9
  TOP w0.254: AL9.1 9.21,66.54 AR222.1 AR213.2 9.46,64.63 v1(9.82,64.27) 9.63,64.09 9.32,64.09 9.02,63.79 9.02,62.56 9.37,62.22 AQ2.3
  BOTTOM w0.254: v2(10.82,65.28) v1(9.82,64.27)
SYS_PWROK: length 209.3
  TOP w0.089: 158.57,42.44 159.27,43.14 160.65,43.14 PCH.AW3
  TOP w0.102: v1(203.05,11.19) 203.05,6.22 v1(202.8,5.97) ; v1(220.55,34.26) 220.55,34.27 222.32,36.04 U104.57 ; v1(146,38.2) 146.51,37.69 150.2,37.69 SR7658.1 155.67,38.85 155.98,38.54 158.08,38.54 158.45,38.9 158.45,42.31 158.57,42.44 ; v1(114.39,29.77) 114.07,29.46 114.07,28.21 115.79,26.5 119.15,26.5 121.44,24.21 121.44,23.55 122.63,22.36 122.63,21.66 124.64,19.65 124.64,18.77 125.51,17.91 125.51,17.29 127.5,15.3 130.02,15.3 138,7.32 144.84,7.32 145.37,6.78 150.19,6.78 150.41,6.55 153.9,6.55 v1(154.23,6.22)
  BOTTOM w0.102: v1(202.8,5.97) 201.77,4.94 188.71,4.94 188.12,5.53 176.85,5.53 175.09,3.76 157.31,3.76 154.85,6.22 v1(154.23,6.22) ; v1(114.39,29.77) 114.67,29.77 114.99,29.44 115.94,29.44 116.57,30.07 119.28,30.07 120.02,30.81 129,30.81 130.96,32.77 139.91,32.77 145.35,38.2 v1(146,38.2) ; v1(203.05,11.19) 209.64,11.19 v2(212.98,14.53) 220.57,14.53 220.83,14.78 220.83,17.25 222.12,18.54 222.12,19.35 223.58,20.82 223.58,27.04 222.33,28.3 221.64,28.3 220.47,29.46 220.47,30 219.9,30.57 219.9,33.62 v1(220.55,34.26)
SYS_RESET#: length 284.6
  TOP w0.102: PCH.AV3 161.21,44.07 161.87,44.07 v1(161.99,43.95) ; v1(32.99,36.37) 32.99,57.65 35.23,59.89 35.23,75.37 39.7,79.84 39.7,87.17 40.8,88.27 40.8,89.49 48.68,97.37 48.68,101.18 50.89,103.39 52.36,103.39 53.01,104.04 70.02,104.04 71.73,105.76 79.23,105.76 80.37,104.61 81.59,104.61 85.22,100.99 85.22,97.15 88.34,94.03 90.69,94.03 SR166.2 SR7691.2 ; v1(133.08,27.93) 132.33,28.68 130.68,28.68 130.42,28.41 SR7690.1 129.33,28.41 128.88,28.86 SW2.2 SW2.1
  BOTTOM w0.102: v1(161.99,43.95) 161.96,43.98 160.58,43.98 160.01,43.41 158.81,43.41 154.86,39.46 154.72,39.46 v2(151.58,36.33) 150.6,36.33 143.22,28.94 142.86,28.94 142.3,29.5 134.66,29.5 v1(133.08,27.93) 131.8,26.64 122.17,26.64 121.31,25.78 98.02,25.78 97.23,26.57 36.74,26.57 33.57,29.74 33.57,30.02 32.99,30.59 v1(32.99,36.37)
SYS_SWCLK: length 73.2
  TOP w0.102: P311.2 148.24,3.87 146.26,3.87 145.29,4.84 145.29,5 144.29,5.99 135.29,5.99 127.82,13.46 125.32,13.46 122.84,15.94 108.85,15.94 107.64,17.16 107.64,17.92 106.73,18.83 106.73,22.55 107.5,23.32 107.5,29.36 109.52,31.39 109.52,31.58 110.35,32.41 110.73,32.41 111.59,33.27 U15.37
SYS_SWDIO: length 66.6
  TOP w0.102: P311.3 145.76,4.83 144.38,6.21 135.38,6.21 127.91,13.68 125.41,13.68 122.93,16.16 110.33,16.16 109.31,17.18 109.31,17.81 108.51,18.61 108.51,22.55 109.17,23.21 109.17,24.41 107.76,25.83 107.76,28.9 109.75,30.89 109.75,31.5 110.41,32.16 110.79,32.16 111.58,32.94 115.49,32.94 115.92,32.51 U15.34
SYSFAN_PWM: length 336.9
  TOP w0.102: FR1.2 136.65,235.59 v1(136.5,235.74) 136.06,236.18 135.44,236.18 135.17,235.91 135.17,234.94 134.92,234.7 FR2.2 ; U104.49 223.85,32.84 224.61,33.6 226.53,33.6 226.76,33.83 226.98,33.83 230.12,36.98 239.19,36.98 239.88,37.67 239.88,38 v1(239.32,38.56)
  BOTTOM w0.102: v1(136.5,235.74) 137.34,236.58 145.59,236.58 146.21,237.19 153.9,237.19 161.81,229.29 168.52,229.29 174.21,234.97 174.21,235.11 177.6,238.5 206.76,238.5 207.68,237.58 212.81,237.58 216.92,233.48 225.96,233.48 228.3,231.14 232.09,231.14 233.49,229.75 v2(233.49,227.76) 233.49,226.88 236.98,223.39 236.98,217.27 237.59,216.66 237.59,215.55 237.12,215.08 237.12,212.98 235.71,211.57 235.71,205.13 235.53,204.95 235.53,199.03 235.84,198.73 235.84,149.67 235.19,149.02 235.19,143.54 235.83,142.9 235.83,117.37 236.74,116.45 236.74,111.95 235.81,111.02 235.81,92.92 231.91,89.02 231.91,87.83 230.45,86.37 229.26,86.37 228.37,85.48 228.37,73.4 233.87,67.9 233.87,62.75 239.05,57.57 239.05,45.65 238.62,45.22 238.62,43.02 239.32,42.32 v1(239.32,38.56)
SYSFAN_TACH: length 355.7
  TOP w0.102: v1(137.59,233.76) 137.59,233.31 FR8.2 FR17.2 133.29,232.37 133.03,232.62 124.47,232.62 123.74,233.35 FD3.3 ; v1(238.28,27) 237.55,26.27 237.55,25.39 237.04,24.87 234.25,24.87 231.17,27.96 227.43,27.96 226.52,27.05 224.96,27.05 224.57,27.44 224.57,27.95 223.68,28.84 U104.39
  BOTTOM w0.102: v1(238.28,27) 238.27,27 237.4,27.87 237.4,28.74 237.42,28.76 237.42,31.27 237.4,31.29 237.4,32.88 238.25,33.73 238.25,35.87 237.87,36.25 237.87,40.08 235.42,42.53 235.42,53.41 237.72,55.72 237.72,57.98 233.22,62.48 233.22,67.63 227.72,73.13 227.72,85.75 229,87.02 230.18,87.02 231.27,88.1 231.27,89.3 235.16,93.19 235.16,142.65 234.54,143.27 234.54,149.29 235.19,149.94 235.19,198.44 234.34,199.29 234.34,208.13 234.81,208.6 234.81,211.58 236.47,213.24 236.47,215.8 236.26,216.01 236.26,223.14 232.23,227.17 232.23,228.89 231.62,229.5 v2(229.55,229.5) 229.02,229.5 225.69,232.83 216.46,232.83 212.35,236.93 207.41,236.93 206.49,237.85 177.87,237.85 174.89,234.88 174.89,234.74 168.79,228.64 159.62,228.64 154.88,233.37 146.33,233.37 146.2,233.5 137.85,233.5 v1(137.59,233.76)
TACH_B: length 32
  TOP w0.102: P70.3 151.22,237.15 v1(151.22,235.65) 151.51,235.36 151.51,234.2 FD10.2 149.47,232.17 FD7.1 FD7.2 145.23,233.47 144.99,233.23 144.99,232.34 144.89,232.24 143.1,232.24 142.61,232.74 142.61,234.15 141.3,235.46 139.54,235.46 138.09,236.91 133.17,236.91 131.7,238.38
  BOTTOM w0.102: v1(151.22,235.65) 151.63,235.24 v2(151.86,235.24)
TBT_DET#: length 202.9
  TOP w0.089: PCH.AV41 179.48,43.58 179.17,43.89 v1(179.17,44.09)
  TOP w0.102: v1(110.21,31.37) 110.21,31.04 107.97,28.81 107.97,25.92 109.39,24.5 109.39,23.12 108.73,22.46 108.73,18.7 109.52,17.9 109.52,17.27 110.42,16.38 123.02,16.38 125.5,13.89 128,13.89 128.01,13.89 128.65,13.89 v1(130.37,12.17) ; v1(61.09,32.51) 61.09,33.53 61.2,33.64 SR7780.2 ; v1(193.04,44.78) 193.8,44.02 193.8,43.43 196.35,40.88 196.35,37.87 195.93,37.44 195.42,37.44 194.49,36.51 194.49,36.22 191.12,32.86 191.12,27.58 192.91,25.79 192.91,22.3 v1(192.71,22.1) ; v1(188.82,45.06) SR443.2
  BOTTOM w0.102: v1(130.37,12.17) 130.57,11.97 134.44,11.97 138.96,16.49 149.16,16.49 149.38,16.71 154.88,16.71 155.84,17.67 157.56,17.67 159.97,20.09 168.13,20.09 168.88,19.33 176.9,19.33 178.22,20.65 180.91,20.65 182.58,22.33 189.24,22.33 189.66,21.91 192.52,21.91 v1(192.71,22.1) ; v1(61.09,32.51) 61.67,31.93 63.91,31.93 64.23,32.25 89,32.25 89.86,31.39 97.11,31.39 97.88,30.63 109.47,30.63 v1(110.21,31.37) ; v1(193.04,44.78) 192.61,45.21 v2(189.56,45.21) 188.98,45.21 v1(188.82,45.06) 188.42,44.65 179.73,44.65 v1(179.17,44.09)
TEST_EN: length 3.6
  TOP w0.102: U4.31 v1(33.52,149.91) 32.91,149.91 UR69705.1
  BOTTOM w0.102: v2(33.02,150.67) 33.52,150.18 v1(33.52,149.91)
TMIN_SHIFT: length 104.3
  TOP w0.089: v1(170.61,41.81) 170.42,42 PCH.BA22
  TOP w0.102: v1(175.17,23.81) 174.28,24.7 174.28,28.46 173.88,28.86 173.88,31.81 174.05,31.99 174.05,32.72 173.96,32.82 172.36,32.82 SR268.2 171.95,34.13 v1(172.06,34.24) ; O2R10.2 225.51,23.83 225.31,23.83 224.07,25.07 224.07,26.02 223.65,26.44 U104.33 222.05,26.44 222,26.39 221.54,26.39 220.83,27.1 v1(220.83,27.74) ; v1(196.09,28.91) 196.54,28.46 196.54,24.08 196.91,23.7 196.91,22.88 197.35,22.45 197.35,20.79 200.16,17.97 200.16,16.84 201.11,15.89 201.11,12.21 v1(201.51,11.82)
  BOTTOM w0.089: 172.24,37.77 171.64,38.37 171.64,38.67 170.51,39.79 170.51,40.66 170.33,40.85 170.33,41.53 v1(170.61,41.81)
  BOTTOM w0.102: v1(172.06,34.24) 172.45,34.63 172.45,36.31 172.24,36.52 172.24,37.77 ; v1(196.09,28.91) 195.49,28.31 188.05,28.31 187.42,27.67 180.83,27.67 179,25.84 176.96,25.84 175.17,24.05 v1(175.17,23.81) ; v1(201.51,11.82) 201.56,11.86 206.43,11.86 208.35,13.78 208.76,13.78 210.26,15.28 210.26,16.45 212.4,18.59 219.51,18.59 221.3,20.38 221.3,21.19 v2(220.85,21.64) 221.07,21.86 221.07,27.5 v1(220.83,27.74)
TP_CPU_RSVD_L8: length 2
  TOP w0.102: XU1.L8 v1(115.85,148.47)
  BOTTOM w0.102: HT56.1 116.32,148.47 v1(115.85,148.47)
TP_GPP_A14: length 6.8
  TOP w0.089: PCH.BF16 167.73,39.45 167.73,38.48
  TOP w0.102: v1(168.05,34.16) 168.05,34.67 167.89,34.82 167.89,38.31 167.73,38.48
  BOTTOM w0.102: ST147.1 167.93,34.16 v1(168.05,34.16)
TP_SLP_A#: length 8.2
  TOP w0.089: 165.11,36.46 165.28,36.63 165.28,38.91 165.4,39.04 165.4,40.03 PCH.BE13
  TOP w0.102: v1(164,33.52) 165.11,34.62 165.11,36.46
  BOTTOM w0.102: v1(164,33.52) 164,33.09 ST154.1
TP_SLP_LAN#: length 1.6
  TOP w0.102: PCH.AV11 165.14,43.93 v1(165.14,43.94)
  BOTTOM w0.102: v1(165.14,43.94) 164.49,43.29 ST1.1
TP_SLP_S0#: length 6.3
  TOP w0.089: v4(170.43,36.07) 171.08,36.71 171.08,39.44 171.04,39.53 170.95,39.6 170.95,39.82 171.04,40.13 171.16,40.24 PCH.BE24
  BOTTOM w0.102: v4(170.43,36.07) 170.43,34.49 ST156.1
TP_SLP_WLAN#: length 7.2
  TOP w0.102: PCH.BA9 163.43,42.29 v1(163.06,42.29)
  BOTTOM w0.102: v1(163.06,42.29) 163.06,42.23 162.82,41.99 162.82,39.18 161.5,37.86 161.5,37.02 ST106.1
U2DM_A: length 75.3
  TOP w0.102: v1(28.65,152) 28.78,151.87 29.59,151.87 30.42,152.71 36.83,152.71 37.77,151.76 37.77,149.79 37.87,149.69 37.87,149.31 38.02,149.17 U4.22 ; v1(30.55,112.66) 30.3,112.92 29.97,112.92 28.14,111.09 23.35,111.09 16.44,118.01 16.44,118.4 15.23,119.61 14.99,119.61 14.81,119.44 UL62.4
  BOTTOM w0.102: 28.87,131.11 28.87,131.91 28.4,132.38 28.4,137.39 27.73,138.06 27.73,139.35 27.11,139.97 27.11,144.7 27.61,145.2 27.61,146.16 28.11,146.65 28.11,151.46 v1(28.65,152) ; 28.87,131.11 v2(28.57,131.11) ; 28.87,131.11 28.87,123.14 29.25,122.76 29.25,119.03 29.79,118.48 29.79,113.42 v1(30.55,112.66)
U2DM_A-: length 15.6
  TOP w0.102: UL62.3 13.25,119.44 13.06,119.63 12.31,119.63 12.23,119.71 11.84,119.71 11.7,119.58 M1U6.4 M1U6.7 10.75,119.58 10.57,119.76 10.28,119.76 9.96,120.08 9.96,121.19 10.52,121.75 10.52,123.13 8.97,124.68 8.97,126.47 9.58,127.08 9.58,128.91 10.13,129.46 10.44,129.46 10.64,129.67 J133.12
U2DM_B: length 34.3
  TOP w0.102: UL76.3 13.91,152.8 15.99,154.89 33.63,154.89 34.24,154.28 38.72,154.28 40.35,152.65 40.35,149.87 39.9,149.43 39.9,149.07 40.02,148.96 U4.18
U2DM_B_C: length 23
  TOP w0.102: J_TYPEC.B7 3.91,146.68 3.66,146.43 3.66,146.18 v1(3.45,145.97) ; UL76.4 10.26,152.8 10.11,152.65 9.53,152.65 9.42,152.76 UU52.7 UU52.4 8.11,152.76 7.95,152.6 7.52,152.6 7.24,152.88 v1(7.24,152.9) ; J_TYPEC.A7 6.9,146.18 v1(7.16,145.92)
  BOTTOM w0.102: 5.77,153.52 5.28,153.52 3,151.23 3,147.56 3.68,146.88 3.68,146.2 v1(3.45,145.97) 3.76,145.67 3.81,145.67 3.84,145.64 3.84,145.64 4.23,145.24 4.64,145.24 5.58,146.18 6.9,146.18 v1(7.16,145.92) ; 5.77,153.52 v2(5.77,153.81) ; 5.77,153.52 5.97,153.52 6.83,152.65 7.01,152.65 7.24,152.88 v1(7.24,152.9)
U2DP_A: length 75.3
  TOP w0.102: v1(30.55,113.68) 30.81,113.42 30.81,113.25 30.68,113.12 29.88,113.12 28.06,111.3 23.44,111.3 16.64,118.09 16.64,118.48 15.31,119.81 14.96,119.81 14.79,119.99 UL62.1 ; v1(28.7,151.37) 29.01,151.67 29.67,151.67 30.51,152.5 36.74,152.5 37.57,151.68 37.57,149.71 37.66,149.61 37.66,149.31 37.52,149.17 U4.23
  BOTTOM w0.102: v1(30.55,113.68) 30.73,113.5 30.73,113.27 30.57,113.11 30.39,113.11 30,113.51 30,118.57 29.45,119.11 29.45,122.85 29.07,123.23 29.07,131.99 28.6,132.46 28.6,133.27 ; v2(28.89,133.27) 28.6,133.27 ; 28.6,133.27 28.6,137.48 27.93,138.14 27.93,139.43 27.31,140.05 27.31,144.62 27.81,145.11 27.81,146.07 28.31,146.57 28.31,150.97 v1(28.7,151.37)
U2DP_A+: length 15.6
  TOP w0.102: UL62.2 13.25,119.99 13.11,119.84 12.4,119.84 12.32,119.91 11.89,119.91 11.73,120.08 M1U6.5 M1U6.6 10.73,120.08 10.62,119.96 10.36,119.96 10.16,120.17 10.16,121.11 10.72,121.67 10.72,123.22 9.17,124.76 9.17,126.39 9.78,127 9.78,128.82 10.22,129.26 10.57,129.26 10.87,128.96 10.87,128.38 J133.13
U2DP_B: length 34.3
  TOP w0.102: U4.19 39.52,148.96 39.7,149.15 39.7,149.51 40.14,149.96 40.14,152.57 38.64,154.07 34.16,154.07 33.54,154.69 16.08,154.69 13.99,152.6 12.46,152.6 12.4,152.53 12.4,152.33 12.32,152.25 UL76.2
U2DP_B_C: length 23
  TOP w0.102: UL76.1 10.28,152.25 10.08,152.45 9.63,152.45 9.44,152.26 UU52.6 UU52.5 8.14,152.26 8,152.4 7.34,152.4 7.24,152.3 v1(7.24,151.84) ; v1(4.27,146) 4.08,146 3.86,146.21 3.86,146.35 3.99,146.48 4.55,146.48 4.85,146.18 J_TYPEC.B6 ; v1(7.16,146.68) J_TYPEC.A6
  BOTTOM w0.102: 5.99,146.39 5.5,146.39 4.55,145.44 4.32,145.44 4.04,145.72 4.04,145.85 4.19,146 v1(4.27,146) 3.89,146.38 3.89,146.96 3.2,147.65 3.2,151.15 5.37,153.31 5.88,153.31 6.75,152.45 7.05,152.45 7.24,152.27 v1(7.24,151.84) ; 5.99,146.39 6.86,146.39 v1(7.16,146.68) ; 5.99,146.39 v2(5.99,146.7)
U2FAN_DET: length 52.3
  TOP w0.102: v1(96.61,34.16) 97.17,33.6 97.17,23.29 96.42,22.53 96.42,18.68 95.5,17.76 95.5,17.09 92.89,14.48 92.5,14.48 91.83,13.81 FR37.1 ; v1(120.77,33.58) 120.77,34.55 120.05,35.27 U15.41
  BOTTOM w0.102: v1(96.61,34.16) v2(97.69,34.16) 97.95,34.42 107.17,34.42 107.8,33.79 113.47,33.79 113.75,34.08 118.54,34.08 119.33,33.29 120.48,33.29 v1(120.77,33.58)
U2FAN_PCH: length 159.6
  TOP w0.102: U15.39 119.2,34.27 119.49,34.56 119.85,34.56 120.1,34.31 120.1,32.79 119,31.69 119,30.63 119.24,30.38 119.66,30.38 120.09,30.81 122.9,30.81 123.74,29.97 123.74,28.13 123.96,27.91 123.96,27.91 126.1,25.77 128.79,25.77 129.54,25.02 129.8,24.76 131,24.76 136.82,18.94 136.82,17.82 v1(139.62,15.01) ; v1(198.13,51.03) 197.6,50.51 197.6,49.18 197.92,48.87 197.92,36.88 194.3,33.26 194.3,32.17 192.86,30.73 192.86,28.31 194.16,27.01 194.16,20.69 v1(193.91,20.43) ; PCH.AA44 182.51,52.34 183.54,53.37 183.54,53.63 187.07,57.16 195.01,57.16 195.41,56.76 195.55,56.76 196.06,56.25 196.06,56.16 SR7784.2 196.66,56.44 v1(196.67,56.44)
  BOTTOM w0.102: v1(193.91,20.43) v2(193.1,20.43) 192.64,20.43 192.45,20.62 189,20.62 188.61,21.01 183.06,21.01 181.48,19.43 179.89,19.43 178.92,18.47 168.12,18.47 167.48,19.1 162.69,19.1 159.93,16.34 157.06,16.34 156.55,15.83 150.25,15.83 149.96,15.54 140.15,15.54 v1(139.62,15.01) ; v1(198.13,51.03) 199.16,52.06 200.84,52.06 203.01,54.23 203.01,55.27 201.83,56.44 v1(196.67,56.44)
U3RXN_A: length 9.9
  TOP w0.114: U4.46 32.18,141.63 32.07,141.73 31.82,141.73 arc(31.65,141.7) 31.52,141.61 29.14,139.23 arc(28.85,138.8) 28.75,138.29 28.75,136.11 arc(28.65,135.61) 28.36,135.18 28.17,134.99 arc(28.03,134.89) 27.85,134.85 27.69,134.85 UC980.2
U3RXN_A_C: length 22.6
  TOP w0.114: UC980.1 26.13,134.82 25.74,134.82 arc(25.67,134.8) 25.62,134.76 25.49,134.64 arc(25.33,134.53) 25.15,134.5 24.87,134.5 24.76,134.38 UU39.6 UU39.5 23.57,134.38 23.44,134.51 23.31,134.51 v1(23.11,134.32)
  BOTTOM w0.114: J133.15 12.14,125.97 12.31,126.14 12.82,126.24 13.29,126.44 arc(13.44,126.49) 13.6,126.49 13.63,126.49 13.98,126.49 arc(14.05,126.48) 14.11,126.46 14.74,126.18 15.46,126.03 15.64,126.03 arc(15.89,126.09) 16.11,126.23 16.18,126.28 arc(16.56,126.46) 16.98,126.52 17.01,126.52 arc(17.44,126.45) 17.82,126.25 17.93,126.19 18.39,126.06 18.53,126.06 arc(18.98,126.15) 19.35,126.4 19.36,126.41 arc(19.52,126.63) 19.59,126.9 19.63,127.11 arc(19.64,127.21) 19.62,127.3 19.51,127.57 arc(19.42,127.94) 19.4,128.32 19.41,128.37 19.59,128.84 19.62,129.21 19.62,129.21 arc(19.61,129.36) 19.57,129.51 19.43,129.92 19.38,130.07 19.38,130.14 19.4,130.25 arc(19.49,130.52) 19.66,130.75 19.91,131 arc(20,131.08) 20.11,131.15 20.12,131.15 20.12,131.15 20.12,131.15 20.71,131.45 arc(20.86,131.54) 20.99,131.65 arc(21.42,131.93) 21.91,132.03 arc(22.17,132.08) 22.39,132.23 22.54,132.37 arc(22.73,132.66) 22.79,132.99 22.79,134.22 22.89,134.32 v1(23.11,134.32)
U3RXN_B: length 12.1
  TOP w0.114: U4.37 32.19,146.13 32.04,146.28 31.84,146.28 31.63,146.49 29.32,146.49 arc(28.96,146.56) 28.66,146.76 28.59,146.83 arc(28.34,146.99) 28.05,147.05 21.24,147.05 21.15,146.96 U5.2
U3RXP_A: length 9.9
  TOP w0.114: U4.45 32.17,142.13 32,141.96 31.82,141.96 arc(31.57,141.91) 31.35,141.77 28.98,139.39 arc(28.64,138.89) 28.52,138.29 28.52,136.11 arc(28.44,135.69) 28.2,135.34 28.01,135.15 arc(27.94,135.1) 27.85,135.08 27.63,135.08 UC979.2
U3RXP_A_C: length 22.6
  TOP w0.114: UC979.1 26.12,135.05 25.74,135.05 arc(25.59,135.02) 25.45,134.93 25.33,134.8 arc(25.25,134.75) 25.15,134.73 24.92,134.73 24.76,134.88 UU39.7 UU39.4 23.55,134.88 23.41,134.74 23.3,134.74 v1(23.09,134.95)
  BOTTOM w0.114: J133.16 12.14,126.66 12.41,126.39 12.75,126.46 13.2,126.65 arc(13.4,126.71) 13.62,126.72 13.64,126.72 13.98,126.72 arc(14.1,126.71) 14.21,126.67 14.82,126.4 15.48,126.26 15.64,126.26 arc(15.81,126.3) 15.95,126.39 15.96,126.41 16.05,126.47 arc(16.49,126.67) 16.98,126.75 17.01,126.75 arc(17.5,126.67) 17.94,126.44 18.02,126.4 18.42,126.29 18.53,126.29 arc(18.89,126.36) 19.19,126.56 19.2,126.57 arc(19.31,126.73) 19.36,126.92 19.37,126.93 19.41,127.16 arc(19.41,127.19) 19.4,127.22 19.3,127.49 arc(19.19,127.91) 19.17,128.35 19.19,128.43 19.36,128.89 19.39,129.22 arc(19.38,129.33) 19.36,129.43 19.21,129.85 19.15,130.03 19.15,130.16 19.17,130.29 arc(19.29,130.63) 19.5,130.92 19.74,131.16 arc(19.87,131.27) 20.02,131.36 20.61,131.65 arc(20.73,131.72) 20.83,131.81 arc(21.33,132.14) 21.91,132.26 arc(22.09,132.29) 22.23,132.39 22.37,132.53 arc(22.52,132.74) 22.57,132.99 22.57,134.43 v1(23.09,134.95)
U3RXP_B: length 12.1
  TOP w0.114: U5.3 21.15,147.36 21.22,147.28 28.05,147.28 arc(28.43,147.2) 28.75,146.99 28.82,146.93 arc(29.05,146.77) 29.32,146.72 31.73,146.72 31.94,146.51 32.07,146.51 32.19,146.63 U4.36
U3TXN_A: length 7.2
  TOP w0.114: U4.43 32.17,143.13 31.9,143.4 31.77,143.4 arc(31.7,143.38) 31.64,143.34 31.61,143.31 30.79,142.49 arc(29.92,141.91) 28.89,141.71 27.9,141.71 arc(27.7,141.67) 27.52,141.55 27.43,141.46 arc(27.35,141.34) 27.32,141.19 27.32,140.96 27.43,140.86 27.66,140.86 27.8,140.71 UC32.2
U3TXN_A_CMC: length 1.3
  TOP w0.114: UC32.1 27.45,139.16 27.45,138.74 27.64,138.55 URN149.4
U3TXN_AMC: length 18.5
  TOP w0.114: URN149.3 27.64,137.07 27.45,136.87 27.45,136.74 arc(27.41,136.58) 27.32,136.44 27.29,136.41 27.21,136.33 arc(26.84,136.08) 26.4,135.99 24.87,135.99 24.76,135.88 UU39.9 UU39.2 23.55,135.88 23.43,136 22.9,136 arc(22.53,135.92) 22.23,135.68 21.66,134.97 arc(21.19,134.59) 20.61,134.46 16.7,134.46 arc(16.17,134.38) 15.67,134.21 14.46,133.65 arc(14.24,133.58) 14.01,133.56 13.82,133.56 arc(13.64,133.51) 13.48,133.4 13.3,133.22 arc(13.2,133.1) 13.13,132.97 12.86,132.36 12.14,131.64 J133.18
U3TXN_B: length 16.8
  TOP w0.114: v1(21.36,145.36) 21.62,145.62 21.89,145.62 arc(22.2,145.6) 22.5,145.57 22.95,145.51 arc(23.34,145.47) 23.73,145.46 26.91,145.46 arc(27.52,145.42) 28.1,145.24 28.97,144.86 arc(29.6,144.66) 30.26,144.58 32.05,144.58 32.1,144.63 U4.40 ; U5.6 20.97,148.55 21.34,148.92 v1(21.6,148.92)
  BOTTOM w0.114: v1(21.36,145.36) 21.85,145.85 21.85,146.46 arc(21.81,146.66) 21.7,146.82 21.56,146.96 21.38,147.14 arc(21.22,147.38) 21.16,147.67 21.16,148.74 arc(21.18,148.82) 21.22,148.88 21.27,148.92 v1(21.6,148.92)
U3TXP_A: length 7.2
  TOP w0.114: UC31.2 26.89,140.7 27.09,140.91 27.09,141.19 arc(27.14,141.42) 27.27,141.62 27.36,141.71 arc(27.61,141.88) 27.9,141.94 28.89,141.94 arc(29.83,142.12) 30.63,142.66 31.48,143.51 arc(31.61,143.59) 31.77,143.63 U4.42
U3TXP_A_CMC: length 1.4
  TOP w0.114: URN149.2 26.99,138.55 27.22,138.78 27.22,139.17 UC31.1
U3TXP_AMC: length 18.5
  TOP w0.114: J133.19 12.14,132.25 12.21,132.18 12.36,132.18 12.66,132.49 12.88,132.99 arc(12.89,133) 12.89,133.01 12.92,133.07 arc(12.92,133.07) 12.92,133.07 arc(13.01,133.23) 13.14,133.38 13.32,133.56 arc(13.55,133.72) 13.82,133.78 14.01,133.78 arc(14.19,133.8) 14.36,133.86 15.58,134.42 arc(16.12,134.61) 16.69,134.69 20.61,134.69 arc(21.09,134.8) 21.49,135.11 22.05,135.82 arc(22.43,136.12) 22.9,136.23 23.42,136.23 23.57,136.38 UU39.1 UU39.10 24.76,136.38 24.91,136.22 26.4,136.22 arc(26.75,136.29) 27.05,136.49 27.13,136.57 27.16,136.6 arc(27.2,136.67) 27.22,136.74 27.22,136.84 26.99,137.06 URN149.1
U3TXP_B: length 16.8
  TOP w0.114: v1(21.34,146.01) 21.5,145.85 21.9,145.85 arc(22.22,145.83) 22.53,145.8 22.98,145.74 arc(23.36,145.7) 23.73,145.69 26.9,145.69 arc(27.56,145.64) 28.19,145.45 29.07,145.07 arc(29.65,144.88) 30.26,144.81 31.83,144.81 32.15,145.13 U4.39 ; U5.7 20.97,148.95 v1(21.58,149.56)
  BOTTOM w0.114: v1(21.34,146.01) 21.62,146.29 21.62,146.46 arc(21.6,146.57) 21.54,146.66 21.4,146.8 21.22,146.98 arc(21.01,147.3) 20.94,147.67 20.94,148.74 arc(20.97,148.9) 21.06,149.04 v1(21.58,149.56)
U4_SPI_CLK: length 60.3
  TOP w0.102: UR69703.2 40.79,191.9 40.75,191.86 40.75,190.6 40.26,190.11 F3U2.6 40.26,187.53 39.98,187.25 v1(38.1,187.25) ; v1(40.77,155.09) 44.32,151.54 44.32,143.86 43.09,142.63 U4.5
  BOTTOM w0.102: v1(38.1,187.25) 38.57,186.78 38.57,185.89 37.8,185.12 37.8,179.15 34.99,176.34 34.99,171.73 35.94,170.78 35.94,165.9 38.48,163.36 v2(38.48,161.65) 38.48,160.32 39.84,158.97 39.84,156.91 40.77,155.98 v1(40.77,155.09)
U4_SPI_DO: length 60.5
  TOP w0.102: U4.6 43.09,143.13 43.97,144 43.97,151.1 v1(40.69,154.38) ; v1(38.1,186.51) 40.56,186.51 41.53,187.48 F3U2.5 41.53,189.69 41.15,190.07 41.15,191.27 41.71,191.83 UR69704.2
  BOTTOM w0.102: v1(38.1,186.51) 38.1,185.93 37.44,185.27 37.44,179.3 34.63,176.49 34.63,171.39 v2(35.03,170.99) 35.59,170.43 35.59,165.75 37.93,163.4 37.93,159.88 39.34,158.47 39.34,156.84 40.35,155.84 40.35,154.72 v1(40.69,154.38)
UART1_RXD: length 51.4
  TOP w0.102: P312.2 148.23,10.24 145.11,10.24 144.13,9.26 138.76,9.26 136.35,11.67 136.35,11.83 135.56,12.62 135.56,18.28 132.28,21.57 132.28,21.68 130.13,23.83 129.76,23.83 128.98,24.61 128.46,25.12 124.88,25.12 123.81,26.19 122.66,26.19 121.77,27.08 120.04,27.08 119.89,26.93 116.45,26.93 115.79,27.58 UCR12.2 116.22,28.55 116.22,29.26 115.83,29.64 115.83,30.01 115.57,30.28 115.08,30.28 114.42,30.94 U15.31
UART1_TXD: length 49.8
  TOP w0.102: U15.30 113.92,30.98 114.81,30.1 114.81,29.6 114.46,29.25 114.46,28.59 UCR11.2 114.92,27.68 115.89,26.71 119.98,26.71 120.13,26.86 121.68,26.86 122.58,25.96 123.37,25.96 124.42,24.9 126.44,24.9 127.73,23.62 127.73,23.57 128.15,23.15 130.5,23.15 132.06,21.59 132.06,21.48 135.32,18.22 135.32,12.55 136.13,11.74 136.13,11.58 138.67,9.04 144.22,9.04 145.2,10.02 146.45,10.02 P312.3
UC_I2C_LED_SCL: length 167.5
  TOP w0.102: U15.21 109.06,34.77 108.17,33.87 UCC14.1 107.38,33.87 107.25,34 v1(107,34) ; v1(195.89,36.66) 196.79,37.56 196.79,41.16 195.3,42.65 v1(195.3,43.61) SR7779.2 ; v1(126.9,32.28) 126.9,32.2 127.39,31.7 127.39,28.38 128.21,27.56 129.49,27.56 130.59,26.45 132.38,26.45 138.65,20.19 138.65,18.86 144.79,12.71 149.47,12.71 v1(149.86,13.11) ; v1(190.45,9.93) 190.65,10.13 190.65,25.71 189.52,26.84 189.52,34.84 v1(189.7,35.01) ; PCH.AY33 176.12,42.6 v1(176.35,42.6)
  BOTTOM w0.102: v1(195.89,36.66) 195.89,35.86 194.76,34.73 189.98,34.73 v1(189.7,35.01) ; v1(149.86,13.11) 150.25,12.71 152.92,12.71 153.1,12.71 153.57,12.24 153.57,12.24 154.23,11.58 156.17,9.65 156.86,9.65 161.21,5.3 169.34,5.3 170.44,6.41 170.44,6.65 170.99,7.2 172.97,7.2 175.78,10.01 176.91,10.01 177.81,10.91 184.02,10.91 184.5,11.39 188.99,11.39 v1(190.45,9.93) ; v1(126.9,32.28) 126.11,33.07 119.24,33.07 118.45,33.86 113.84,33.86 113.56,33.58 107.57,33.58 107.14,34 v1(107,34) ; v1(195.3,43.61) 194.82,43.13 193.47,43.13 193.01,42.67 184.07,42.67 183.48,42.08 182.2,42.08 182.16,42.11 v2(179.53,42.11) 176.83,42.11 v1(176.35,42.6)
UC_I2C_LED_SDA: length 163
  TOP w0.102: v1(127.61,32.08) 127.61,28.47 128.29,27.79 129.59,27.79 130.71,26.67 132.47,26.67 138.96,20.18 138.96,18.85 144.68,13.13 v1(149.07,13.13) ; v1(190.43,35.15) 190.43,35.15 189.74,34.46 189.74,26.93 190.87,25.8 190.87,9.49 v1(190.75,9.37) ; v1(182.37,42.49) 182.07,42.79 PCH.AY45 ; U15.22 109.12,34.27 108.31,33.45 108.17,33.45 UCC13.1 107.3,33.43 106.82,33.43 v1(106.33,33.92) ; SR7778.2 v1(194.34,43.61) 194.34,43.28 196.57,41.05 196.57,37.65 196.06,37.13 195.71,37.13 v1(195.23,36.66)
  BOTTOM w0.102: v1(127.61,32.08) 127.31,31.78 124.22,31.78 123.15,32.85 119.15,32.85 118.36,33.64 113.93,33.64 113.65,33.36 107.48,33.36 107.28,33.56 106.68,33.56 v1(106.33,33.92) ; v1(149.07,13.13) 149.71,12.5 153.01,12.5 153.48,12.03 156.08,9.43 156.77,9.43 161.12,5.09 169.42,5.09 170.66,6.32 170.66,6.57 171.08,6.99 173.06,6.99 175.87,9.79 177,9.79 177.9,10.69 184.11,10.69 184.59,11.18 188.79,11.18 190.03,9.94 190.03,9.76 190.42,9.37 v1(190.75,9.37) ; v1(190.43,35.15) 190.58,35 194.73,35 195.23,35.51 v1(195.23,36.66) ; v1(182.37,42.49) 183.16,42.49 v2(183.4,42.74) 183.57,42.9 192.92,42.9 193.63,43.61 v1(194.34,43.61)
UC_SPKR: length 96.5
  TOP w0.102: U15.29 113.42,30.95 113.41,30.94 113.41,27.85 UCR39.1 113.5,27.34 v1(113.76,27.6) ; R37.1 28.17,35.69 29.72,34.14 v1(33.43,34.14)
  BOTTOM w0.102: v1(33.43,34.14) 35.26,34.14 v2(37,32.39) 41.1,28.3 98.22,28.3 99.14,27.38 113.54,27.38 v1(113.76,27.6)
USB2_COMP: length 13.9
  TOP w0.089: PCH.AG3 160.58,49.35 159.98,49.35 159.94,49.33 158.9,49.33 158.65,49.07
  TOP w0.102: SR60.1 148.98,48.69 154.18,48.69 154.89,47.98 155.94,47.98 156.22,48.26 157.56,48.26 158.08,48.78 158.36,48.78 158.65,49.07
USB2_OC#: length 9.1
  TOP w0.102: TUU2.3 41.72,199.68 41.16,200.24 40.12,200.24 39.78,199.9 37.99,199.9 UR69724.1 UR69723.2 CR17.1 v1(34.9,200.24)
  BOTTOM w0.102: v2(34.3,199.71) 34.84,200.24 v1(34.9,200.24)
USB2_P1_N_CHARGE: length 5.1
  TOP w0.102: URN62.3 232.2,102.27 231.61,102.85 231.47,102.85 231.46,102.85 230.94,102.85 230.19,102.1 U51.11
USB2_P1_P_CHARGE: length 5.1
  TOP w0.102: URN62.1 231.55,102.56 231.46,102.64 231.02,102.64 230.28,101.9 228.65,101.9 228.56,101.8 228.56,101.45 228.49,101.38 228.34,101.38 228.27,101.45 228.27,101.52 228.19,101.6 U51.10
USB2_P1_STATUS#: length 22.5
  TOP w0.102: MQ19.2 228.06,82.23 227.95,82.33 SC167.1 227.95,85.38 226.62,86.72 v1(226.62,94.97) 226.62,98.2 228.49,100.06 228.52,100.06 SR7564.2 228.51,100.46 227.97,100.46 227.68,100.74 U51.9
  BOTTOM w0.102: v2(226.62,94.21) v1(226.62,94.97)
USB2_P2_N_CHARGE: length 9.4
  TOP w0.102: U942691.11 225.98,113.98 226.28,113.68 226.41,113.68 226.49,113.77 226.49,113.87 226.59,113.97 226.72,113.97 226.82,113.87 226.82,113.77 226.91,113.68 227.47,113.68 228.39,112.77 230.07,108.9 230.07,108.29 230.24,108.12 230.59,108.12 230.66,108.2 UL64.3
USB2_P2_P_CHARGE: length 9.4
  TOP w0.102: UL64.2 231.21,108.46 230.68,107.92 230.15,107.92 229.87,108.21 229.87,108.86 228.22,112.65 227.39,113.48 U942691.10
USB2_P2_STATUS#: length 10.7
  TOP w0.102: U942691.9 226.42,112.98 226.83,112.56 SC166.1 226.45,112.1 225.95,111.59 SR7565.2 v1(224.64,111.18) ; v1(224.64,109.91) 224.4,109.91 223.76,110.54 222.35,110.54 222,110.19 MQ20.2
  BOTTOM w0.102: v1(224.64,109.91) v1(224.64,111.18) 224.64,111.87 v2(224.7,111.94)
USB2ID: length 11.2
  TOP w0.089: 158.83,48.92 159.05,49.15 159.98,49.15 160.01,49.16 160.27,49.16 PCH.AG2
  TOP w0.102: 158.83,48.92 158.5,48.59 158.16,48.59 157.64,48.07 156.3,48.07 155.92,47.69 154.44,47.69 v1(154.28,47.85) 154.13,48.01 SR70.2 153.11,48.48 151.55,48.48 151.42,48.35 SR2.1
  BOTTOM w0.102: v2(154.85,48.43) v1(154.28,47.85)
USB2VBUSSENSE: length 36.3
  TOP w0.254: SR1.1 SR20.2 143.05,42.25 142.42,42.88 v1(141,42.88) ; v1(164.41,49.48) 164.41,49.72 PCH.AE10
  BOTTOM w0.254: v1(164.41,49.48) 164.41,49.35 164.13,49.07 162.7,49.07 162.18,49.59 160.78,49.59 160.37,50.01 158.75,50.01 158.17,50.58 155.23,50.58 153.67,49.02 v2(152.53,49.02) 151.96,49.02 151.54,48.6 151.54,47.78 153.09,46.23 153.09,45.75 152.48,45.14 149.12,45.14 148.29,45.97 146.94,45.97 145.83,44.85 143.25,44.85 141.28,42.88 v1(141,42.88)
USB3_RX_N1: length 121.4
  TOP w0.089: PCH.B7 162.95,61.59 162.69,61.85 162.69,62.19 161.66,63.21 161.64,63.21 161.63,63.23
  TOP w0.102: 161.63,63.23 161.35,63.5 arc(160.98,63.75) 160.54,63.84 156.97,63.84 arc(156.71,63.85) 156.45,63.87 arc(154.97,64.3) 153.7,65.19 152.83,66.07 arc(151.8,67.61) 151.43,69.43 151.43,70.88 arc(152.19,74.67) 154.33,77.88 154.4,77.95 arc(155.34,79.35) 155.67,81.01 155.67,81.71 arc(155.88,82.76) 156.47,83.64 159.18,86.35 arc(161.13,87.65) 163.44,88.11 166.34,88.11 arc(168.38,87.71) 170.12,86.55 170.56,86.11 arc(172.29,84.95) 174.33,84.54 182.69,84.54 v1(182.78,84.63) ; v1(230.63,94.08) 230.63,93.49 UC987.1
  BOTTOM w0.102: v1(230.63,94.08) 230.63,93.48 arc(230.59,93.27) 230.47,93.08 224.39,87.01 arc(221.96,85.38) 219.08,84.81 218.91,84.81 arc(217.45,84.52) 216.22,83.69 215.9,83.37 arc(213.86,82.01) 211.46,81.53 211.23,81.53 arc(210.59,81.41) 210.04,81.04 arc(208.19,79.8) 206,79.37 188.99,79.37 arc(188.33,79.24) 187.77,78.86 187.59,78.68 arc(186.77,78.13) 185.8,77.94 184.82,77.94 arc(184.17,78.07) 183.61,78.44 183.48,78.58 arc(183.39,78.7) 183.36,78.85 183.36,80.03 arc(183.29,80.41) 183.07,80.73 183,80.8 arc(182.89,80.98) 182.84,81.19 182.84,82.12 ; v2(183.15,82.12) 182.84,82.12 ; 182.84,82.12 182.84,84.57 v1(182.78,84.63)
USB3_RX_N1_C: length 12.7
  TOP w0.102: P24.18 239.12,94.89 239.02,94.99 236.92,94.99 arc(236.66,94.94) 236.44,94.79 arc(236.11,94.39) 235.85,93.94 234.81,91.67 arc(234.71,91.48) 234.57,91.32 234.5,91.25 arc(234.31,91.12) 234.08,91.08 233.99,91.08 233.82,90.92 UU22.9 UU22.2 232.82,90.92 232.71,91.03 231.35,91.03 arc(231.01,91.1) 230.71,91.3 230.63,91.38 arc(230.54,91.52) 230.51,91.68 230.51,91.81 UC987.2
USB3_RX_N2: length 118.2
  TOP w0.102: PCH.C8 163.27,61.29 163.27,62.23 arc(163.25,62.32) 163.2,62.4 161.5,64.1 arc(161.09,64.38) 160.6,64.47 157.45,64.47 arc(155.56,64.85) 153.96,65.92 153.29,66.59 arc(152.46,67.83) 152.17,69.29 152.17,71.04 arc(152.82,74.3) 154.67,77.07 154.83,77.23 arc(156.05,79.06) 156.48,81.22 156.48,81.58 arc(156.65,82.42) 157.13,83.13 159.91,85.91 arc(161.59,87.03) 163.56,87.43 166.21,87.43 arc(168.07,87.06) 169.65,86 169.95,85.7 arc(173.58,83.27) 177.86,82.42 180.68,82.42 arc(180.92,82.47) 181.12,82.6 181.27,82.76 v1(181.27,83.14) ; v1(229.73,89.19) 229.89,89.36 230.38,89.36 UC992.1
  BOTTOM w0.102: v1(181.27,83.14) 181.27,82.76 181.19,82.68 arc(181.11,82.55) 181.08,82.4 181.08,79.86 arc(181.29,78.77) 181.91,77.85 182.4,77.35 arc(183.63,76.54) 185.07,76.25 187.18,76.25 ; 187.18,76.25 v2(187.18,75.94) ; 187.18,76.25 188.42,76.25 arc(189.82,76.53) 191.01,77.32 arc(191.53,77.67) 192.14,77.79 206.25,77.79 arc(208.85,78.31) 211.04,79.78 211.13,79.86 arc(211.24,79.93) 211.36,79.96 212.06,79.96 arc(214.55,80.45) 216.66,81.86 217.31,82.51 arc(218.11,83.05) 219.06,83.24 219.43,83.24 arc(222.67,83.88) 225.41,85.71 228.89,89.19 arc(229.05,89.3) 229.23,89.33 229.59,89.33 v1(229.73,89.19)
USB3_RX_N2_C: length 8.6
  TOP w0.102: UC992.2 232.08,89.42 UU22.5 UU22.6 234.34,89.42 arc(234.57,89.47) 234.76,89.59 235.06,89.87 arc(235.41,90.29) 235.64,90.78 236.16,92.31 arc(236.27,92.54) 236.43,92.75 236.61,92.92 arc(236.68,92.97) 236.78,92.99 237.02,92.99 237.13,92.89 P24.19
USB3_RX_N3: length 138.9
  TOP w0.102: PCH.B9 164.09,61.73 164.22,61.86 164.22,62.35 arc(164.17,62.63) 164,62.88 162.13,64.75 arc(161.45,65.2) 160.65,65.36 157.52,65.36 arc(155.91,65.68) 154.54,66.59 153.97,67.17 arc(153.3,68.17) 153.06,69.36 153.06,70.78 arc(153.67,73.83) 155.4,76.42 155.64,76.67 arc(157.02,78.72) 157.5,81.15 157.5,81.39 arc(157.66,82.18) 158.1,82.85 160.48,85.22 arc(161.93,86.2) 163.65,86.54 166.17,86.54 arc(167.7,86.23) 168.99,85.37 169.21,85.15 arc(173.52,82.27) 178.61,81.26 180.9,81.26 arc(181.68,81.41) 182.34,81.86 182.67,82.18 arc(182.82,82.4) 182.87,82.66 182.87,83.07 arc(182.94,83.24) 183.1,83.3 183.8,83.3 v1(183.92,83.19) ; v1(229.25,121.53) 229.43,121.7 229.73,121.7 UC994.1
  BOTTOM w0.102: v1(229.25,121.53) 228.9,121.53 228.86,121.48 arc(228.81,121.41) 228.79,121.32 arc(228.85,121.04) 229.01,120.79 229.19,120.61 arc(229.31,120.53) 229.45,120.51 230.06,120.51 arc(230.29,120.46) 230.49,120.33 230.64,120.17 arc(230.94,119.79) 231.14,119.35 231.98,116.8 arc(232.22,115.82) 232.3,114.81 232.3,110.56 arc(232.28,110.33) 232.21,110.1 230.73,106.07 arc(230.23,105.05) 229.51,104.16 229.32,103.97 arc(229.05,103.57) 228.96,103.09 228.96,99.79 arc(228.8,99.02) 228.37,98.37 227.13,97.13 arc(225.95,95.63) 225.17,93.89 225.16,93.85 arc(224.63,92.69) 223.84,91.68 221.05,88.89 arc(220.2,88.32) 219.19,88.12 219.06,88.12 arc(217.13,87.73) 215.49,86.63 214.24,85.39 arc(212.79,84.41) 211.07,84.07 209.86,84.07 arc(209.43,83.99) 209.07,83.74 208.88,83.56 arc(208.38,83.23) 207.79,83.11 190.91,83.11 arc(190.74,83.14) 190.59,83.24 190.57,83.27 arc(190.35,83.41) 190.09,83.46 189.1,83.46 ; v2(189.1,83.17) 189.1,83.46 ; 189.1,83.46 184.2,83.46 v1(183.92,83.19)
USB3_RX_N3_C: length 10.1
  TOP w0.102: P150.16 239.12,122.95 239.02,123.05 237.28,123.05 arc(236.92,123) 236.6,122.84 234.41,121.27 arc(234.27,121.2) 234.12,121.17 233.98,121.17 233.83,121.02 UU43.9 UU43.2 232.82,121.02 232.7,121.15 232.36,121.15 arc(232.13,121.18) 231.92,121.3 231.66,121.5 arc(231.57,121.57) 231.48,121.65 231.47,121.66 arc(231.4,121.7) 231.32,121.72 231.22,121.72 UC994.2
USB3_RX_N4: length 141.8
  TOP w0.102: v1(158.97,63.3) 158.53,62.87 158.08,62.87 arc(157.9,62.9) 157.75,63 arc(157.48,63.18) 157.16,63.25 156.77,63.25 arc(156.5,63.25) 156.24,63.28 arc(154.86,63.69) 153.69,64.52 152.39,65.82 arc(151.31,67.44) 150.93,69.36 150.93,70.87 arc(151.72,74.85) 153.97,78.22 154.11,78.36 arc(154.87,79.5) 155.14,80.84 155.14,81.76 arc(155.39,83.01) 156.1,84.07 158.66,86.64 arc(160.83,88.09) 163.39,88.6 166.63,88.6 arc(168.61,88.2) 170.29,87.08 171.02,86.35 arc(171.85,85.8) 172.84,85.6 181.47,85.6 v1(181.73,85.34) ; UC995.1 230.45,119.43 229.86,119.43 v1(229.64,119.21) ; PCH.E11 164.49,59.92 164.41,59.92 v1(164.03,60.3)
  BOTTOM w0.102: v1(158.97,63.3) 158.75,63.52 158.75,63.65 158.95,63.86 159.11,63.86 159.23,63.73 159.86,63.73 160.04,63.91 161.16,63.91 arc(161.67,63.81) 162.1,63.52 163.19,62.43 arc(163.42,62.08) 163.5,61.68 163.5,60.37 arc(163.52,60.27) 163.58,60.18 163.71,60.05 163.78,60.05 v1(164.03,60.3) ; v1(181.73,85.34) 182.06,85.67 185.64,85.67 ; 185.64,85.67 190.57,85.67 arc(190.9,85.73) 191.17,85.92 191.39,86.13 arc(191.54,86.23) 191.73,86.27 193.23,86.27 arc(193.41,86.24) 193.56,86.13 193.64,86.06 arc(193.84,85.92) 194.07,85.88 213.29,85.88 arc(213.66,85.95) 213.98,86.16 214.98,87.16 arc(216.8,88.38) 218.94,88.8 219.18,88.8 arc(219.89,88.94) 220.49,89.35 223.31,92.16 arc(224.01,93.06) 224.49,94.08 224.71,94.73 arc(225.36,96.11) 226.31,97.3 227.79,98.79 arc(228.14,99.32) 228.27,99.95 228.27,103.12 arc(228.42,103.87) 228.85,104.52 229.2,104.87 arc(229.38,105.08) 229.53,105.31 arc(229.64,105.56) 229.71,105.83 230.05,107.57 arc(230.12,108.11) 230.15,108.65 230.15,115.79 arc(229.96,116.75) 229.41,117.57 229.23,117.75 arc(228.93,118.2) 228.83,118.72 228.83,118.95 arc(228.97,119.29) 229.31,119.43 229.43,119.43 v1(229.64,119.21) ; 185.64,85.67 v2(185.64,85.36)
USB3_RX_N4_C: length 7.1
  TOP w0.102: UC995.2 231.98,119.48 232.08,119.48 arc(232.24,119.51) 232.37,119.6 232.39,119.62 arc(232.47,119.67) 232.55,119.68 232.66,119.68 232.83,119.52 UU43.5 UU43.6 233.82,119.52 233.96,119.66 234.15,119.66 arc(234.92,119.81) 235.58,120.25 236.08,120.75 arc(236.41,120.97) 236.8,121.05 237.02,121.05 237.13,120.95 P150.17
USB3_RX_N5: length 199
  TOP w0.102: v1(165.25,59.37) 165.51,59.37 165.76,59.61 165.76,59.85 PCH.E13 ; UC986.2 27.52,125.32 28.24,125.32 arc(28.85,125.2) 29.36,124.86 29.76,124.46 arc(29.92,124.23) 29.97,123.95 29.97,122.96 arc(30.16,122.04) 30.68,121.26 32.44,119.49 arc(34.2,118.32) 36.27,117.91 36.78,117.91 arc(37.57,118.06) 38.24,118.49 39.12,119.31 arc(39.46,119.53) 39.87,119.62 40.05,119.62 arc(40.15,119.57) 40.19,119.47 40.19,119.35 40.1,119.25 39.78,119.25 39.66,119.14 v1(39.66,118.89)
  BOTTOM w0.102: 153.68,69.13 153.74,69.19 arc(154.1,69.43) 154.53,69.52 158.65,69.52 arc(159.3,69.25) 159.57,68.6 159.57,68.47 arc(159.67,67.95) 159.96,67.52 165.09,62.39 arc(165.16,62.31) 165.23,62.24 arc(165.47,61.78) 165.56,61.27 165.56,59.46 165.46,59.37 v1(165.25,59.37) ; 153.68,69.13 v2(153.9,68.91) ; 153.68,69.13 152.24,67.7 arc(151.9,67.47) 151.49,67.39 145.95,67.39 arc(145.16,67.23) 144.49,66.78 144.34,66.63 arc(143.91,66.35) 143.41,66.25 78.52,66.25 arc(76.85,66.58) 75.43,67.53 74.12,68.84 arc(71.19,70.8) 67.72,71.49 62.96,71.49 arc(62.35,71.37) 61.83,71.02 61.31,70.51 arc(60.61,70.04) 59.78,69.88 52.93,69.88 arc(49.18,70.62) 46,72.74 42.43,76.32 arc(41.74,77.35) 41.5,78.56 41.5,93.45 arc(41.25,94.69) 40.54,95.75 40.23,96.06 arc(39.51,97.15) 39.25,98.44 39.25,116.13 arc(39.34,116.56) 39.58,116.92 39.74,117.08 arc(39.95,117.4) 40.03,117.77 40.03,118.42 39.92,118.53 39.74,118.53 39.66,118.61 v1(39.66,118.89)
USB3_RX_N5_C: length 13.3
  TOP w0.102: J133.25 15.34,125.91 15.49,126.06 15.54,126.06 arc(15.64,126.04) 15.71,125.97 16.33,124.99 arc(17.01,124.36) 17.91,124.13 21.57,124.13 arc(22.1,124.2) 22.6,124.4 22.94,124.59 arc(23.1,124.66) 23.27,124.69 23.47,124.69 23.61,124.55 UU14.5 UU14.6 24.6,124.55 24.77,124.72 24.8,124.72 arc(25.03,124.76) 25.23,124.87 25.73,125.27 arc(25.8,125.31) 25.88,125.32 26.02,125.32 UC986.1
USB3_RX_N6: length 206
  TOP w0.089: PCH.H15 166.36,58.1 v1(166.31,58.1)
  TOP w0.102: v1(37.63,119.61) 37.41,119.39 37.41,119.28 arc(37.25,118.88) 36.86,118.72 36.18,118.72 arc(34.43,119.07) 32.94,120.06 31.32,121.68 arc(30.85,122.39) 30.68,123.22 30.68,124.87 arc(30.53,125.62) 30.08,126.25 29.59,126.71 arc(29.46,126.79) 29.31,126.82 29.2,126.82 UC984.2
  BOTTOM w0.102: v2(159.33,66.42) 159.33,66.11 ; 159.33,66.11 145.78,66.11 arc(145.49,66.06) 145.25,65.89 144.04,64.68 arc(143.01,63.99) 141.8,63.75 128.59,63.75 arc(128.13,63.66) 127.74,63.4 124.42,60.08 arc(123.04,59.16) 121.41,58.83 116.91,58.83 arc(115.97,58.65) 115.17,58.11 114.84,57.78 arc(114.65,57.66) 114.43,57.61 82.22,57.61 arc(81.09,57.84) 80.13,58.48 79.4,59.2 arc(79.31,59.35) 79.27,59.52 79.27,59.64 arc(79.19,60.04) 78.97,60.37 78.19,61.16 arc(77.98,61.29) 77.74,61.34 77.45,61.34 arc(76.89,61.57) 76.66,62.13 76.66,62.49 arc(76.58,62.9) 76.35,63.25 75.88,63.71 arc(75.56,64.2) 75.44,64.79 75.44,64.79 arc(75.33,65.33) 75.02,65.8 73.05,67.77 arc(70.41,69.53) 67.3,70.15 63.56,70.15 arc(62.94,70.03) 62.41,69.67 62.07,69.33 arc(61.38,68.87) 60.56,68.71 44.78,68.71 arc(44.03,68.86) 43.4,69.28 43.3,69.37 arc(42.9,69.98) 42.76,70.7 42.76,71.53 arc(42.59,72.36) 42.12,73.07 41.09,74.1 arc(40.53,74.94) 40.33,75.94 40.33,93.19 arc(40.14,94.16) 39.59,94.97 38.74,95.83 arc(37.76,97.29) 37.41,99.02 37.41,119.39 v1(37.63,119.61) ; 159.33,66.11 159.7,66.11 arc(160.48,65.96) 161.15,65.51 164.15,62.51 arc(164.45,62.06) 164.56,61.53 164.56,60.8 164.72,60.64 164.72,59.55 164.81,59.46 164.81,58.08 165.23,57.66 165.87,57.66 v1(166.31,58.1)
USB3_RX_N6_C: length 7.4
  TOP w0.102: J133.45 21.74,125.8 22,126.06 22.2,126.06 arc(22.4,126.07) 22.61,126.1 22.96,126.15 arc(23.13,126.17) 23.3,126.18 23.47,126.18 23.6,126.05 UU14.2 UU14.9 24.58,126.05 24.74,126.21 24.87,126.21 arc(25.16,126.24) 25.44,126.34 26.17,126.67 arc(26.6,126.82) 27.06,126.86 27.61,126.86 UC984.1
USB3_RX_N7: length 204.7
  TOP w0.089: v1(166.31,58.93) 166.43,58.93 PCH.G15
  TOP w0.102: UC982.2 26.64,128.26 27.99,128.26 arc(28.83,128.13) 29.55,127.69 30.05,127.23 arc(30.67,126.84) 31.39,126.7 35.87,126.7 arc(36.34,126.67) 36.8,126.55 37.98,126.12 arc(38.55,125.97) 39.13,125.92 40.73,125.92 arc(40.73,125.92) 40.74,125.92 arc(41.05,125.99) 41.31,126.18 41.5,126.37 arc(41.63,126.56) 41.68,126.79 v1(41.68,127.29)
  BOTTOM w0.102: v1(166.31,58.93) 166.81,59.44 166.81,61.14 arc(166.67,61.88) 166.24,62.52 161.17,67.59 arc(160.78,68.17) 160.65,68.85 arc(160.54,69.4) 160.23,69.87 158.85,71.25 arc(158.15,71.72) 157.32,71.88 151.55,71.88 arc(151.19,71.81) 150.89,71.61 150.73,71.45 arc(150.34,71.19) 149.88,71.09 143.8,71.09 arc(142.31,70.8) 141.04,69.95 140.12,69.03 arc(138.78,68.14) 137.2,67.83 78.7,67.83 arc(77.91,67.98) 77.25,68.43 75.24,70.44 arc(72.21,72.46) 68.63,73.17 48.97,73.17 arc(47.89,73.39) 46.97,74 43.62,77.36 arc(43.21,77.96) 43.07,78.67 43.07,94.01 arc(42.81,95.34) 42.05,96.47 41.81,96.71 arc(41.14,97.71) 40.91,98.9 40.91,112.12 ; 40.91,112.12 40.91,113.05 arc(41.01,113.57) 41.31,114.01 41.72,114.42 arc(42.03,114.89) 42.14,115.44 42.14,119.54 arc(42.07,119.87) 41.88,120.16 41.84,120.2 arc(41.72,120.38) 41.68,120.6 v1(41.68,127.29) ; 40.91,112.12 v2(41.2,112.12)
USB3_RX_N7_C: length 8.7
  TOP w0.102: UC982.1 25.13,128.25 24.79,128.25 24.65,128.11 UU53.6 UU53.5 23.66,128.11 23.49,128.27 23.1,128.27 arc(22.68,128.24) 22.27,128.15 21.63,127.95 21.62,127.95 21.58,127.93 arc(21.31,127.79) 21.08,127.6 19.87,126.39 arc(19.49,126.14) 19.04,126.05 18.68,126.05 18.54,125.91 J133.35
USB3_RX_P1: length 121.6
  TOP w0.089: 161.77,63.37 161.79,63.36 161.79,63.34 162.95,62.18 PCH.A7
  TOP w0.102: UC988.1 230.84,93.24 230.84,93.6 230.91,93.68 231.39,93.68 231.47,93.75 231.47,93.95 v1(231.32,94.11) ; v1(182.36,84.12) 182.36,84.24 182.26,84.34 174.33,84.34 arc(172.21,84.76) 170.41,85.96 169.97,86.4 arc(168.31,87.52) 166.34,87.91 163.44,87.91 arc(161.21,87.47) 159.32,86.21 156.62,83.5 arc(156.07,82.68) 155.87,81.71 155.87,81.01 arc(155.53,79.28) 154.55,77.8 154.48,77.73 arc(152.38,74.59) 151.64,70.89 151.64,69.43 arc(151.98,67.69) 152.97,66.22 153.85,65.34 arc(155.05,64.48) 156.48,64.07 arc(156.72,64.05) 156.97,64.04 160.54,64.04 arc(161.06,63.94) 161.5,63.65 161.77,63.37
  BOTTOM w0.102: v1(182.36,84.12) 182.64,83.84 182.64,81.19 arc(182.7,80.9) 182.86,80.66 182.93,80.59 arc(183.1,80.33) 183.16,80.03 183.16,78.85 arc(183.2,78.62) 183.33,78.43 183.46,78.3 arc(184.09,77.88) 184.82,77.74 185.8,77.74 arc(186.85,77.94) 187.73,78.54 187.91,78.72 arc(188.41,79.05) 188.99,79.16 189.55,79.16 ; v1(231.32,94.11) 231.52,93.9 231.52,93.7 231.47,93.65 230.89,93.65 230.84,93.6 230.84,93.48 arc(230.78,93.19) 230.61,92.94 224.54,86.87 arc(222.03,85.19) 219.08,84.61 218.91,84.61 arc(217.53,84.33) 216.36,83.55 216.04,83.23 arc(213.94,81.82) 211.46,81.33 211.23,81.33 arc(210.66,81.22) 210.18,80.9 arc(208.26,79.61) 206,79.16 189.55,79.16 ; 189.55,79.16 v2(189.55,78.87)
USB3_RX_P1_C: length 12.4
  TOP w0.102: UC988.2 230.71,91.81 230.71,91.68 arc(230.73,91.59) 230.77,91.52 230.85,91.44 arc(231.08,91.29) 231.35,91.24 232.66,91.24 232.85,91.42 UU22.1 UU22.10 233.85,91.42 233.98,91.29 234.08,91.29 arc(234.23,91.31) 234.36,91.4 234.42,91.46 arc(234.54,91.6) 234.63,91.75 235.66,94.02 arc(235.94,94.51) 236.3,94.93 236.3,94.94 arc(236.58,95.13) 236.92,95.19 239.02,95.19 239.12,95.3 P24.16
USB3_RX_P2: length 117.8
  TOP w0.102: v1(229.73,89.84) 230.01,89.56 230.46,89.56 UC991.1 ; PCH.B8 163.47,61.68 163.47,62.23 arc(163.44,62.4) 163.35,62.54 161.64,64.25 arc(161.16,64.56) 160.6,64.68 157.45,64.68 arc(155.64,65.04) 154.11,66.06 153.43,66.74 arc(152.65,67.91) 152.37,69.29 152.37,71.04 arc(153.01,74.22) 154.81,76.92 154.97,77.08 arc(156.24,78.98) 156.69,81.22 156.69,81.58 arc(156.84,82.34) 157.27,82.98 160.06,85.77 arc(161.66,86.85) 163.56,87.22 166.21,87.22 arc(167.99,86.87) 169.51,85.86 169.81,85.55 arc(173.5,83.09) 177.86,82.22 180.68,82.22 arc(181,82.28) 181.26,82.46 v1(181.94,83.14)
  BOTTOM w0.102: 181.28,80.7 181.28,82.4 arc(181.29,82.47) 181.34,82.54 v1(181.94,83.14) ; 181.28,80.7 181.28,79.86 arc(181.48,78.85) 182.05,77.99 182.55,77.5 arc(183.7,76.73) 185.07,76.45 188.42,76.45 arc(189.74,76.72) 190.87,77.47 190.87,77.47 arc(191.45,77.86) 192.14,78 206.25,78 arc(208.77,78.5) 210.9,79.92 210.99,80.01 arc(211.16,80.12) 211.36,80.16 212.06,80.16 arc(214.47,80.64) 216.52,82.01 217.16,82.65 arc(218.03,83.23) 219.06,83.44 219.43,83.44 arc(222.59,84.07) 225.27,85.86 228.75,89.34 arc(228.97,89.48) 229.23,89.53 229.42,89.53 v1(229.73,89.84) ; 181.28,80.7 v2(181.58,80.7)
