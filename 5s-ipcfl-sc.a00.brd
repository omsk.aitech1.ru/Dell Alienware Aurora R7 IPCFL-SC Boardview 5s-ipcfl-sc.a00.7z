# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MIC1-VREFO-L: length 91.6
  TOP w0.254: v1(11.26,70.93) 11.78,71.45 11.78,72.48 9,75.26 7.66,75.26 5.27,77.65 5.27,82.04 7.4,84.16 7.4,85.76 5.78,87.38 AR219.2 ; v1(15.67,17.61) 14.83,16.77 12.51,16.77 12.47,16.82 AU1.28 ; v1(14.73,40.82) 14.73,40.49 17.22,38.01 17.22,31.46 v1(15.11,29.36)
  BOTTOM w0.254: v1(15.11,29.36) 15.11,28.4 15.81,27.7 15.81,17.75 v1(15.67,17.61) ; v1(14.73,40.82) 12.6,40.82 8.64,44.78 8.64,50.52 4.99,54.17 4.99,64.36 5.99,65.37 6.65,65.37 7.03,65.75 8.91,65.75 9.24,66.07 9.24,66.74 v2(9.96,67.47) 10.47,67.98 10.47,69.41 10.53,69.47 10.53,70.2 v1(11.26,70.93)
MIC1-VREFO-R: length 80.5
  TOP w0.254: v1(10.46,10.26) 12.63,12.43 12.63,14.65 12.47,14.82 AU1.32 ; v1(3.33,28.73) 3.82,29.22 3.82,30.36 3.75,30.44 3.75,56.65 3.42,56.98 3.42,73.52 3.81,73.91 5.08,73.91 5.77,73.23 8.1,73.23 8.79,72.54 AR223.2
  BOTTOM w0.254: v1(10.46,10.26) 10.46,11.4 8.98,12.89 v2(8.61,12.89) 8.1,12.89 6.25,14.73 6.25,18.87 4.74,20.38 4.74,24.17 3.05,25.86 3.05,28.45 v1(3.33,28.73)
MIC1_JD: length 99.5
  TOP w0.254: v1(15.21,26.21) 17.77,26.21 AR16.2 ; v1(12.67,19.61) 3.99,19.61 v1(2.13,21.46)
  BOTTOM w0.254: J83.3 4.26,94.55 1.42,91.71 1.42,23.34 1.55,23.22 1.55,22.05 v1(2.13,21.46) ; v1(15.21,26.21) 15.21,25.73 13.26,23.77 13.26,20.19 v1(12.67,19.61)
MIC1_L: length 4.6
  TOP w0.254: J83.2 7.16,90.73 7.18,90.71 AD6.1 7.18,89.22 AC183.1 6.45,88.49 AL12.1
MIC1_L_B: length 2
  TOP w0.254: AR216.1 AR219.1 4.41,87.87 4.41,87.87 AL12.2
MIC1_R: length 37.1
  TOP w0.254: AL14.1 5.58,72.43 AC184.1 4.47,72.3 AD7.1 4.45,72.9 v1(4.19,73.15) ; v1(9.33,92.37) 8.77,92.94 8.77,100.44 J83.5
  BOTTOM w0.254: v1(4.19,73.15) 4.19,73.66 2.95,74.9 2.95,82.03 4.12,83.2 4.12,86.9 6.4,89.19 8.15,89.19 9.2,90.24 9.2,92.25 v1(9.33,92.37)
MIC1_R_B: length 3.8
  TOP w0.254: AL14.2 7.35,71.08 7.49,70.94 AR218.1 AR223.1 v1(7.95,72.54)
  BOTTOM w0.254: v2(7.35,73.14) v1(7.95,72.54)
MIC2-L: length 42
  TOP w0.254: AR5.1 35.9,10.2 v1(35.81,10.29) ; AC162.2 17.65,24.23 17.27,23.85 v1(14.94,23.85)
  BOTTOM w0.254: v1(35.81,10.29) 34.95,9.42 32.49,9.42 32.26,9.65 29.08,9.65 28.57,9.14 25.29,9.14 23.01,6.87 21.25,6.87 20.84,7.28 19.23,7.28 17.1,9.4 17.1,10.85 15.22,12.74 15.22,16.29 14.41,17.09 14.41,22.54 v2(14.94,23.06) v1(14.94,23.85)
MIC2-L_C: length 5.5
  TOP w0.254: v1(17.4,18.44) 17.4,18.85 17.25,18.99 AU1.16 17.25,21.87 17.65,22.28 AC162.1
  BOTTOM w0.254: v2(17.4,19.28) v1(17.4,18.44)
MIC2-R: length 37.6
  TOP w0.254: AC161.2 15.11,24.64 14.94,24.46 14.71,24.46 v1(14.12,23.88) ; v1(32.89,8.26) 32.89,7.87 32.85,7.84 AR6.1
  BOTTOM w0.254: v1(32.89,8.26) 32.77,8.13 26.01,8.13 24,6.12 21.28,6.12 20.63,6.77 19.02,6.77 16.59,9.19 16.59,10.55 v2(15.58,11.57) 14.71,12.44 14.71,16.08 13.91,16.88 13.91,23.66 v1(14.12,23.88)
MIC2-R_C: length 7.3
  TOP w0.254: v1(17.4,17.65) 16.75,18.3 AU1.17 16.75,20.99 15.86,21.89 15.35,21.89 15.11,22.12 AC161.1
  BOTTOM w0.254: v2(17.4,16.81) v1(17.4,17.65)
MIC2-VREFO: length 16.9
  TOP w0.254: v1(13.36,13.39) 13.36,15.36 12.9,15.82 AU1.30 ; AD1.3 21.08,5.64 19.82,6.9 18.02,6.9 v1(16.68,8.24)
  BOTTOM w0.254: v1(16.68,8.24) 15.93,8.99 v2(15.93,9.78) 15.93,10.34 14.07,12.19 14.07,12.67 v1(13.36,13.39)
MIC2_JD: length 29.7
  TOP w0.254: AR11.2 8.61,11.71 v1(8.64,11.68)
  BOTTOM w0.254: P23.6 29.91,3.05 28.65,4.31 27.37,4.31 26.69,3.63 23.05,3.63 20.48,6.2 18.77,6.2 17.27,7.7 15.65,7.7 15.11,8.23 13.64,8.23 13.54,8.13 11.63,8.13 9.57,10.18 v2(9.35,10.18) 8.64,10.89 v1(8.64,11.68)
MIC2_L_C: length 3.4
  TOP w0.254: AL15.2 38.23,8.08 38.39,7.91 AC77.1 38.39,7.02 37.97,6.6 P23.1
MIC2_R_C: length 3.5
  TOP w0.254: P23.3 35.43,7.28 AC76.1 34.96,8.76 AL16.2
ML_LANE_0N: length 11.3
  TOP w0.102: J125.3 9.54,159.44 9.68,159.3 11.42,159.3 13.59,161.48 13.59,162.69 14.3,163.4 14.91,163.4 15.07,163.56 M1U1.9 M1U1.2 16.55,163.56 16.85,163.26 17.38,163.26 SC65.1
ML_LANE_0P: length 11.3
  TOP w0.102: J125.1 9.54,159 9.64,159.1 11.5,159.1 13.79,161.39 13.79,162.6 14.38,163.19 14.86,163.19 15,163.06 M1U1.10 M1U1.1 17.14,163.06 SC64.1
ML_LANE_1N: length 12.1
  TOP w0.102: SC67.1 17.21,164.92 16.66,164.92 16.53,165.06 M1U1.5 M1U1.6 15.12,165.06 14.94,164.87 14.63,164.87 11.23,161.48 10.19,161.48 9.81,161.86 9.27,161.86 8.57,161.16 8.24,161.16 8.14,161.26 J125.6
ML_LANE_1P: length 12.1
  TOP w0.102: SC66.1 17.31,164.72 16.76,164.72 16.6,164.56 M1U1.4 M1U1.7 15.04,164.56 14.94,164.67 14.71,164.67 11.32,161.27 10.53,161.27 9.81,160.56 9.27,160.56 8.88,160.95 8.26,160.95 8.14,160.83 J125.4
ML_LANE_2N: length 10.8
  TOP w0.102: J125.9 9.54,163.44 9.68,163.3 11.88,163.3 14.1,165.52 14.1,166.24 15.02,167.17 M1U2.9 M1U2.2 16.45,167.17 16.64,166.98 17.43,166.98 SC69.1
ML_LANE_2P: length 10.8
  TOP w0.102: SC68.1 17.09,166.77 16.66,166.77 16.55,166.67 M1U2.1 M1U2.10 14.81,166.67 14.3,166.16 14.3,165.44 11.96,163.1 9.65,163.1 9.54,162.99 J125.7
ML_LANE_3N: length 12.8
  TOP w0.102: J125.12 8.14,165.22 8.26,165.11 8.74,165.11 8.84,165.21 8.84,165.48 9.22,165.86 9.86,165.86 10.14,165.58 12.26,165.58 13.13,166.45 13.13,167.6 14.01,168.48 14.86,168.48 15.05,168.67 M1U2.6 M1U2.5 16.53,168.67 16.66,168.53 17.16,168.53 SC153.1
ML_LANE_3P: length 12.7
  TOP w0.102: SC152.1 17.36,168.33 16.66,168.33 16.5,168.17 M1U2.4 M1U2.7 15.07,168.17 14.96,168.28 14.1,168.28 13.34,167.51 13.34,166.37 12.34,165.38 10.33,165.38 10.19,165.23 10.19,164.96 9.78,164.55 9.22,164.55 8.87,164.9 8.24,164.9 8.14,164.8 J125.10
MODE_DEL: length 5.9
  TOP w0.102: AR242.1 24.43,144.97 21.88,144.97 21.71,144.8 20.83,144.8 20.2,145.43 U5.32
MUTE: length 49.7
  TOP w0.254: AQ14.3 24.49,34.24 20.22,38.51 20.22,58.75 18.68,60.29 AR61.1 AR62.1 AR203.1 13.11,60.76 13.04,60.76 AR204.1 11.84,60.29 AR64.1 AR63.1 v1(8.71,60.29) AR201.1 AR202.1 6.08,60.78 6,60.78 AR199.1 5.21,61.13 5.2,61.13 AR200.1
  BOTTOM w0.254: v1(8.71,60.29) 8.29,59.87 v2(7.87,59.87)
Net_44: length 0.3
  TOP w0.203: 181.63,41.71 181.91,41.71
Net_272: length 0.3
  TOP w0.203: 181.63,53.99 181.63,53.74
Net_2055: length 0.3
  TOP w0.203: 181.63,44.9 181.63,44.65
Net_2078: length 0.3
  TOP w0.203: 181.63,42.27 181.41,42.4
Net_2079: length 0.3
  TOP w0.203: 181.63,41.21 181.92,41.21
Net_2086: length 0.3
  TOP w0.203: 176.41,39.36 176.16,39.36
Net_2105: length 0.3
  TOP w0.203: 169.59,39.36 169.34,39.36
Net_2148: length 0.3
  TOP w0.203: 181.63,56.27 181.63,56.01
Net_2226: length 0.4
  TOP w0.203: 109.91,180.39 109.57,180.62
Net_2228: length 0.4
  TOP w0.203: 109,179.48 109,179.07
Net_2244: length 0.4
  TOP w0.203: 141,142.53 141,142.12
Net_2245: length 0.4
  TOP w0.203: 141.91,143.44 142.32,143.44
Net_2263: length 0.3
  TOP w0.203: 108.08,158.07 108.4,158
Net_2267: length 0.3
  TOP w0.203: 107.17,158.07 107.49,158
Net_2268: length 0.3
  TOP w0.203: 107.17,152.59 107.17,152.92
Net_2269: length 0.3
  TOP w0.203: 108.08,152.59 108.4,152.51
Net_2278: length 0.3
  TOP w0.203: 108.08,153.5 108.08,153.17
Net_2297: length 0.3
  TOP w0.203: 143.74,172.16 143.74,172.49
Net_2298: length 0.3
  TOP w0.203: 142.83,172.16 142.83,172.49
Net_2302: length 0.3
  TOP w0.203: 142.83,173.99 142.83,173.66
O_AUD_PCSPKR_DET#: length 3.8
  TOP w0.102: U104.54 223.72,34.84 224.22,35.34 224.22,35.83 v1(224.46,36.07) 224.51,36.12 O2R5.2
  BOTTOM w0.102: v2(224.69,36.8) 224.46,36.58 v1(224.46,36.07)
O_IO_PME#: length 62.1
  TOP w0.102: v1(172.12,26.81) 172.12,27.62 170.28,29.46 v1(170.28,31.32) ; v1(210.69,37.52) 215.75,37.52 217.34,39.11 U104.75 ; v1(170.55,33.34) 170.13,32.92 170.01,32.92 SR7713.1
  BOTTOM w0.102: v1(170.55,33.34) 170.28,33.07 v1(170.28,31.32) ; v1(210.69,37.52) 210.69,37.62 209.8,38.51 207.3,38.51 206.35,37.55 206.35,37.34 205.45,36.44 202.76,36.44 202.15,37.05 v2(201.27,37.05) 198.29,37.05 195.76,34.52 183.67,34.52 181.65,32.5 179.19,32.5 177.27,30.58 176.38,30.58 173.07,27.27 172.58,27.27 v1(172.12,26.81)
O_SPEAKER: length 7.5
  TOP w0.102: v1(209.05,27.12) 209.05,27.27 208.68,27.64 U104.125 206.56,27.64 204.88,25.96 OR44.1 ECR97.2
  BOTTOM w0.102: v2(208.25,27.94) 208.69,27.51 208.69,27.48 v1(209.05,27.12)
OC_ASM1142_PA#: length 442.1
  TOP w0.102: U4.28 35.02,149.24 35.2,149.43 v1(35.64,149.43) 35.03,150.04 35.03,150.83 33.84,152.01 30.81,152.01 29,150.21 26.72,150.21 26.14,150.79 24.83,150.79 v1(24.05,150.01) ; v1(22.72,141.53) 22.72,142.07 22.2,142.6 21.39,142.6 20.58,143.41 19.35,143.41 v1(19.1,143.66) ; v1(157.12,15.24) 156.99,15.24 146.94,25.29 v1(146.94,25.55) ; v1(188.14,50.29) 184.78,50.29 184.04,49.55 182.16,49.55 181.8,49.18 180.51,49.18 PCH.AH42 ; v1(197.13,49.28) 197.7,48.7 197.7,36.97 194.46,33.73 192.91,33.73 192.21,33.03 192.21,31.74 192.41,31.55 192.41,28.46 193.57,27.3 193.94,26.92 193.94,21.54 193.43,21.03 193.43,17.75 v1(193.16,17.49) ; v1(13.08,137.82) 12.61,138.29 UR69722.1 UR69721.2 12.61,140.37 12.18,140.81 UU45.3 ; v1(45.54,128.55) 45.54,127.61 48.82,124.33 50.62,124.33 51.41,123.55 51.41,122.68 v1(51.26,122.53) ; v1(30.73,33.25) 28.86,33.25 23.44,38.66 23.44,55.88 26.23,58.66 26.23,62.34 30.1,66.21 30.1,68.86 26.38,72.58 26.38,94.22 34.27,102.11 41.92,102.11 47.87,108.05 50.43,108.05 53.64,111.27 v1(56.98,111.27)
  BOTTOM w0.102: v1(197.13,49.28) 196.11,50.29 v1(188.14,50.29) ; v1(56.98,111.27) 55.67,112.57 55.32,112.57 50.93,116.97 50.93,122.2 v1(51.26,122.53) ; v1(45.54,128.55) 45.54,129.45 43.07,131.93 43.07,133.22 40.63,135.66 40.63,141.48 39.07,143.04 38.94,143.04 35.32,146.66 35.32,149.11 v1(35.64,149.43) ; v1(13.08,137.82) 14.86,137.82 16.03,138.99 18.29,138.99 19.1,139.8 v1(19.1,143.66) ; v1(146.94,25.55) 139.78,25.55 136.78,22.56 134.43,22.56 130.97,19.09 129.57,19.09 128.02,20.64 59.32,20.64 57.24,18.56 41.51,18.56 31.22,28.85 31.22,32.77 v1(30.73,33.25) ; v1(157.12,15.24) 157.12,14.35 162.85,8.62 167.32,8.62 170.07,11.37 170.07,11.88 170.45,12.26 170.45,13.81 171.43,14.8 173.7,14.8 173.95,14.8 174.24,15.09 176.58,15.09 177.13,15.09 177.13,15.09 177.52,15.09 180.96,15.09 181.51,15.09 182.28,15.09 183.08,15.89 187.59,15.89 187.67,15.97 189.62,17.92 192.73,17.92 v1(193.16,17.49) ; v1(24.05,150.01) 23.72,149.68 23.72,148.29 23.48,148.05 23.48,143.54 22.44,142.5 v2(22.44,142.24) 22.44,141.81 v1(22.72,141.53)
OC_ASM1142_PB#: length 16.2
  TOP w0.102: v1(32.6,160.05) 32.6,161.16 AR244.2 33.43,161.58 33.53,161.48 UU54.3 ; v1(34.52,150.16) U4.29
  BOTTOM w0.102: v1(32.6,160.05) 32.6,158.74 34.77,156.57 34.77,155.93 33.62,154.78 v2(33.62,153.7) 33.62,153.07 34.52,152.17 v1(34.52,150.16)
OSC8M__IN: length 4.5
  TOP w0.102: U15.5 114.92,41.19 115.77,42.04 UCC1.1 117.03,42.46 116.78,42.71 UCR30.1
OSC8M__OUT: length 4.9
  TOP w0.102: Y19.1 115.84,44.24 UCC2.1 115.84,42.53 114.42,41.12 U15.6
P1_PSON#: length 20.8
  TOP w0.102: P1R2.1 P1R3.2 P1C2.1 235.97,148.21 v1(236.88,149.12)
  BOTTOM w0.102: v2(236.33,148.54) 236.6,148.81 236.6,148.84 v1(236.88,149.12) 236.94,149.19 236.94,163.01 CON4.16
PCH_DDPC_HPD2: length 18.4
  TOP w0.102: v1(162.94,44.08) 162.94,44.42 PCH.AT7 ; SR139.2 v1(150.67,33.27)
  BOTTOM w0.089: v1(162.94,44.08) 162.94,43.94 162.34,43.35 162.12,43.35 161.71,42.94 160.77,42.94 157.29,39.46 157.29,38.87
  BOTTOM w0.102: v1(150.67,33.27) 151.1,33.27 155.31,37.48 155.89,37.48 v2(156.67,38.25) 157.29,38.87
PCH_DDPC_HPD3: length 10.1
  TOP w0.089: 158.64,39.15 158.64,40.91 PCH.BA1
  TOP w0.102: 158.64,39.15 158.64,38.82 158.16,38.35 v1(154.31,38.35) 153.95,38.35 153.9,38.4 SR664.2
  BOTTOM w0.102: v2(153.72,37.77) v1(154.31,38.35)
PCH_DDPD_CTRCLK: length 298
  TOP w0.089: v1(159,42.16) 159,42.62 159.34,42.96 159.85,42.96 PCH.AY1
  TOP w0.102: v1(19.71,173.2) 19.68,173.2 20.37,173.89 23.05,173.89 M1R13.2 24.13,174.1 MQ12.3
  BOTTOM w0.102: v1(19.71,173.2) 19.76,173.15 v2(19.76,172.09) 19.99,171.86 19.99,159.68 24.69,154.99 24.69,149.45 25.03,149.11 25.03,147.47 24.64,147.08 24.64,146.13 24.28,145.77 24.28,138.9 24.98,138.2 24.98,136.92 25.63,136.26 25.63,127.4 24.8,126.58 24.8,124.98 24.92,124.87 24.92,123.17 24.46,122.71 24.46,120.84 22.78,119.17 22.78,113.77 22.96,113.59 22.96,59.42 24.51,57.87 24.51,44.31 32.14,36.68 32.14,29.24 36.13,25.25 96.52,25.25 97.48,24.3 97.48,23.69 98.11,23.06 131.11,23.06 133.71,25.65 135.37,25.65 138.09,28.37 144.35,28.37 149.89,33.91 150.81,33.91 159,42.1 v1(159,42.16)
PCH_DDPD_CTRLDATA: length 300.8
  TOP w0.089: PCH.AY2 160.38,42.81 160.12,42.55 v1(159.51,42.55)
  TOP w0.102: MQ12.1 24.28,175.4 M1R12.2 23.03,174.14 19.87,174.14 v1(19.7,173.97)
  BOTTOM w0.102: v1(159.51,42.55) 159.51,42 151.2,33.69 149.97,33.69 144.44,28.16 138.2,28.16 135.45,25.4 133.76,25.4 131.1,22.73 97.51,22.73 97.26,22.98 97.26,24.21 96.79,24.68 95.66,24.68 95.31,25.04 36.04,25.04 31.93,29.15 31.93,36.59 24.3,44.22 24.3,57.78 22.75,59.33 22.75,113.49 22.47,113.77 22.47,119.15 24.24,120.93 24.24,122.8 24.7,123.26 24.7,124.78 24.54,124.94 24.54,126.62 25.41,127.49 25.41,136.17 24.76,136.83 24.76,138.11 23.67,139.2 23.67,141.24 23.05,141.87 23.05,142.8 23.7,143.45 23.7,147.96 23.94,148.2 23.94,149.19 24.47,149.72 24.47,154.9 19.38,159.99 v2(19.38,170.33) 19.24,170.47 19.24,173.51 v1(19.7,173.97)
PCH_DPWROK: length 146.8
  TOP w0.102: U104.28 219.74,25.67 219.02,26.39 219.02,27.03 v1(218.95,27.1) ; SC149.1 SR7637.1 134.05,27.1 v1(136.91,24.24) 136.91,23.17 139.6,20.48 139.6,18.72 144.73,13.59 150.02,13.59 150.78,12.83 150.99,12.62 151.48,12.62 154.99,9.12 156.94,9.12 157.8,8.26 168.24,8.26 v1(171.21,11.23) ; v1(162.05,40.64) 161.93,40.77 161.55,40.77 PCH.BD4
  BOTTOM w0.102: v1(171.21,11.23) 172.85,11.23 174.33,12.71 174.82,12.71 174.87,12.77 174.87,12.77 175.11,13 175.71,13 179.35,13 179.35,13.01 180.1,13.01 180.1,13 182.37,13 183.15,13 183.36,13.21 183.36,13.21 183.95,13.8 190.46,13.8 v2(190.69,14.03) 196.38,14.03 197.17,13.24 199.78,13.24 200.32,12.71 204.13,12.71 206.89,15.47 206.89,16.16 212.68,21.94 214.78,21.94 215.32,22.48 218.96,26.12 218.96,27.09 v1(218.95,27.1) ; v1(136.91,24.24) 139.14,26.48 146.54,26.48 149.8,29.74 152.65,29.74 152.97,30.06 156.5,30.06 156.73,29.83 158.08,29.83 159,30.76 159,34.17 161.11,36.27 161.11,38.1 162.05,39.04 v1(162.05,40.64)
PCH_H_TRST#: length 11.8
  TOP w0.102: v1(161.43,43.56) 161.35,43.64 160.89,43.64 PCH.AV2 ; SR280.2 v1(155.68,39.37)
  BOTTOM w0.102: v1(161.43,43.56) 160.43,43.56 160.09,43.22 158.89,43.22 157.28,41.61 157.28,40.97 v1(155.68,39.37) 155.27,38.96 v2(155.03,38.96)
PCH_JTAG_TCK: length 257.1
  TOP w0.089: PCH.AN1 159.15,46.12
  TOP w0.102: 85.47,106.05 84.45,107.07 81.32,107.07 77.28,111.11 75.43,111.11 72.66,108.35 54.82,108.35 51.63,105.16 49.24,105.16 43.22,99.14 35.41,99.14 29.3,93.03 29.3,74.91 32.99,71.22 32.99,63.27 v1(30.53,60.81) ; 159.15,46.12 155.64,42.61 154.01,42.61 153.94,42.54 152.23,42.54 151.84,42.94 144.64,42.94 144.24,43.34 140.7,43.34 139.79,42.43 SR160.1 139.79,39.22 v1(140.51,38.49)
  BOTTOM w0.102: v1(30.53,60.81) 31.5,59.84 31.5,48.92 45.36,35.05 81.23,35.05 82.13,35.95 121.98,35.95 122.43,35.51 122.58,35.51 123.18,34.91 129.88,34.91 130.07,35.1 138.05,35.1 139.7,36.75 v2(139.7,37.64) 139.7,37.68 v1(140.51,38.49)
PCH_PLTRST#: length 150.5
  TOP w0.089: 171.55,38.4 171.55,40.47 171.32,40.69 PCH.BD24
  TOP w0.102: v1(198.84,22.08) 200.29,20.62 203.64,20.62 204.4,19.86 213.32,19.86 214.69,21.24 214.69,22.15 SCB119.2 214.83,22.95 214.83,23.37 214.14,24.06 U104.14 ; Q5.2 102.64,12.32 v1(102.1,12.86) ; 171.55,38.4 171.55,37.2 174.27,34.47 174.89,34.47 175.48,33.88 175.48,31.51 174.84,30.87 174.84,29.08 175.11,28.81 175.11,27.89 178.41,24.59 v1(178.41,20.14)
  BOTTOM w0.102: v1(198.84,22.08) 198.43,21.67 189.59,21.67 189.15,22.11 182.67,22.11 181,20.43 180.49,20.43 180.48,20.43 178.7,20.43 v1(178.41,20.14) 177.38,19.11 168.79,19.11 168.04,19.87 160.1,19.87 157.37,17.14 157.31,17.14 157.31,17.15 156.95,17.15 156.95,17.14 v2(156.48,17.14) 155.62,17.14 154.97,16.49 149.47,16.49 149.25,16.28 139.08,16.28 134.56,11.76 121.67,11.76 121.52,11.91 120.83,12.6 119.68,12.6 119.47,12.38 104.06,12.38 103.98,12.3 102.66,12.3 v1(102.1,12.86)
PCH_PME#: length 28.3
  TOP w0.089: 167.2,37.4 167.28,37.49 167.28,38.61 166.87,39.03 166.87,39.54 PCH.BF15
  TOP w0.102: v1(167.18,28.36) 166.9,28.64 166.9,31.55 167.26,31.9 168.16,31.9 SR7713.2 ; v1(161.66,27.54) 161.91,27.79 161.91,28.52 163.02,29.62 163.02,30.47 163.19,30.65 163.88,30.65 SR115.2 164.6,30.48 164.6,32.44 167.2,35.04 v1(167.2,36.4) 167.2,37.4
  BOTTOM w0.102: v1(161.66,27.54) 162.97,27.54 163.1,27.66 166.48,27.66 v1(167.18,28.36) ; v2(167.06,37.39) 167.06,36.54 v1(167.2,36.4)
PCH_PWROK: length 122.7
  TOP w0.102: v1(207.77,46.43) OR65.2 207.41,47.44 MQ28.3 ; SR653.1 v1(152.02,33.53) ; PCH.BE4 161.14,40.42 v1(161.02,40.54) ; v1(172.29,15.91) 172.29,16.21 168.38,20.11 162.33,20.11 162.12,19.91 162.12,19.9 161.04,18.82 156.41,18.82 148.16,27.08 146.48,27.08 v1(145.36,28.19)
  BOTTOM w0.102: v1(161.02,40.54) 161.02,39.75 159.49,38.21 159.49,36.4 157.9,34.82 v2(154.28,34.82) 153.31,34.82 v1(152.02,33.53) 151.31,32.82 149.63,32.82 145.36,28.55 v1(145.36,28.19) ; v1(172.29,15.91) 172.77,16.4 173.63,16.4 174.28,15.75 176.85,15.75 178.21,15.75 182.01,15.75 182.81,16.55 187.31,16.55 189.34,18.58 198.18,18.58 201.85,22.26 201.85,23.47 208.7,30.31 210.09,30.31 211.32,31.54 211.32,34.41 211.3,34.42 211.3,34.97 211.32,34.98 211.32,35.03 211.89,35.6 211.89,38.02 211.56,38.35 211.56,38.64 211.56,38.64 211.56,40.15 209.7,42 209.7,44.5 v1(207.77,46.43)
PCH_RSMRST#: length 416.9
  TOP w0.089: v1(161.04,38.68) 161.24,38.68 161.86,39.3 PCH.BG5
  TOP w0.102: v1(85.05,112.52) 85.06,112.52 85.06,112.53 86.18,112.53 86.36,112.35 SR162.1 ; Q3.5 98.88,12.32 99.19,12.01 v1(99.19,11.11) ; v1(25.01,40.74) 25.01,52.88 33.86,61.72 33.86,71.58 30.17,75.27 30.17,92.68 35.73,98.23 43.54,98.23 49.6,104.29 51.99,104.29 55.15,107.45 73.01,107.45 74.35,108.79 78.16,108.79 v1(78.36,108.99) ; v1(23.83,34.14) 24,33.96 24,30.4 v1(23.42,29.82) ; v1(133.05,19.75) 135.06,17.74 135.06,12.22 v1(135.71,11.57) 138.63,8.65 144.13,8.65 145.29,9.8 146.17,9.8 146.8,9.18 146.8,8.47 147.38,7.89 150.61,7.89 150.82,7.67 168.55,7.67 171.97,11.09 171.97,13.71 v1(171.68,14.01) ; v1(212.5,32.13) 212.71,31.92 215.12,31.92 215.81,32.61 218.23,32.61 222.06,36.44 U104.58 ; v1(157.76,30.61) 157.95,30.41 SR336.1 SC148.1 157.95,28.16 156.53,26.74 v1(156.53,24.89)
  BOTTOM w0.102: v1(157.76,30.61) 158.06,30.91 158.06,31.63 158.5,32.06 158.5,34.17 160.85,36.52 160.85,38.5 v1(161.04,38.68) ; v1(133.05,19.75) 134.11,20.82 141.81,20.82 143.05,22.06 149.51,22.06 150.36,22.91 154.55,22.91 v1(156.53,24.89) ; v1(171.68,14.01) 172.03,14.36 173.52,14.36 173.52,14.36 174.13,14.36 174.42,14.66 176.4,14.66 178.66,14.66 180.78,14.66 180.78,14.66 181.69,14.66 181.69,14.66 182.46,14.66 183.26,15.46 187.76,15.46 187.85,15.54 189.35,17.04 193.42,17.04 194.3,17.92 198.45,17.92 202.51,21.98 202.51,23.19 208.76,29.44 210.14,29.44 212.5,31.79 v1(212.5,32.13) ; v1(135.71,11.57) 135.26,11.11 121.4,11.11 121.25,11.26 119.76,11.26 119.5,11.52 104.86,11.52 104.62,11.28 102.93,11.28 102.23,10.58 99.72,10.58 v1(99.19,11.11) 98.95,11.35 94.04,11.35 93.65,11.75 92.29,11.75 91.58,11.04 75.84,11.04 74.97,10.17 74.47,10.17 74.13,9.83 58.13,9.83 58,9.7 57.93,9.63 54.8,9.63 53.89,10.54 51.71,10.54 50.44,11.81 41.03,11.81 27.77,25.07 27.09,25.07 23.42,28.74 v1(23.42,29.82) ; v1(78.36,108.99) 82.06,112.69 82.76,112.69 82.93,112.52 v1(85.05,112.52) ; v1(25.01,40.74) 23.83,39.55 v2(23.83,35.86) v1(23.83,34.14)
PCH_SUSACK#: length 11.8
  TOP w0.089: 168.33,38.49 168.14,38.68 168.14,39.54 168.18,39.59 168.18,40.65 PCH.BD17
  TOP w0.102: v1(167.06,33.2) 167.74,32.51 SC175.1 168.16,32.92 168.92,32.92 SR119.2 168.81,34 168.81,34.54 168.33,35.03 168.33,38.49
  BOTTOM w0.102: v2(167.39,32.51) 167.39,32.86 v1(167.06,33.2)
PCH_SUSCLK: length 394.8
  TOP w0.102: v1(201.27,17.78) 201.27,17.32 201.71,16.88 201.71,13.5 202.55,12.66 203.43,12.66 204.66,11.44 204.66,9.43 207,7.09 207.94,7.09 M2R33.1 ; v1(25.02,39.62) 25.5,40.11 25.5,52.91 30.33,57.73 30.79,57.73 34.07,61.02 34.07,71.67 30.38,75.36 30.38,92.59 35.72,97.92 43.81,97.92 v1(47.57,101.68) ; ECR101.1 217.96,18.76 214.26,18.76 213.42,19.6 204.23,19.6 203.66,20.17 v1(203,20.17) 199.63,20.17 198.4,21.4 198.4,22.76 198.08,23.08 198.08,24.09 v1(197.87,24.31) ; v1(163.44,21.67) 163.44,22.39 165,23.95 165,25.38 165.13,25.51 165.8,25.51 SR7646.2 166.22,26.22 165.53,26.9 165.53,28.71 v1(165.2,29.04) ; v1(166.32,43.92) 166.11,43.7 PCH.AV13 ; J60.50 39.67,116.89 40.16,117.37 41.2,117.37 41.8,117.97 44.09,117.97 45.93,119.81 47.61,119.81 M2C53.1 50.13,119.74 52.32,119.74 52.7,119.36 53.74,119.36 54.18,118.92 54.18,118.49 55.7,116.97 57.56,116.97 57.96,116.56 57.96,115.41 56.57,114.02 52.83,114.02 49.59,110.77 v1(47.57,110.77)
  BOTTOM w0.089: 166.85,41.02 166.85,41.78 166.57,42.06 166.57,43.67 v1(166.32,43.92)
  BOTTOM w0.102: v1(201.27,17.78) 201.27,18.44 v1(203,20.17) ; v1(47.57,101.68) v1(47.57,110.77) ; 166.85,41.02 166.85,40.71 166.83,40.69 166.83,39.44 167.88,38.4 167.88,35.46 168.52,34.83 168.52,32.94 167.57,31.99 166.66,31.99 166.42,31.75 165.66,31.75 165.2,31.29 v1(165.2,29.04) ; v1(197.87,24.31) 197.87,23.94 196.76,22.83 195.99,22.83 195.26,23.56 182.29,23.56 180.46,21.73 177.77,21.73 176.45,20.41 169.33,20.41 168.58,21.17 164.58,21.17 164.07,21.67 v1(163.44,21.67) 162.96,21.19 159.55,21.19 157.11,18.75 155.39,18.75 154.63,17.99 148.38,17.99 147.75,17.36 137.33,17.36 133.44,13.46 130.14,13.46 129.55,12.87 123.35,12.87 122.75,13.46 105.6,13.46 105.12,13.94 92.26,13.94 90.98,12.66 86.9,12.66 86.06,13.51 62.13,13.51 62.04,13.41 59.96,13.41 59.73,13.64 57.59,13.64 57.14,13.19 55.27,13.19 54.81,13.65 40.87,13.65 28.6,25.92 28.6,27.01 25.58,30.03 25.58,37.74 v2(25.02,38.3) v1(25.02,39.62)
PCH_SUSWARN#: length 92.5
  TOP w0.089: 167.92,38.56 167.92,39.76 PCH.BF17
  TOP w0.102: v1(210.46,34.72) 210.74,34.44 216.23,34.44 216.6,34.81 218.33,34.81 218.54,35.03 220.03,35.03 220.6,35.59 220.6,36.73 221.83,37.96 221.83,39.08 222.17,39.42 223.72,39.42 223.86,39.56 224.47,39.56 224.69,39.78 224.69,40.89 223.53,42.05 223.53,42.28 223.35,42.46 222.9,42.46 ECR96.1 ; v1(167.36,25.11) 167.25,25.23 167.25,26.49 166.69,27.05 166.69,31.13 165.77,32.04 165.77,32.91 166.56,33.69 168.28,33.69 SR119.1 168.58,33.41 168.58,34.47 168.11,34.94 168.11,38.37 167.92,38.56
  BOTTOM w0.102: v1(210.46,34.72) 210.77,35.03 v2(210.77,35.43) 210.77,36.49 210.2,37.07 210.2,37.74 209.69,38.24 207.34,38.24 206.57,37.46 206.57,37.25 205.54,36.22 197.77,36.22 195.85,34.3 183.76,34.3 181.74,32.28 179.28,32.28 177.36,30.36 176.47,30.36 173.16,27.05 172.96,27.05 172.26,26.35 171.41,26.35 170.48,25.43 168.07,25.43 167.76,25.11 v1(167.36,25.11)
PCH_TGR_L900MIL: length 16.2
  TOP w0.089: 157.97,46.73 158.43,47.19 159.84,47.19 PCH.AL1
  TOP w0.102: SR281.1 146.19,45.42 v1(147.17,45.42) 147.76,45.42 148.08,45.1 151.68,45.1 151.73,45.15 156.39,45.15 157.97,46.73
  BOTTOM w0.102: v1(147.17,45.42) 147.87,45.42 v2(147.93,45.36)
PCHXDP_HOOK0_RSMRST#: length 6.6
  TOP w0.102: v1(90.39,107.67) 89.51,107.67 88.31,108.87 XDP2.39 87.48,109.69 SR162.2
  BOTTOM w0.102: v2(89.82,107.11) v1(90.39,107.67)
PCHXDP_PRDY#: length 266.2
  TOP w0.102: v1(149.61,41.1) 149.66,41.05 153.67,41.05 154.38,41.75 156,41.75 159.33,45.08 PCH.AR1 ; v1(29.51,61.67) 32.35,64.5 32.35,70.91 28.66,74.6 28.66,93.3 35.16,99.81 42.94,99.81 48.93,105.8 51.36,105.8 54.57,109.02 72.33,109.02 76.62,113.31 79.31,113.31 SR153.2 81.29,111.33 83.01,111.33 84.86,113.18 85.57,113.18 89.74,117.35 90.91,117.35 SR154.1
  BOTTOM w0.102: v1(29.51,61.67) 28.83,60.99 v2(28.83,59.41) 28.96,59.28 28.96,55.71 29.35,55.32 29.35,54.61 28.74,54 28.74,50.14 44.91,33.97 81.98,33.97 82.88,34.87 107.34,34.87 107.98,34.23 113.29,34.23 113.58,34.51 118.72,34.51 119.51,33.72 120.01,33.72 120.51,34.21 121.03,34.21 121.58,33.67 130.26,33.67 130.58,33.99 139.51,33.99 144.02,38.5 144.02,39.97 145.15,41.1 v1(149.61,41.1)
PCHXDP_PREQ_R#: length 269.5
  TOP w0.089: PCH.AU3 160.67,44.72 160.3,44.72 160.03,44.45 159.48,44.45 156.49,41.46
  TOP w0.102: SR7634.1 89.63,117.57 85.75,113.69 84.04,113.69 SR7635.2 83.11,112.76 83.11,112.39 82.52,111.8 81.37,111.8 79.65,113.53 76.53,113.53 72.24,109.23 54.48,109.23 51.27,106.02 48.84,106.02 42.85,100.02 35.07,100.02 28.44,93.39 28.44,74.51 32.13,70.82 32.13,65.02 v1(28.7,61.59) ; v1(145.7,39.88) 145.96,39.62 148,39.62 148.22,39.84 152.18,39.84 152.35,40.01 155.04,40.01 156.49,41.46
  BOTTOM w0.102: v1(145.7,39.88) 144.94,39.88 v2(144.81,39.75) 144.81,38.68 139.55,33.41 130.69,33.41 128.84,31.57 123.96,31.57 122.89,32.64 119.06,32.64 118.27,33.43 114.02,33.43 113.74,33.15 107.39,33.15 107.19,33.35 95.37,33.35 95.24,33.48 44.8,33.48 28.31,49.96 28.31,54.18 28.92,54.79 28.92,55.14 28.26,55.8 28.26,56.73 27.8,57.19 27.8,60.69 v1(28.7,61.59)
PCI_IRQA: length 19
  TOP w0.102: v1(165.25,43.21) 165.52,42.94 PCH.AY13 ; v1(162.81,28.12) 162.67,27.98 SR7638.2
  BOTTOM w0.089: v1(165.25,43.21) 165.72,42.74 165.72,40.34 165.21,39.83 165.21,37.78 166.36,36.63
  BOTTOM w0.102: v1(162.81,28.12) 162.48,28.45 162.48,29.09 162.99,29.6 v2(162.99,29.9) 162.99,30.81 166.36,34.17 166.36,36.63
PCIE-WAKE_C: length 6.5
  TOP w0.102: v1(44.86,125.58) 44.84,125.56 M2R4.1 43.47,125.09 41.55,125.09 40.92,124.46 J60.55
  BOTTOM w0.102: v1(44.86,125.58) 45.52,124.92 v2(45.67,124.92)
PCIE_RCOMPN_W15S15MIL: length 5.7
  TOP w0.089: 164.69,62.4 164.7,62.39 164.7,61.67 PCH.B10
  TOP w0.102: 164.69,62.4 164.69,63.58 163.02,65.25 162.47,65.25 SR401.1
PCIE_RCOMPP_W15S15MIL: length 5.7
  TOP w0.089: PCH.C10 164.88,61.34 164.88,62.32 164.89,62.33 164.89,62.38 164.89,62.39 164.89,62.5
  TOP w0.102: 164.89,62.5 164.89,63.67 SR401.2
PCIEX16_1_PNT1: length 4
  TOP w0.102: XR15.1 46.09,25.35 46.09,25.09 45.45,24.45 45.45,24.34 SLOT4.A1
PCIEX16_PNT1: length 3.5
  TOP w0.102: SLOT1.A1 45.45,85.58 45.45,85.58 XR11.1
PE4_2_A5: length 4.8
  TOP w0.102: SLOT2.A5 49.45,64.79 50.06,65.41 50.69,65.41 XR4.1
PE4_2_TRST#: length 6.5
  TOP w0.102: XR3.2 57.26,56.67 54.58,59.36 54.1,59.36 SLOT2.B9
PE4_3_A5: length 4
  TOP w0.102: XR20.1 49.75,45.36 49.75,43.28 49.45,42.98 SLOT3.A5
PE4_3_A6: length 1.8
  TOP w0.102: SLOT3.A6 50.45,44.93 50.19,45.19 XR18.2
PE4_3_A8: length 2.4
  TOP w0.102: SLOT3.A8 51.68,44.96 51.36,44.96 51.1,45.21 XR17.2
PE4_3_TRST#: length 7.2
  TOP w0.102: XR19.2 57.7,35.68 56.62,36.75 55.7,36.75 55.24,37.21 55.24,37.89 SLOT3.B9
PE5_RXN: length 131.4
  TOP w0.102: v1(168.39,57.35) 168.57,57.35 PCH.K19 ; SLOT2.A17 63.45,64.82 66.67,68.05 68.96,68.05 72.26,71.35 78.23,71.35 79.96,73.08 v1(80.26,73.08)
  BOTTOM w0.089: 170.49,61.92 170.5,61.92 170.5,61.76 170.5,61.76 170.5,60.45 170.18,60.13 170.18,59.51 170.13,59.46 170.13,58.42 169.73,58.02 169.22,58.02 168.81,57.6 168.81,57.44 168.71,57.35 v1(168.39,57.35)
  BOTTOM w0.102: 170.49,61.92 170.49,64.05 165.96,68.58 165.96,72.64 164.84,73.76 163.7,73.76 162.33,75.13 162.33,75.13 160.96,76.5 136.08,76.5 131.99,72.42 82.03,72.42 81.1,73.36 80.54,73.36 v1(80.26,73.08)
PE5_RXP: length 131.4
  TOP w0.102: v1(168.4,56.68) 168.66,56.68 PCH.L19 ; v1(79.81,73.56) 79.81,73.21 78.15,71.55 72.17,71.55 68.87,68.25 66.59,68.25 62.85,64.51 SLOT2.A16
  BOTTOM w0.089: v1(168.4,56.68) 168.99,57.27 168.99,57.53 169.3,57.84 169.8,57.84 170.31,58.34 170.31,59.39 170.36,59.44 170.36,60.05 170.68,60.38 170.68,61.84
  BOTTOM w0.102: 170.68,61.84 170.69,61.85 170.69,64.13 166.16,68.66 166.16,72.73 164.92,73.96 163.79,73.96 161.04,76.71 135.99,76.71 131.91,72.63 82.12,72.63 81.19,73.56 v1(79.81,73.56)
PE5_TXN: length 148.2
  TOP w0.076: PCH.D22 170.31,60.73 170.08,60.96 170.08,61.1 170.01,61.17 170.01,61.8 170.08,61.87 170.08,62.92 170.22,63.07
  TOP w0.102: v1(168.35,71.54) 168.94,71.54 169.31,71.17 169.31,70.75 170.43,69.62 170.43,67.82 170.54,67.72 170.54,63.38 170.22,63.07 ; SC61.1 62.34,67.23 62.34,67.69 62.57,67.92 65.28,67.92 66.29,68.94 68.59,68.94 71.89,72.24 74.55,72.24 77.72,75.41 v1(77.72,76.2)
  BOTTOM w0.102: v1(168.35,71.54) 168.23,71.65 168.23,73.66 170.64,76.07 170.64,76.44 171.64,77.44 171.64,82.7 167.21,87.13 162.63,87.13 154.07,78.57 135.19,78.57 135.11,78.57 131.79,75.25 90.82,75.25 89.4,73.84 88.54,73.84 85.96,73.84 85.43,74.37 81.01,74.37 80.63,74.75 78.23,74.75 77.72,75.26 v1(77.72,76.2)
PE5_TXN1_C: length 17
  TOP w0.102: M2C41.1 48.64,123.28 48.64,123.06 48.51,122.94 48.06,122.94 47.82,122.69 47.82,121.17 47.67,121.02 45.86,121.02 45.31,120.47 41.88,120.47 41.68,120.67 37.6,120.67 36.17,122.11 36.17,122.3 36.42,122.55 J60.37
PE5_TXN_C: length 10.4
  TOP w0.102: SLOT2.B15 61.45,59.24 61.32,59.11 61.32,58.78 61.44,58.65 61.65,58.65 62.28,59.28 62.28,62.92 61.47,63.73 61.47,64.88 62.02,65.43 62.28,65.43 62.41,65.56 62.41,65.7 62.03,66.08 SC61.2
PE5_TXP: length 148.2
  TOP w0.076: PCH.C22 170.19,61.25 170.19,61.73 170.26,61.8 170.26,62.82 170.36,62.92
  TOP w0.102: v1(168.66,72.11) 169.51,71.26 169.51,70.84 170.64,69.71 170.64,67.9 170.74,67.8 170.74,63.3 170.36,62.92 ; v1(78.4,76.2) 78.4,75.86 78.33,75.79 77.98,75.79 77.93,75.74 77.93,75.33 74.63,72.03 71.97,72.03 68.67,68.73 66.37,68.73 65.36,67.72 62.66,67.72 62.54,67.61 62.54,67.45 62.65,67.35 62.8,67.35 62.94,67.21 SC32.1
  BOTTOM w0.102: v1(78.4,76.2) 78.4,75.93 78.31,75.84 78.04,75.84 77.93,75.73 77.93,75.34 78.32,74.96 80.72,74.96 81.1,74.57 85.51,74.57 86.04,74.04 88.63,74.04 89.32,74.04 90.73,75.45 131.7,75.45 135.02,78.77 135.28,78.77 153.98,78.77 162.55,87.34 167.3,87.34 171.85,82.78 171.85,77.36 170.85,76.36 170.85,75.98 168.44,73.58 168.44,72.33 v1(168.66,72.11)
PE5_TXP1_C: length 17
  TOP w0.102: M2C40.1 48.58,122.73 48.15,122.73 48.02,122.61 48.02,121.09 47.75,120.82 45.95,120.82 45.4,120.27 41.8,120.27 41.6,120.47 37.52,120.47 35.97,122.02 35.97,122.45 35.92,122.5 J60.35
PE5_TXP_C: length 10.4
  TOP w0.102: SC32.2 62.61,65.75 62.61,65.47 62.37,65.23 62.1,65.23 61.67,64.8 61.67,63.81 62.48,63 62.48,59.2 61.73,58.45 60.88,58.45 SLOT2.B14
PE6_RXN: length 143.3
  TOP w0.102: SLOT2.A22 68.45,63.9 68.55,63.8 69.06,63.8 69.39,64.14 69.39,66.81 72.76,70.18 81.42,70.18 83.69,72.45 83.69,73.15 v1(83.46,73.38) ; PCH.G22 170.62,59.35 v1(170.74,59.23)
  BOTTOM w0.089: v1(170.74,59.23) 171.2,59.69 171.2,60.45 171.07,60.58 171.07,61.65 171.35,61.93
  BOTTOM w0.102: v1(83.46,73.38) 83.97,73.89 85.23,73.89 85.8,73.31 131.59,73.31 135.67,77.39 154.63,77.39 162.67,85.43 167.26,85.43 170.48,82.21 170.48,77.94 169.47,76.94 169.47,76.55 166.87,73.94 166.87,68.96 171.35,64.47 171.35,61.93
PE6_RXP: length 143.3
  TOP w0.102: SLOT2.A21 67.45,63.36 67.68,63.59 69.14,63.59 69.6,64.05 69.6,66.73 72.85,69.98 81.51,69.98 83.9,72.36 83.9,73.15 v1(84.1,73.36) ; PCH.E22 170.3,59.87 v1(170.77,59.87)
  BOTTOM w0.089: 171.15,61.99 171.15,61.98 170.89,61.72 170.89,60.5 171.02,60.38 171.02,60.11 v1(170.77,59.87)
  BOTTOM w0.102: v1(84.1,73.36) 84.1,73.58 84.2,73.69 85.14,73.69 85.72,73.11 131.67,73.11 135.75,77.19 154.72,77.19 162.75,85.22 167.18,85.22 170.27,82.13 170.27,78.03 169.29,77.04 169.27,77.02 169.27,76.64 166.66,74.03 166.66,68.87 171.15,64.39 171.15,61.99
PE6_TXN: length 144.4
  TOP w0.102: v1(169.75,72.54) 170.09,72.54 170.27,72.36 170.27,70.83 171.17,69.93 171.17,66.6 170.98,66.41 170.98,63.09 170.54,62.64 170.54,61.71 PCH.B22 ; v1(81.51,76.25) 81.25,76 81.25,75.12 81.55,74.82 81.55,72.16 80.05,70.66 72.54,70.66 69.24,67.36 67.51,67.36 67.44,67.28 SC63.1
  BOTTOM w0.102: v1(169.75,72.54) 169.75,72.54 170.22,73.01 170.22,74.12 171.53,75.44 171.53,76.05 172.53,77.06 172.53,83.07 167.58,88.02 162.2,88.02 153.68,79.5 134.75,79.5 133.46,78.21 131.98,78.21 129.91,76.14 90.45,76.14 89.03,74.73 86.33,74.73 85.79,75.26 81.66,75.26 81.28,75.64 81.28,76.02 v1(81.51,76.25)
PE6_TXN_C: length 8.9
  TOP w0.102: SC63.2 67.09,65.71 67.09,65.34 67.48,64.96 67.48,64.21 66.48,63.21 66.48,61.44 66.6,61.32 66.6,59.42 66.45,59.27 SLOT2.B20
PE6_TXP: length 144.5
  TOP w0.102: v1(169.72,73.2) 170.47,72.44 170.47,70.91 171.37,70.01 171.37,66.51 171.19,66.33 171.19,63.01 170.74,62.56 170.74,62.06 PCH.A23 ; SC62.1 66.52,67.21 66.77,67.46 67.33,67.46 67.43,67.56 69.16,67.56 72.46,70.87 79.96,70.87 81.34,72.25 81.34,74.74 81.05,75.03 81.05,76.05 v1(80.85,76.25)
  BOTTOM w0.102: v1(169.72,73.2) 170.01,73.49 170.01,74.21 171.33,75.53 171.33,76.14 172.33,77.14 172.33,82.98 167.5,87.82 162.29,87.82 153.76,79.29 134.83,79.29 133.54,78 132.06,78 130,75.94 90.53,75.94 89.12,74.52 86.24,74.52 85.71,75.06 81.58,75.06 81.08,75.56 81.08,76.02 v1(80.85,76.25)
PE6_TXP_C: length 8.9
  TOP w0.102: SC62.2 66.89,65.68 66.89,65.26 67.27,64.87 67.27,64.3 66.27,63.3 66.27,61.35 66.4,61.23 66.4,59.5 66.09,59.19 65.95,59.19 65.77,59.37 SLOT2.B19
PE7_RXN: length 118.8
  TOP w0.102: PCH.L22 169.84,57.06 v1(169.54,56.77)
  BOTTOM w0.102: v1(169.54,56.77) 168.74,55.97 165.93,55.97 163.86,58.04 163.86,58.44 162.53,59.77 162.53,61.77 162.18,62.13 160.39,62.13 160.02,62.5 155.74,62.5 153.07,65.17 145.79,65.17 143.48,62.87 128.75,62.87 123.24,57.35 115.71,57.35 115.08,56.72 76.1,56.72 75.31,57.52 75.31,58.65 74.24,59.72 74.24,63.1 73.43,63.91 73.43,65.47 73.13,65.77 71.79,65.77 71.65,65.63 71.65,63.81 71.96,63.5 72.16,63.5 72.6,63.65 72.68,63.81 SLOT2.A26
PE7_RXP: length 118.9
  TOP w0.102: PCH.K22 169.69,57.4 v1(169.54,57.4)
  BOTTOM w0.102: v1(169.54,57.4) 169.13,56.98 169.13,56.64 168.66,56.17 166.01,56.17 164.06,58.12 164.06,58.53 162.74,59.85 162.74,61.86 162.26,62.33 160.48,62.33 160.11,62.7 155.83,62.7 153.15,65.38 145.7,65.38 143.4,63.07 128.67,63.07 123.16,57.56 115.62,57.56 114.99,56.93 76.19,56.93 75.51,57.6 75.51,58.74 74.44,59.8 74.44,63.18 73.63,63.99 73.63,65.55 73.22,65.97 71.7,65.97 71.45,65.72 SLOT2.A25
PE7_TXN: length 142.4
  TOP w0.089: 171.26,62.16 171.26,62.15 171.26,61.78 171.17,61.69 171.17,61.16 PCH.C23
  TOP w0.102: SC157.1 71.48,67.2 71.48,67.56 73.13,69.22 73.37,69.22 82.08,69.22 85.45,72.59 85.45,73.89 84.25,75.08 v1(84.25,76.28) ; v1(171.21,73) 171.69,72.52 171.69,71.06 172.06,70.69 172.06,66.34 171.67,65.95 171.67,62.71 171.26,62.31 171.26,62.16
  BOTTOM w0.102: v1(171.21,73) 170.91,73.3 170.91,73.85 172.22,75.16 172.22,75.77 173.22,76.77 173.22,83.35 167.86,88.71 161.84,88.71 153.31,80.18 132.96,80.18 129.6,76.82 90.16,76.82 88.75,75.41 86.61,75.41 86.08,75.95 84.58,75.95 v1(84.25,76.28)
PE7_TXN_C: length 8.7
  TOP w0.102: SLOT2.B24 70.45,59.6 70.61,59.76 70.61,61.29 70.48,61.42 70.48,63.14 71.48,64.13 71.48,65.75 SC157.2
PE7_TXP: length 142.5
  TOP w0.089: 171.06,62.16 171.08,62.14 171.08,61.85 170.91,61.68 PCH.B23
  TOP w0.102: 171.06,62.16 171.06,62.39 171.47,62.79 171.47,66.03 171.86,66.42 171.86,70.6 171.49,70.97 171.49,72.1 v1(171.22,72.36) ; v1(83.62,76.28) 84.05,75.84 84.05,75 85.24,73.8 85.24,72.67 81.99,69.42 73.37,69.42 73.04,69.42 71.27,67.65 71.27,67.3 SC155.1
  BOTTOM w0.102: v1(171.22,72.36) 170.71,72.88 170.71,73.94 172.01,75.24 172.01,75.85 173.02,76.85 173.02,83.27 167.78,88.5 161.92,88.5 153.4,79.98 133.04,79.98 129.69,76.62 90.25,76.62 88.83,75.21 86.53,75.21 85.99,75.74 84.15,75.74 v1(83.62,76.28)
PE7_TXP_C: length 8.7
  TOP w0.102: SC155.2 71.27,65.65 71.27,64.22 70.27,63.22 70.27,61.34 70.41,61.21 70.41,59.84 69.85,59.28 69.6,59.28 69.45,59.43 SLOT2.B23
PE8_RXN: length 138.5
  TOP w0.102: v1(91.76,74.51) 92.05,74.21 92.05,73.79 90.83,72.57 90.83,71.66 85.54,66.37 82.24,66.37 79.35,63.48 76.12,63.48 75.9,63.7 75.83,64.11 75.98,64.35 SLOT2.A30 ; v1(170.8,57.89) 171.11,57.58 171.28,57.58 PCH.K24
  BOTTOM w0.089: 171.63,61.72 171.63,61.61 171.25,61.22 171.25,60.68 171.39,60.53 171.39,58.09 171.19,57.89 v1(170.8,57.89)
  BOTTOM w0.102: v1(91.76,74.51) 92.47,73.79 131.3,73.79 135.38,77.88 154.43,77.88 162.56,86.01 167.36,86.01 167.46,85.91 167.46,85.91 170.96,82.41 170.96,77.74 169.96,76.74 169.96,76.35 167.39,73.79 167.39,69.16 171.63,64.92 171.63,64.84 171.63,64.75 171.63,61.72
PE8_RXP: length 138.5
  TOP w0.102: v1(92.41,74.5) 92.25,74.34 92.25,73.71 91.03,72.49 91.03,71.57 85.62,66.17 82.32,66.17 79.44,63.28 76.22,63.28 SLOT2.A29 ; PCH.L24 171.2,57.38 170.93,57.38 v1(170.8,57.25)
  BOTTOM w0.089: 171.83,61.71 171.83,61.56 171.42,61.15 171.42,60.75 171.57,60.61 171.57,58.02 v1(170.8,57.25)
  BOTTOM w0.102: v1(92.41,74.5) 92.41,74.14 92.55,74 131.22,74 135.3,78.08 154.35,78.08 162.48,86.21 167.45,86.21 167.55,86.11 167.55,86.11 171.16,82.5 171.16,77.66 170.16,76.65 170.16,76.27 167.59,73.7 167.59,69.24 171.83,65 171.83,64.75 171.83,64.75 171.83,64.67 171.83,64.67 171.83,61.71
PE8_TXN: length 137.8
  TOP w0.089: PCH.C24 171.42,61.14 171.68,61.39 171.68,62.18 172.11,62.61 172.11,65.24 172.26,65.39
  TOP w0.102: v1(87.16,76.43) 86.92,76.19 86.92,72.58 82.18,67.84 75.13,67.84 74.83,67.54 74.83,67.3 SC156.1 ; v1(173.21,75.37) 173.21,73.32 172.38,72.49 172.38,71.35 172.75,70.99 172.75,65.87 172.26,65.39
  BOTTOM w0.102: v1(87.16,76.43) 87.5,76.1 88.47,76.1 89.88,77.51 129.32,77.51 132.69,80.88 152.97,80.88 161.49,89.4 168.14,89.4 174.09,83.45 174.09,76.67 173.21,75.79 v1(173.21,75.37)
PE8_TXN_C: length 8.8
  TOP w0.102: SC156.2 74.87,65.74 74.87,65.49 75.35,65.01 75.35,63.92 74.55,63.12 74.55,59.4 74.45,59.3 SLOT2.B28
PE8_TXP: length 137.7
  TOP w0.089: PCH.B24 171.5,61.65 171.5,62.25 171.93,62.68 171.93,65.35 171.98,65.4
  TOP w0.102: 171.98,65.4 172.54,65.96 172.54,70.91 172.18,71.27 172.18,72.57 173.01,73.4 173.01,74.66 v1(172.77,74.9) ; v1(86.51,76.45) 86.72,76.25 86.72,72.66 82.1,68.05 75.05,68.05 74.63,67.62 74.63,67.25 SC154.1
  BOTTOM w0.102: v1(86.51,76.45) 87.07,75.9 88.55,75.9 89.96,77.31 129.4,77.31 132.77,80.68 153.06,80.68 161.58,89.2 168.05,89.2 173.89,83.37 173.89,76.75 172.77,75.64 v1(172.77,74.9)
PE8_TXP_C: length 8.8
  TOP w0.102: SC154.2 74.66,65.71 74.66,65.41 75.15,64.93 75.15,64 74.35,63.2 74.35,59.49 74.17,59.31 73.66,59.31 73.45,59.52 SLOT2.B27
PE9_RXN: length 197.5
  TOP w0.102: SLOT3.A17 62.94,42.7 62.94,43.04 63.6,43.71 63.6,44.53 65.25,46.18 65.25,46.61 71.98,53.34 77.68,53.34 83.61,59.27 83.61,60.77 v1(83.82,60.98) ; v1(121.73,63.47) 121.51,63.68 121.51,63.94 122.21,64.64 123.43,64.64 136.91,78.12 136.91,84.94 145.9,93.94 155.42,93.94 157.79,96.31 175.84,96.31 177.85,94.3 178.71,94.3 188.11,84.9 188.11,83.68 189.34,82.46 189.34,76.39 186.76,73.81 183.69,73.81 179.29,69.41 179.29,67.86 v1(179.12,67.69) ; v1(175.44,58.83) 175.41,58.83 PCH.G31
  BOTTOM w0.102: v1(179.12,67.69) 179.5,67.31 179.5,66.73 177.32,64.55 177.32,61.11 176.35,60.15 176.35,59.06 175.84,58.55 175.72,58.55 v1(175.44,58.83) ; v1(83.82,60.98) 83.58,61.22 83.58,61.47 84.03,61.93 89.57,61.93 89.72,62.08 94.65,62.08 94.94,62.37 112.45,62.37 113.68,61.15 120.87,61.15 121.51,61.79 121.51,63.26 v1(121.73,63.47)
PE9_RXP: length 197.6
  TOP w0.102: PCH.H31 175.02,58.56 v1(175.41,58.17) ; v1(179.78,67.72) 179.49,68.01 179.49,69.32 183.78,73.61 186.84,73.61 189.54,76.31 189.54,82.54 188.32,83.77 188.32,84.99 178.8,94.51 177.93,94.51 175.93,96.51 157.71,96.51 155.33,94.14 145.82,94.14 136.7,85.02 136.7,78.21 123.34,64.85 122.13,64.85 121.31,64.03 121.31,63.66 v1(121.09,63.44) ; SLOT3.A16 63.03,43.61 63.22,43.61 63.4,43.79 63.4,44.61 65.05,46.26 65.05,46.69 71.9,53.54 77.6,53.54 83.41,59.35 83.41,60.73 v1(83.16,60.97)
  BOTTOM w0.102: v1(83.16,60.97) 83.38,61.18 83.38,61.56 83.95,62.13 89.48,62.13 89.63,62.28 94.56,62.28 94.86,62.58 112.54,62.58 113.76,61.35 120.78,61.35 121.31,61.87 121.31,63.22 v1(121.09,63.44) ; v1(175.41,58.17) 175.59,58.34 175.92,58.34 176.56,58.98 176.56,60.06 177.52,61.03 177.52,64.47 179.71,66.65 179.71,67.64 v1(179.78,67.72)
PE9_TXN: length 183.7
  TOP w0.076: 174.65,62.1 174.65,61.92 174.55,61.83 174.55,61.21 174.68,60.91 174.85,60.73 PCH.D31
  TOP w0.102: v1(81.82,59.65) 81.98,59.49 81.98,58.92 77.29,54.23 69.6,54.23 63.55,48.19 63.55,47.72 SC160.1 ; v1(114.63,59.02) 114.63,59.35 115.37,60.1 121.87,60.1 123.36,61.59 126.25,61.59 139.65,74.99 139.65,83.72 147.09,91.16 156.67,91.16 158.89,93.38 174.82,93.38 176.78,91.42 177.71,91.42 185.37,83.77 185.37,82.47 186.44,81.39 186.44,78.19 184.89,76.64 182.57,76.64 176.12,70.19 176.12,64.91 174.65,63.43 174.65,62.1
  BOTTOM w0.102: v1(81.82,59.65) 81.82,58.71 82.44,58.09 114.41,58.09 114.58,58.27 114.58,58.6 114.63,58.65 v1(114.63,59.02)
PE9_TXN_C: length 12.1
  TOP w0.102: SC160.2 63.55,46.16 63.55,45.93 62.88,45.26 62.18,45.26 61.39,44.48 61.39,43.26 62.33,42.32 62.33,38.96 61.85,38.48 61.27,38.48 61.14,38.61 61.14,38.76 61.45,39.07 SLOT3.B15
PE9_TXP: length 183.7
  TOP w0.076: 174.85,62.1 174.85,61.87 174.73,61.75 174.73,61.41 174.74,61.41 174.74,61.4 PCH.C31
  TOP w0.102: v1(82.49,59.64) 82.18,59.34 82.18,58.83 77.38,54.03 69.68,54.03 63.76,48.1 63.76,47.71 SC162.1 ; v1(114,59) 115.29,60.3 121.79,60.3 123.28,61.79 126.17,61.79 139.45,75.07 139.45,83.8 147.01,91.36 156.59,91.36 158.81,93.59 174.9,93.59 176.86,91.62 177.8,91.62 185.57,83.85 185.57,82.55 186.65,81.48 186.65,78.1 184.98,76.43 182.66,76.43 176.33,70.1 176.33,64.82 174.85,63.35 174.85,62.1
  BOTTOM w0.102: v1(114,59) 114.38,58.62 114.38,58.35 114.32,58.3 82.52,58.3 82.02,58.79 82.02,59.18 v1(82.49,59.64)
PE9_TXP_C: length 12.1
  TOP w0.102: SC162.2 63.75,46.16 63.75,45.85 62.97,45.06 62.26,45.06 61.59,44.39 61.59,43.34 62.53,42.4 62.53,38.88 61.93,38.28 61.04,38.28 SLOT3.B14
PE10_RXN: length 198.6
  TOP w0.102: SLOT3.A22 68.45,43.34 68.57,43.22 68.82,43.22 69.29,43.7 69.29,47.08 74.38,52.17 79.22,52.17 86.07,59.01 86.07,59.88 85.47,60.47 85.47,61.31 86.16,61.99 86.16,62.79 v1(85.95,62.99) ; PCH.G29 174.14,59.35 v1(174.47,59.02) ; v1(182.93,70.68) 182.7,70.92 182.7,71.55 184.02,72.87 187.32,72.87 190.28,75.83 190.28,82.8 189,84.07 189,85.27 178.99,95.28 178.15,95.28 176.22,97.21 157.35,97.21 154.96,94.83 145.52,94.83 136.02,85.33 136.02,78.51 123.07,65.57 120.3,65.57 119.03,64.29 119.03,63.67 v1(118.79,63.44)
  BOTTOM w0.089: v1(174.47,59.02) 175.07,59.61 175.07,60.03 175.05,60.05 175.05,60.4 175.27,60.63 175.28,60.63 175.31,60.66 175.34,60.66 175.35,60.67
  BOTTOM w0.102: v1(118.79,63.44) 119,63.23 119,62.48 118.55,62.03 114.11,62.03 112.81,63.34 94.55,63.34 94.19,62.98 88.52,62.98 88,63.5 86.46,63.5 v1(85.95,62.99) ; v1(182.93,70.68) 182.73,70.48 182.73,70.05 182.38,69.71 179.17,69.71 176,66.54 176,63.47 175.41,62.88 175.41,60.73 175.35,60.67
PE10_RXP: length 198.6
  TOP w0.102: PCH.E29 173.79,59.99 173.79,59.79 173.91,59.67 174.04,59.67 174.1,59.6 174.31,59.6 v1(174.47,59.77) ; v1(86.59,62.99) 86.36,62.75 86.36,61.9 85.68,61.22 85.68,60.55 86.27,59.96 86.27,58.93 79.31,51.97 74.47,51.97 69.49,47 69.49,43.61 68.9,43.02 68.28,43.02 SLOT3.A21 ; v1(119.46,63.46) 119.23,63.69 119.23,64.21 120.39,65.36 123.16,65.36 136.22,78.43 136.22,85.24 145.6,94.62 155.05,94.62 157.43,97.01 176.13,97.01 178.06,95.08 178.91,95.08 188.8,85.19 188.8,83.99 190.08,82.71 190.08,75.91 187.24,73.08 183.94,73.08 182.49,71.63 182.49,70.86 v1(182.29,70.66)
  BOTTOM w0.089: v1(174.47,59.77) 174.47,59.62 174.56,59.53 174.73,59.53 174.89,59.68 174.89,59.96 174.87,59.98 174.87,60.48 175.2,60.81
  BOTTOM w0.102: v1(182.29,70.66) 182.52,70.42 182.52,70.14 182.3,69.91 179.08,69.91 175.79,66.62 175.79,63.55 175.21,62.97 175.21,60.82 175.2,60.81 ; v1(86.59,62.99) 86.9,63.3 87.91,63.3 88.43,62.78 94.27,62.78 94.63,63.13 112.73,63.13 114.03,61.83 118.64,61.83 119.2,62.4 119.2,63.2 v1(119.46,63.46)
PE10_TXN: length 179.6
  TOP w0.089: 175.46,63.53 175.46,63.51 175.08,63.13 175.08,61.71 PCH.B31
  TOP w0.102: v1(126.67,63.8) 126.46,64.02 126.46,64.69 138.96,77.2 138.96,84.07 146.77,91.87 156.41,91.87 158.64,94.1 175.08,94.1 177.04,92.15 177.96,92.15 186.06,84.05 186.06,82.77 187.15,81.67 187.15,77.93 185.17,75.95 182.85,75.95 176.83,69.93 176.83,64.9 175.46,63.53 ; v1(84.98,59.66) 84.71,59.39 84.71,58.75 78.61,52.65 72.29,52.65 66.85,47.22 66.85,47 SC158.1
  BOTTOM w0.102: v1(126.67,63.8) 122.73,59.86 113.45,59.86 112.59,59 86.79,59 85.62,60.17 84.82,60.17 84.71,60.07 84.71,59.93 v1(84.98,59.66)
PE10_TXN_C: length 8.9
  TOP w0.102: SC158.2 66.84,45.44 66.84,45.14 67.46,44.52 67.46,43.78 66.65,42.97 66.65,38.88 66.45,38.67 SLOT3.B20
PE10_TXP: length 179.7
  TOP w0.089: PCH.A32 175.26,62.08 175.26,63.06 175.57,63.37 175.59,63.37 175.6,63.38
  TOP w0.102: SC164.1 66.65,47 66.65,47.3 72.2,52.86 78.53,52.86 84.5,58.83 84.5,59.52 v1(84.35,59.68) ; 175.6,63.38 177.04,64.82 177.04,69.84 182.94,75.74 185.26,75.74 187.36,77.85 187.36,81.75 186.26,82.85 186.26,84.13 178.04,92.35 177.12,92.35 175.17,94.31 158.56,94.31 156.33,92.08 146.69,92.08 138.76,84.15 138.76,77.28 126.25,64.78 126.25,64.03 v1(126.03,63.81)
  BOTTOM w0.102: v1(84.35,59.68) 84.51,59.84 84.51,60.15 84.73,60.38 85.7,60.38 86.88,59.2 112.5,59.2 113.36,60.06 122.64,60.06 126.03,63.45 v1(126.03,63.81)
PE10_TXP_C: length 8.9
  TOP w0.102: SLOT3.B19 66.25,38.89 66.37,38.89 66.45,38.96 66.45,43.05 67.26,43.87 67.26,44.43 66.64,45.06 66.64,45.47 SC164.2
PE11_RXN: length 200.7
  TOP w0.102: v1(174.4,56.77) 174.66,57.04 PCH.L31 ; v1(86.96,64.9) 87.14,64.72 87.14,64.26 88.2,63.2 88.2,59.04 79.96,50.8 76.9,50.8 73.15,47.04 73.15,43.74 72.66,43.25 72.24,43.25 72.11,43.38 72.11,43.85 SLOT3.A26 ; v1(117.49,63.79) 117.27,64.01 117.27,64.18 119.22,66.12 122.93,66.12 135.53,78.73 135.53,85.55 145.3,95.31 154.76,95.31 157.16,97.71 176.42,97.71 178.25,95.87 179.09,95.87 189.48,85.47 189.48,84.29 190.78,83 190.78,75.54 186.61,71.38 186.61,68.83 186.19,68.41 182.38,68.41 182.01,68.05 v1(182.01,67.46)
  BOTTOM w0.102: v1(174.4,56.77) 174.65,57.02 174.95,57.02 175.1,56.87 175.95,56.87 177.04,57.95 177.04,59.86 178.13,60.95 178.13,63.14 181.13,66.14 181.13,67.28 181.57,67.72 181.76,67.72 v1(182.01,67.46) ; v1(86.96,64.9) 87.2,64.66 87.2,64.36 87.5,64.06 88.52,64.06 89,63.58 93.78,63.58 94.1,63.9 112.98,63.9 114.24,62.64 116.74,62.64 117.22,63.12 117.22,63.52 v1(117.49,63.79)
PE11_RXP: length 200.7
  TOP w0.102: PCH.K31 174.74,57.8 v1(174.4,57.45) ; v1(87.61,64.92) 87.35,64.66 87.35,64.34 88.4,63.29 88.4,58.96 80.04,50.6 76.99,50.6 73.35,46.96 73.35,43.66 72.74,43.05 72.31,43.05 SLOT3.A25 ; v1(116.85,63.78) 117.07,64 117.07,64.26 119.14,66.33 122.84,66.33 135.33,78.82 135.33,85.63 145.21,95.51 154.68,95.51 157.08,97.91 176.5,97.91 178.34,96.08 179.17,96.08 189.69,85.56 189.69,84.38 190.98,83.09 190.98,75.46 186.82,71.3 186.82,68.75 186.28,68.21 182.77,68.21 v1(182.47,67.92)
  BOTTOM w0.102: v1(116.85,63.78) 117.02,63.61 117.02,63.2 116.65,62.84 114.33,62.84 113.06,64.1 94.02,64.1 93.69,63.78 89.09,63.78 88.6,64.26 87.59,64.26 87.4,64.45 87.4,64.71 v1(87.61,64.92) ; v1(182.47,67.92) 181.48,67.92 180.92,67.36 180.92,66.23 177.93,63.23 177.93,61.04 176.83,59.94 176.83,58.04 175.87,57.07 175.18,57.07 175.03,57.23 174.62,57.23 v1(174.4,57.45)
PE11_TXN: length 178.2
  TOP w0.089: PCH.C32 175.72,61.16 175.72,61.7 175.79,61.77 175.79,62.77 175.8,62.78 175.8,62.79 175.81,62.79
  TOP w0.102: v1(111.95,60.45) 112.15,60.65 112.15,61.04 112.48,61.37 121.84,61.37 138.07,77.6 138.07,84.44 146.4,92.77 155.98,92.77 158.27,95.06 175.4,95.06 177.4,93.06 178.3,93.06 186.94,84.42 186.94,83.16 188.05,82.05 188.05,77.5 185.6,75.06 183.24,75.06 177.8,69.61 177.8,64.91 175.81,62.92 175.81,62.79 ; v1(87.69,60.78) 87.55,60.64 87.55,59.09 79.75,51.28 74.8,51.28 70.89,47.37 70.89,46.77 SC165.1
  BOTTOM w0.102: v1(111.95,60.45) 112.19,60.22 112.19,60.02 112.06,59.89 88.61,59.89 87.71,60.78 v1(87.69,60.78)
PE11_TXN_C: length 9
  TOP w0.102: SC165.2 70.79,45.33 70.79,45.21 71.48,44.52 71.48,43.76 70.45,42.74 70.45,40.88 70.66,40.67 70.66,38.89 70.45,38.67 SLOT3.B24
PE11_TXP: length 178.2
  TOP w0.089: PCH.B32 175.53,61.48 175.53,61.78 175.62,61.86 175.62,62.77 175.6,62.78 175.6,62.79
  TOP w0.102: v1(87.05,60.77) 87.35,60.48 87.35,59.17 79.66,51.49 74.72,51.49 70.69,47.46 70.69,46.98 SC161.1 ; 175.6,62.79 175.6,63 177.6,65 177.6,69.7 183.16,75.26 185.52,75.26 187.85,77.59 187.85,81.97 186.74,83.08 186.74,84.34 178.22,92.86 177.31,92.86 175.32,94.85 158.36,94.85 156.06,92.56 146.48,92.56 138.28,84.36 138.28,77.51 121.93,61.16 112.56,61.16 112.36,60.96 112.36,60.71 v1(112.61,60.45)
  BOTTOM w0.102: v1(112.61,60.45) 112.39,60.24 112.39,59.93 112.15,59.68 88.52,59.68 87.86,60.35 87.48,60.35 v1(87.05,60.77)
PE11_TXP_C: length 9.1
  TOP w0.102: SC161.2 70.59,45.33 70.59,45.13 71.27,44.44 71.27,43.85 70.25,42.82 70.25,40.79 70.46,40.58 70.46,38.97 70.35,38.87 70.27,38.87 SLOT3.B23
PE12_RXN: length 200
  TOP w0.102: PCH.E33 175.76,59.93 v1(175.46,60.23) ; v1(183.26,66.82) 183.13,66.95 183.13,67.28 183.35,67.49 186.55,67.49 187.68,68.62 187.68,71.12 191.69,75.13 191.69,83.39 190.37,84.71 190.37,85.84 181.81,94.4 181.81,97.39 179.52,99.68 177.64,99.68 176.62,98.66 156.8,98.66 154.38,96.24 144.97,96.24 134.62,85.89 134.62,79.08 122.55,67.02 118.84,67.02 115.29,63.47 114.9,63.47 114.77,63.6 114.77,63.78 v1(114.98,63.99) ; SLOT3.A30 75.95,43.69 75.95,43.41 76.07,43.28 76.75,43.28 77.47,44 77.47,45.12 91.69,59.34 91.69,60.61 90.82,61.47 90.82,64.08 v1(90.62,64.28)
  BOTTOM w0.102: v1(183.26,66.82) 183.27,66.83 183.27,68.32 182.49,69.1 179.34,69.1 176.58,66.34 176.58,62.09 175.92,61.43 175.92,60.2 175.73,60.01 175.63,60.01 175.48,60.15 175.48,60.21 v1(175.46,60.23) ; v1(114.98,63.99) 114.75,64.22 114.75,64.66 114.36,65.05 91.06,65.05 90.82,64.81 90.82,64.49 v1(90.62,64.28)
PE12_RXP: length 200
  TOP w0.102: v1(182.6,66.83) 182.93,67.16 182.93,67.36 183.26,67.69 186.46,67.69 187.48,68.71 187.48,71.2 191.49,75.22 191.49,83.3 190.17,84.62 190.17,85.76 181.61,94.32 181.61,97.31 179.44,99.48 177.73,99.48 176.71,98.46 156.88,98.46 154.46,96.04 145.05,96.04 134.82,85.81 134.82,79 122.64,66.81 118.92,66.81 115.38,63.27 114.82,63.27 114.57,63.52 114.57,63.75 v1(114.34,63.99) ; v1(91.26,64.28) 91.03,64.05 91.03,61.56 91.89,60.69 91.89,59.25 77.67,45.03 77.67,43.92 76.83,43.08 75.67,43.08 75.45,42.86 SLOT3.A29 ; PCH.G33 175.9,59.44 175.81,59.54 v1(175.49,59.54)
  BOTTOM w0.102: v1(114.34,63.99) 114.55,64.19 114.55,64.57 114.27,64.85 91.15,64.85 91.03,64.72 91.03,64.53 91.26,64.3 v1(91.26,64.28) ; v1(175.49,59.54) 175.48,59.54 175.48,59.58 175.69,59.79 175.8,59.79 176.12,60.12 176.12,61.34 176.78,62 176.78,66.26 179.42,68.9 182.4,68.9 183.06,68.24 183.06,67.29 v1(182.6,66.83)
PE12_TXN: length 175.7
  TOP w0.102: SC163.1 74.96,46.77 74.96,47.32 77.55,49.91 81.36,49.91 90.1,58.65 90.1,60.18 v1(90.33,60.4) ; v1(110.41,61.12) 110.41,61.78 110.89,62.26 121.75,62.26 137.39,77.9 137.39,84.73 146.11,93.45 155.69,93.45 158.02,95.78 175.68,95.78 177.68,93.77 178.56,93.77 187.63,84.7 187.63,83.46 188.77,82.33 188.77,76.76 186.36,74.35 183.52,74.35 178.49,69.31 178.49,64.84 176.24,62.59 176.24,61.44 175.97,61.17 PCH.C33
  BOTTOM w0.102: v1(110.41,61.12) 110.41,61.46 110.25,61.62 95.54,61.62 94.92,61 90.34,61 90.22,60.87 90.22,60.52 v1(90.33,60.4)
