# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_DQ7: length 97.4
  TOP w0.102: 183.24,222.5 182.21,222.5 181.66,221.95 181.1,221.95 180.85,222.2 180.29,222.2 180.1,222.39 179.42,222.39 179.26,222.24 ; 183.24,222.5 183.36,222.5 183.46,222.4 183.95,222.4 184.75,222 186.84,221.75 CON_XMM1.155 ; 183.24,222.5 183.24,222.28 182.98,222.02 182.98,221.77 182.85,221.64 182.63,221.64 182.52,221.74 182.52,221.9 182.42,222.01 182.21,222.01 181.94,221.75 CON_XMM3.155 ; XU1.AG40 131.73,180.52 131.73,181.46 130.82,182.37
  TOP w0.159: 130.82,182.37 130.81,182.37 129.29,183.89 129.29,192.85 149.64,213.19 151.47,213.19 154.97,216.69 161.59,216.69 161.83,216.45 161.83,214.53 162.02,214.34 162.42,214.34 162.56,214.48 162.56,215.56 162.73,215.72 163,215.72 163.19,215.53 163.19,214.51 163.36,214.35 163.66,214.35 163.83,214.52 163.83,215.62 164.02,215.82 165.27,215.82 165.4,215.95 165.4,217.27 165.63,217.5 167.54,217.5 171.25,221.21 171.88,221.21 172.19,220.9 172.19,220.47 172.34,220.32 172.85,220.32 173.03,220.5 173.03,221.03 173.23,221.22 174.36,221.22 174.68,220.9 176.63,220.9 177.29,221.57 178.2,221.57 178.7,222.07 179.09,222.07 179.26,222.24
M_CHA_DQ8: length 85.7
  TOP w0.102: XU1.AJ38 133.68,178.56 133.15,179.1 133.15,180.8 133.19,180.84 133.19,181.38 131.53,183.04 ; 180.98,218.67 181.1,218.55 181.57,218.55 183.52,219.06 CON_XMM1.14 ; 180.98,218.67 180.9,218.59 180.48,218.59 180.07,218.99 179.47,218.99 179.33,218.85 ; 180.98,218.67 180.71,218.94 180.71,219.24 180.56,219.39 179.19,219.39 178.98,219.19 178.72,219.19 178.66,219.13 178.66,218.98 178.57,218.89 178.43,218.89 178.33,219 178.33,219.23 178.22,219.33 177.99,219.33 CON_XMM3.14
  TOP w0.159: 179.33,218.85 179.09,218.61 177.97,218.61 177.87,218.51 177.12,218.51 176.28,217.67 175.52,217.67 175.31,217.88 173.69,217.88 173.43,217.63 173.43,217.02 173.2,216.79 172.82,216.79 172.26,217.35 171.73,217.35 171.17,216.79 169.49,216.79 165.14,212.44 153.85,212.44 152.62,211.2 150.38,211.2 131.2,192.02 131.2,183.37 131.53,183.04
M_CHA_DQ9: length 86.9
  TOP w0.102: CON_XMM3.159 180.23,218.35 180.42,218.16 180.59,218.16 180.78,218.35 182.24,218.35 182.32,218.26 182.32,218.11 182.42,218.01 182.6,218.01 182.81,218.22 182.96,218.22 183.48,217.7 ; 131.98,182.93 133.39,181.51 133.39,180.67 133.35,180.63 133.35,179.29 133.63,179.01 133.76,179.01 134.05,178.71 134.05,178.01 XU1.AJ37 ; 183.48,217.7 184.22,217.7 184.96,218.44 186.49,218.44 186.58,218.35 CON_XMM1.159 ; 183.48,217.7 183.41,217.63 182.52,217.63 181.74,218.14 181.12,218.14 180.05,217.7 179.47,217.7 179.39,217.77
  TOP w0.159: 131.98,182.93 131.87,183.04 131.87,191.79 150.65,210.57 152.88,210.57 154.12,211.81 165.4,211.81 169.76,216.16 173.49,216.16 175.18,217.32 176.44,217.32 177.29,218.17 177.65,218.17 178.5,218.04 179.39,217.77
M_CHA_DQ10: length 84.7
  TOP w0.102: 177.09,210.2 177.24,210.05 177.85,210.05 178.14,210.34 178.3,210.34 ; 136.17,182.81 136.01,182.65 136.01,180.78 136.05,180.74 136.05,179.09 XU1.AL38 ; 185.18,210.05 185.08,210.05 184.24,210.89 183.06,210.89 182.88,211.07 182.45,211.07 182.07,210.7 CON_XMM3.168 ; 185.18,210.05 186.32,210.05 186.49,210.21 186.49,210.52 186.67,210.7 CON_XMM1.168 ; 185.18,210.05 185.18,209.87 185.09,209.78 184.75,209.78 184.03,210.49 183.41,210.49 183.31,210.4
  TOP w0.159: 183.31,210.4 183.12,210.2 181.85,210.2 181.63,209.98 181.12,209.98 180.81,210.3 180.29,210.3 180.04,210.54 179.52,210.54 179.31,210.34 178.3,210.34 ; 177.09,210.2 176.9,210.39 176.45,210.39 176.28,210.57 175.36,210.57 175.21,210.41 175.21,210.16 175.08,210.03 174.22,210.03 174.09,210.16 174.09,210.36 173.89,210.56 173.63,210.56 173.51,210.44 173.51,209.57 173.3,209.36 172.87,209.36 172.75,209.49 172.75,210.4 172.56,210.59 172.23,210.59 172.09,210.44 172.09,209.5 171.95,209.36 171.56,209.36 171.4,209.52 171.4,210.31 171.2,210.52 170.89,210.52 170.69,210.31 170.69,209.49 170.55,209.36 170.25,209.36 170.03,209.58 169.83,209.58 167.21,206.95 165.07,206.95 163.04,204.92 161.07,204.92 160.97,205.03 160.65,205.03 160.55,204.92 158.57,204.92 158.45,204.8 158.45,204.51 157.88,203.95 150.8,203.95 136.77,189.92 136.77,183.41 136.17,182.81
M_CHA_DQ11: length 85.8
  TOP w0.102: 179.45,212.65 179.37,212.57 178.7,212.57 ; 179.45,212.65 179.51,212.6 180.02,212.6 181.48,213.25 CON_XMM1.21 ; 179.45,212.65 178.96,213.15 178.96,213.35 178.88,213.43 178.76,213.43 178.68,213.35 178.68,213.16 178.59,213.07 178.46,213.07 178.37,213.16 178.37,213.32 178.24,213.44 176.57,213.44 CON_XMM3.21 ; XU1.AL37 135.15,178.01 135.15,180.57 135.22,180.65 135.22,181.52 134.99,181.75 134.99,182.26 134.69,182.56
  TOP w0.159: 134.69,182.56 134.69,190.53 151,206.85 151.45,206.85 151.66,206.63 151.66,206.04 151.79,205.92 152.2,205.92 152.45,206.17 152.45,206.68 152.62,206.85 153.49,206.85 154.36,207.71 156.34,207.71 156.65,208.03 157.05,208.03 157.36,207.71 157.93,207.71 158.12,207.9 158.12,208.61 158.35,208.85 158.69,208.85 158.85,208.68 158.85,207.88 159.02,207.71 159.43,207.71 159.56,207.85 159.56,208.68 159.73,208.85 160.03,208.85 160.2,208.68 160.2,207.88 160.36,207.71 160.67,207.71 160.86,207.91 160.86,208.66 161.05,208.85 161.38,208.85 161.54,208.68 161.54,207.87 161.71,207.71 161.94,207.71 162.2,207.98 162.2,208.68 162.37,208.85 162.69,208.85 162.86,208.67 162.86,208.31 163.03,208.15 163.36,208.15 163.52,208.31 163.52,208.67 163.69,208.84 166.42,208.84 170.52,212.93 170.96,212.93 171.31,212.58 172.75,212.58 173.11,212.94 173.57,212.94 173.93,212.58 176.28,212.58 176.45,212.75 176.97,212.75 177.32,213.11 177.93,213.11 178.46,212.57 178.7,212.57
M_CHA_DQ12: length 83.5
  TOP w0.102: 180.98,216.97 180.9,216.89 180.48,216.89 180.07,217.29 179.47,217.29 179.32,217.14 ; 180.98,216.97 181.1,216.85 181.57,216.85 183.52,217.29 CON_XMM1.16 ; 180.98,216.97 180.45,217.5 178.88,217.5 178.81,217.42 178.81,217.22 178.71,217.12 178.5,217.12 178.41,217.21 178.41,217.66 178.32,217.76 178.08,217.76 CON_XMM3.16 ; XU1.AJ40 133.68,181.53 132.5,182.72 132.5,183.51
  TOP w0.159: 179.32,217.14 178.98,216.81 177.1,216.81 176.26,215.97 175.73,215.97 175.68,216.02 174.46,216.02 173.98,215.53 170.02,215.53 165.66,211.18 157.08,211.18 156.75,210.85 156.75,210.64 156.53,210.42 156.25,210.42 156.09,210.59 156.09,210.93 155.91,211.11 155.64,211.11 155.48,210.94 155.48,210.57 155.31,210.4 155,210.4 154.84,210.57 154.84,210.94 154.67,211.11 154.44,211.11 154.25,210.92 154.25,210.57 154.09,210.4 153.71,210.4 153.34,210.03 153.24,209.93 152.44,209.93 152.27,209.77 152.27,209.24 152.11,209.07 151.56,209.07 151.39,209.24 151.39,209.77 151.23,209.93 150.91,209.93 132.5,191.52 132.5,183.51
M_CHA_DQ13: length 84.5
  TOP w0.102: 183.48,216 184.4,216 184.71,216.31 184.71,216.38 184.97,216.65 CON_XMM1.161 ; 183.48,216 183.08,215.85 182.4,215.85 181.8,216.44 180.94,216.44 180.77,216.27 ; 183.48,216 183.07,216.41 182.86,216.41 182.63,216.18 182.52,216.18 182.45,216.26 182.45,216.56 182.36,216.65 CON_XMM3.161 ; 133.93,181.62 133.93,180.68 134.01,180.6 134.01,180.19 133.68,179.86 XU1.AJ39
  TOP w0.159: 133.93,181.62 133.12,182.42 133.12,191.25 150.66,208.79 150.95,208.79 151.33,208.41 152.62,208.41 152.86,208.65 152.86,209.02 153.15,209.3 153.51,209.3 153.95,209.74 154.29,209.74 154.4,209.86 154.69,209.86 154.81,209.74 155.51,209.74 155.63,209.86 155.98,209.86 156.1,209.74 156.83,209.74 157.64,210.55 165.92,210.55 170.24,214.86 171.52,214.86 172.01,214.38 172.29,214.38 172.78,214.86 174.14,214.86 174.41,214.59 174.71,214.59 175,214.88 175,215.09 174.85,215.24 174.85,215.49 174.98,215.62 176.45,215.62 177.36,216.53 177.8,216.53 178.11,216.22 179.23,216.22 179.49,215.96 180.06,215.96 180.25,216.15 180.65,216.15 180.77,216.27
M_CHA_DQ14: length 83.1
  TOP w0.102: 136.14,183.21 135.81,182.87 135.81,180.65 135.84,180.61 135.84,179.81 XU1.AL39 ; 177.03,211.23 177.14,211.34 177.86,211.34 178.42,210.78 178.97,210.78 179.47,210.89 ; CON_XMM1.23 183.17,211.34 181.06,211.34 179.92,210.89 179.47,210.89 ; 179.47,210.89 179.11,211.25 179.11,211.49 179.04,211.56 178.88,211.56 178.8,211.47 178.8,211.28 178.7,211.19 178.57,211.19 178.48,211.28 178.48,211.42 178.35,211.55 CON_XMM3.23
  TOP w0.159: 177.03,211.23 176.82,211.01 176.41,211.01 176.28,210.88 175.59,210.88 175.35,211.12 175.12,211.12 174.79,210.79 174.54,210.79 174.12,211.22 170.58,211.22 166.94,207.58 164.81,207.58 162.79,205.56 161.3,205.56 161.14,205.72 161.14,206.13 160.93,206.34 160.69,206.34 160.5,206.15 160.5,205.75 160.31,205.56 160.02,205.56 159.87,205.71 159.87,206.16 159.74,206.29 159.37,206.29 159.23,206.15 159.23,205.69 159.11,205.56 158.74,205.56 158.57,205.72 158.57,206.2 158.37,206.4 157.99,206.4 157.81,206.22 157.81,204.77 157.62,204.58 157.22,204.58 157.05,204.75 157.05,206.22 156.88,206.4 156.58,206.4 156.39,206.21 156.39,204.75 156.23,204.58 155.9,204.58 155.73,204.75 155.73,206.16 155.57,206.32 155.24,206.32 155.07,206.16 155.07,204.75 154.91,204.58 150.53,204.58 136.14,190.19 136.14,183.21
M_CHA_DQ15: length 82
  TOP w0.102: 185.18,211.75 185.08,211.75 184.24,212.59 183.12,212.59 182.96,212.75 182.5,212.75 182.14,212.4 CON_XMM3.166 ; 185.18,211.75 186.22,211.75 186.39,211.91 186.39,212.14 186.64,212.4 CON_XMM1.166 ; 185.18,211.75 185.18,211.51 185.06,211.38 184.85,211.38 184.03,212.19 183.41,212.19 183.32,212.1 ; XU1.AL40 135.51,181.86 135.5,181.87 ; 178.33,212.06 178.16,212.06 177.85,211.75 177.26,211.75 177.13,211.88
  TOP w0.159: 178.33,212.06 179.29,212.06 179.46,212.22 180.08,212.22 180.36,211.94 180.86,211.94 181.09,211.71 181.66,211.71 181.85,211.9 183.12,211.9 183.32,212.1 ; 177.13,211.88 176.93,212.08 176.4,212.08 176.16,212.32 175.75,212.32 175.35,211.92 170.4,211.92 166.68,208.21 164.39,208.21 162.5,206.32 161.85,206.32 161.09,207.09 154.86,207.09 154.44,206.67 154.44,205.38 154.27,205.22 153.91,205.22 153.75,205.38 153.75,205.88 153.53,206.1 153.23,206.1 153.01,205.88 153.01,205.38 152.84,205.22 151.48,205.22 151.1,205.59 150.64,205.59 135.5,190.45 135.5,181.87
M_CHA_DQ16: length 77.2
  TOP w0.102: XU1.AN38 136.81,179.09 136.81,180.71 136.85,180.74 136.85,183.11 137.25,183.51 ; CON_XMM1.25 183.19,209.64 180.99,209.64 179.91,209.19 179.47,209.19 ; 179.47,209.19 179.12,209.54 179.12,209.77 179.04,209.85 178.93,209.85 178.85,209.77 178.85,209.58 178.75,209.49 178.62,209.49 178.53,209.58 178.53,209.75 178.44,209.85 CON_XMM3.25 ; 179.47,209.19 178.99,209.04 178.45,209.04 177.85,209.64 177.27,209.64 177.1,209.47
  TOP w0.159: 177.1,209.47 176.81,209.18 175.51,209.18 175.24,209.45 174.35,209.45 173.63,208.73 169.87,208.73 167.47,206.32 165.33,206.32 163.3,204.3 159.13,204.3 158.14,203.31 155.05,203.31 154.88,203.15 154.88,202.54 154.6,202.26 154.36,202.26 154.22,202.39 154.22,203.15 154.06,203.31 153.73,203.31 153.56,203.15 153.56,202.24 153.4,202.08 153.07,202.08 152.9,202.24 152.9,203.15 152.74,203.31 152.41,203.31 152.24,203.15 152.24,202.25 152.08,202.08 151.75,202.08 151.58,202.25 151.58,203.15 151.42,203.31 151.06,203.31 150.82,203.07 150.82,202.74 150.7,202.61 150.36,202.61 137.41,189.66 137.41,183.67 137.25,183.51
M_CHA_DQ17: length 75
  TOP w0.102: 138.56,183.51 137.34,182.3 XU1.AN40 ; 179.47,207.49 179.02,207.34 178.48,207.34 177.88,207.94 177.26,207.94 177.09,207.77 ; 179.47,207.49 179.92,207.49 181.12,207.94 183.15,207.94 CON_XMM1.27 ; 179.47,207.49 179.12,207.84 179.12,208.07 179.04,208.16 178.93,208.16 178.85,208.07 178.85,207.88 178.75,207.79 178.62,207.79 178.53,207.88 178.53,208.03 178.41,208.15 CON_XMM3.27
  TOP w0.159: 177.09,207.77 176.94,207.62 176.41,207.62 176.26,207.46 175.62,207.46 175.27,207.81 174.74,207.81 174.33,207.4 172.3,207.4 172.14,207.24 172.14,206.4 171.93,206.2 171.35,206.2 171.17,206.38 171.17,207.04 170.89,207.31 170.24,207.31 168,205.07 165.85,205.07 163.82,203.04 159.67,203.04 158.72,202.1 158.72,200.98 158.47,200.72 158.2,200.72 158.06,200.86 158.06,201.88 157.9,202.05 157.52,202.05 157.35,201.88 157.35,200.61 157.19,200.44 156.82,200.44 156.69,200.57 156.69,201.86 156.5,202.05 156.17,202.05 156.01,201.88 156.01,201.01 155.8,200.81 152.81,200.81 152.43,200.44 151.91,200.44 151.54,200.81 150.36,200.81 138.68,189.13 138.68,183.64 138.56,183.51
M_CHA_DQ18: length 75.8
  TOP w0.102: XU1.AR38 139.62,179.01 139.62,179.59 139.98,179.94 140.22,179.94 140.53,180.26 140.53,180.79 140.97,181.23 ; 183.24,202.01 183.86,202.01 185.71,201.35 CON_XMM1.179 ; 183.24,202.01 183.24,201.84 182.8,201.4 182.8,201.11 182.53,200.84 182.14,200.84 181.81,201.17 180.83,201.17 180.65,201.35 CON_XMM3.179 ; 183.24,202.01 182.75,202.01 182.52,201.78 181.9,201.78 181.66,201.54 181.09,201.54 180.89,201.74 180.3,201.74 180.07,201.96 180.05,201.96 180.02,201.99 179.48,201.99 179.45,201.96 179.44,201.96 179.28,201.81
  TOP w0.159: 179.28,201.81 179.07,201.59 179.07,201.26 178.86,201.04 177.99,201.04 177.84,201.19 177.3,201.19 176.42,200.32 175.45,200.32 175.13,200 169.9,200 168.66,198.76 168.66,196.37 165.58,193.29 157.15,193.29 156.91,193.06 156.64,193.06 156.38,193.31 156.1,193.31 155.91,193.12 155.91,192.84 156.16,192.59 156.16,192.31 155.97,192.11 155.69,192.11 155.44,192.37 155.16,192.37 154.96,192.18 154.96,191.9 155.22,191.64 155.22,191.37 155.03,191.17 154.75,191.17 154.49,191.43 154.22,191.43 154.02,191.23 154.02,190.96 154.28,190.7 154.28,190.42 154.08,190.23 153.81,190.23 153.55,190.48 153.27,190.48 153.08,190.29 153.08,190.01 153.33,189.76 153.33,189.48 153.14,189.28 152.86,189.28 152.61,189.54 152.33,189.54 152.13,189.35 152.13,189.07 152.39,188.81 152.39,188.54 152.2,188.34 151.92,188.34 151.66,188.6 151.39,188.6 151.19,188.4 151.19,188.13 151.45,187.87 151.45,187.59 151.25,187.4 150.98,187.4 150.72,187.65 150.44,187.65 150.25,187.46 150.25,187.18 150.5,186.93 150.5,186.65 150.31,186.45 150.03,186.45 149.78,186.71 149.5,186.71 149.3,186.52 149.3,186.24 149.56,185.98 149.56,185.71 149.37,185.51 148.73,185.51 148.48,185.26 148.48,184.87 148.65,184.7 148.96,184.7 149.12,184.53 149.12,184.2 148.89,183.97 147.27,183.97 145.67,182.37 142.8,182.37 142.32,181.89 142.32,181.38 142.16,181.23 140.97,181.23
M_CHA_DQ19: length 76.9
  TOP w0.102: 180.92,204.56 181.25,204.56 181.51,204.54 182.42,204.26 183.61,204.09 184.23,204.02 184.74,203.9 CON_XMM1.32 ; 180.92,204.56 180.92,204.44 180.37,203.89 178.63,203.89 178.53,203.79 ; 180.92,204.56 180.51,204.56 180.04,204.09 179.51,204.09 179.12,204.48 179.12,204.7 179.03,204.8 178.87,204.8 178.8,204.72 178.8,204.42 178.6,204.22 178.45,204.22 178.12,203.9 CON_XMM3.32 ; 139.8,182.58 139.15,181.93 139.15,180.91 138.8,180.56 138.8,178.01 XU1.AR37
  TOP w0.159: 178.53,203.79 177.97,203.23 177.14,203.23 176.48,203.89 175.54,203.89 174.42,202.77 169.47,202.77 166.78,200.08 166.78,197.15 164.85,195.22 150.09,195.22 149.88,195.01 149.88,194.74 150.48,194.14 150.48,193.86 150.28,193.67 150.01,193.67 149.41,194.27 149.13,194.27 148.93,194.07 148.93,193.79 149.53,193.19 149.53,192.92 149.34,192.72 149.06,192.72 148.46,193.32 148.19,193.32 147.99,193.13 147.99,192.85 148.59,192.25 148.59,191.97 148.4,191.78 148.12,191.78 147.49,192.4 147.19,192.4 147,192.21 147,191.96 147.36,191.6 147.36,190.29 146.58,189.5 146.58,185.95 144.63,184 141.91,184 140.49,182.58 139.8,182.58
M_CHA_DQ20: length 75.9
  TOP w0.102: 177.09,208.5 177.24,208.35 177.85,208.35 178.14,208.64 178.3,208.64 ; 183.31,208.69 183.41,208.79 184.03,208.79 184.78,208.04 185.06,208.04 185.19,208.18 185.19,208.33 ; CON_XMM1.170 186.67,209 186.44,208.76 186.44,208.53 186.23,208.33 185.19,208.33 ; 185.19,208.33 185.07,208.33 184.23,209.17 183.08,209.17 182.91,209.35 182.47,209.35 182.12,209 CON_XMM3.170 ; 138.04,183.51 137.12,182.59 137.12,180.71 137.01,180.6 137.01,180.13 137.34,179.8 XU1.AN39
  TOP w0.159: 138.04,183.51 138.04,189.4 150.09,201.45 154.68,201.45 155.91,202.68 158.41,202.68 159.4,203.67 163.56,203.67 165.59,205.7 167.74,205.7 170.13,208.09 174.16,208.09 174.52,208.46 174.52,208.64 174.71,208.82 176.77,208.82 177.09,208.5 ; 183.31,208.69 183.1,208.48 181.83,208.48 181.68,208.33 181.07,208.33 180.76,208.65 180.43,208.65 180.26,208.82 179.48,208.82 179.2,208.53 178.81,208.53 178.71,208.64 178.3,208.64
M_CHA_DQ21: length 77.8
  TOP w0.102: XU1.AN37 137.34,177.67 137.71,178.04 137.71,178.78 137.69,178.8 137.69,180.57 137.58,180.68 137.58,182.03 139.06,183.51 ; 185.08,206.65 186.2,206.65 186.85,207.3 CON_XMM1.172 ; 185.08,206.65 184.92,206.49 184.64,206.49 184.03,207.09 183.42,207.09 183.3,206.97 ; 185.08,206.65 184.49,207.24 184.49,207.33 184.33,207.49 183.16,207.49 182.96,207.29 182.58,207.29 182.4,207.47 182.14,207.47 181.97,207.3 CON_XMM3.172
  TOP w0.159: 139.06,183.51 139.31,183.76 139.31,188.87 150.49,200.05 151.41,200.05 151.65,199.81 152.69,199.81 153.06,200.18 153.52,200.18 153.89,199.81 154.24,199.81 154.61,200.17 154.89,200.17 155.25,199.81 155.49,199.81 155.83,200.15 156.21,200.15 156.56,199.81 158.44,199.81 159.44,200.8 159.44,201.91 159.94,202.41 164.08,202.41 166.11,204.44 168.26,204.44 169.32,205.5 172.78,205.5 173.2,205.92 173.58,205.92 174.01,205.5 174.41,205.5 174.88,205.96 174.88,206.62 175.4,207.14 176.25,207.14 176.54,206.84 177.03,206.84 177.27,206.61 177.88,206.61 178.08,206.81 179.14,206.81 179.46,207.14 180.04,207.14 180.39,206.79 180.92,206.79 181.1,206.61 181.71,206.61 181.9,206.8 183.14,206.8 183.3,206.97
M_CHA_DQ22: length 74.3
  TOP w0.102: 180.97,202.84 180.51,202.84 180.06,202.39 179.38,202.39 179.11,202.67 179.11,202.88 179.02,202.97 178.89,202.97 178.8,202.88 178.8,202.52 178.7,202.42 178.01,202.42 CON_XMM3.34 ; 180.97,202.84 180.97,202.84 180.97,202.72 180.44,202.19 179.1,202.19 178.96,202.06 ; 180.97,202.84 181.61,202.84 181.89,202.77 183.15,202.46 183.87,202.35 184.72,202.27 CON_XMM1.34 ; XU1.AR39 139.51,179.82 139.51,180.42 139.66,180.56 139.66,181.32 139.95,181.61
  TOP w0.159: 178.96,202.06 178.58,201.68 178.03,201.68 177.88,201.53 177.12,201.53 176.26,200.67 175.51,200.67 175.26,200.91 169.77,200.91 168.03,199.17 168.03,196.63 165.35,193.95 155.51,193.95 155.08,193.52 154.8,193.52 154.39,193.93 154.12,193.93 153.92,193.73 153.92,193.46 154.33,193.05 154.33,192.77 154.14,192.58 153.86,192.58 153.45,192.99 153.17,192.99 152.98,192.79 152.98,192.52 153.39,192.11 153.39,191.83 153.19,191.63 152.92,191.63 152.51,192.04 152.23,192.04 152.03,191.85 152.03,191.57 152.44,191.16 152.44,190.89 152.25,190.69 151.97,190.69 151.56,191.1 151.29,191.1 151.09,190.9 151.09,190.63 151.5,190.22 151.5,189.94 151.31,189.75 151.03,189.75 150.62,190.16 150.34,190.16 150.15,189.96 150.15,189.69 150.56,189.28 150.56,189 150.36,188.8 150.09,188.8 149.57,189.32 149.3,189.32 149.1,189.12 149.1,188.84 149.61,188.33 149.61,188.06 149.42,187.86 149.14,187.86 148.73,188.27 148.46,188.27 148.26,188.07 148.26,187.8 148.77,187.29 148.77,186.87 148.51,186.61 148.23,186.61 147.85,186.23 147.85,185.45 145.39,182.98 142.6,182.98 141.22,181.61 139.95,181.61
M_CHA_DQ23: length 73.1
  TOP w0.102: CON_XMM1.177 184.86,203.05 184.2,203.71 183.46,203.71 ; CON_XMM3.177 180.29,203.05 180.42,203.17 180.85,203.17 180.98,203.05 181.74,203.05 181.96,203.12 182.16,203.33 182.45,203.33 182.55,203.22 182.55,203.15 182.67,203.03 182.81,203.03 183.02,203.24 183.02,203.26 183.46,203.71 ; 183.46,203.71 183.36,203.8 182.22,203.8 181.67,203.25 181.08,203.25 180.83,203.5 180.23,203.5 180.05,203.69 179.46,203.69 179.15,203.37 ; 139.9,182.09 139.39,181.57 139.39,180.6 XU1.AR40
  TOP w0.159: 179.15,203.37 178.7,203.37 178.2,202.87 177.28,202.87 176.62,202.21 175.23,202.21 174.88,201.85 169.8,201.85 167.41,199.46 167.41,196.89 165.1,194.59 152.43,194.59 152.13,194.3 152.13,194.02 152.5,193.65 152.5,193.37 152.31,193.18 152.03,193.18 151.66,193.55 151.38,193.55 151.19,193.35 151.19,193.08 151.56,192.71 151.56,192.43 151.37,192.23 151.09,192.23 150.72,192.61 150.44,192.61 150.25,192.41 150.25,192.13 150.62,191.76 150.62,191.49 150.42,191.29 150.15,191.29 149.77,191.66 149.5,191.66 149.3,191.47 149.3,191.19 149.67,190.82 149.67,190.54 149.48,190.35 149.2,190.35 148.82,190.73 148.43,190.73 148.16,190.45 148.16,190.09 148.39,189.86 148.39,189.36 147.21,188.18 147.21,185.69 144.98,183.46 142.19,183.46 140.82,182.09 139.9,182.09
M_CHA_DQ24: length 66
  TOP w0.102: CON_XMM1.183 185.77,197.94 183.87,197.29 183.37,197.29 ; 183.37,197.29 183.08,197.58 183.08,197.87 182.99,197.96 182.82,197.96 182.73,197.87 182.73,197.77 182.63,197.68 182.45,197.68 182.19,197.94 CON_XMM3.183 ; 183.37,197.29 183.11,197.18 182.4,197.18 181.84,197.74 180.92,197.74 180.75,197.57 ; 144.68,178.79 143.53,177.65 XU1.AW37
  TOP w0.159: 180.75,197.57 180.62,197.45 180.25,197.45 180,197.21 179.55,197.21 179.23,197.53 178.27,197.53 178,197.79 177.29,197.79 176.42,196.92 175.11,196.92 174.65,196.47 172.72,196.47 167,190.75 161.16,190.75 160.69,190.28 160.69,190 160.94,189.75 160.94,189.48 160.74,189.28 160.47,189.28 160.22,189.53 159.94,189.53 159.74,189.33 159.74,189.06 159.99,188.81 159.99,188.53 159.8,188.34 159.52,188.34 159.27,188.59 159,188.59 158.8,188.39 158.8,188.12 159.05,187.87 159.05,187.59 158.85,187.4 158.58,187.4 158.33,187.64 158.05,187.64 157.86,187.45 157.86,187.17 158.11,186.92 158.11,186.65 157.91,186.45 157.64,186.45 157.39,186.7 157.11,186.7 156.91,186.5 156.91,186.23 157.16,185.98 157.16,185.7 156.97,185.51 156.69,185.51 156.44,185.76 156.17,185.76 155.97,185.56 155.97,185.29 156.22,185.04 156.22,184.76 155.95,184.49 155.65,184.49 155.48,184.67 155.2,184.67 155.01,184.47 155.01,184.19 155.18,184.02 155.18,183.75 154.98,183.55 154.71,183.55 154.53,183.72 154.26,183.72 154.06,183.53 154.06,183.16 153.2,182.3 152.43,182.3 151.41,181.28 148.19,181.28 147.43,180.52 145.24,180.52 144.68,179.96 144.68,178.79
M_CHA_DQ25: length 67.8
  TOP w0.102: CON_XMM1.36 183.52,200.36 181.56,199.85 181.11,199.85 180.98,199.97 ; 180.98,199.97 180.71,200.25 180.71,200.53 180.55,200.69 179.05,200.69 178.94,200.58 178.94,200.43 178.74,200.23 178.43,200.23 178.33,200.33 178.33,200.56 178.22,200.66 178.09,200.66 CON_XMM3.36 ; 180.98,199.97 180.91,199.9 180.47,199.9 180.08,200.29 179.47,200.29 179.33,200.15 ; 141.71,180.11 141.48,179.88 141.48,179.04 XU1.AU38
  TOP w0.159: 179.33,200.15 179.09,199.91 177.97,199.91 177.87,199.81 177.11,199.81 176.26,198.96 175.49,198.96 175.29,199.16 170.39,199.16 169.29,198.06 169.29,196.11 165.84,192.66 158.34,192.66 157.54,191.85 157.26,191.85 157.07,192.05 156.79,192.05 156.59,191.85 156.59,191.57 156.79,191.38 156.79,191.1 156.59,190.91 156.32,190.91 156.12,191.1 155.85,191.1 155.65,190.91 155.65,190.63 155.84,190.44 155.84,190.16 155.65,189.97 155.37,189.97 155.18,190.16 154.9,190.16 154.71,189.96 154.71,189.69 154.9,189.49 154.9,189.22 154.71,189.02 154.43,189.02 154.24,189.22 153.96,189.22 153.76,189.02 153.76,188.74 153.96,188.55 153.96,188.27 153.76,188.08 153.49,188.08 153.29,188.27 153.02,188.27 152.82,188.08 152.82,187.8 153.01,187.61 153.01,187.33 152.82,187.14 152.54,187.14 152.35,187.33 152.07,187.33 151.88,187.13 151.88,186.86 152.07,186.66 152.07,186.39 151.88,186.19 151.6,186.19 151.41,186.38 151.13,186.38 150.9,186.16 150.9,185.85 151.11,185.64 151.11,185.35 150.88,185.12 150.49,185.12 150.32,185.29 150.04,185.29 149.78,185.04 149.78,183.9 149.12,183.24 147.42,183.24 146.02,181.84 144.02,181.84 143.67,181.49 143.39,181.49 143.19,181.7 142.91,181.7 142.72,181.5 142.72,181.23 142.92,181.02 142.92,180.74 142.29,180.11 141.71,180.11
M_CHA_DQ26: length 67.8
  TOP w0.102: 144.06,175.39 143.48,175.39 143.37,175.28 142.08,175.28 141.91,175.45 XU1.AV35 ; CON_XMM1.190 186.84,192 186.05,191.2 185.18,191.2 184.19,192.19 182.36,192.19 182.17,192 CON_XMM3.190
  TOP w0.159: 144.06,175.39 144.18,175.26 144.18,175.12 144.63,174.68 155.78,174.68 165,183.9 168.76,183.9 169.29,184.43 169.29,185.29 170,186 170.58,186 170.83,186.25 170.83,186.55 170.45,186.94 170.45,187.21 170.64,187.41 170.92,187.41 171.38,186.95 171.65,186.95 171.85,187.14 171.85,187.42 171.39,187.88 171.39,188.16 171.59,188.35 171.86,188.35 172.32,187.89 172.6,187.89 172.79,188.09 172.79,188.36 172.33,188.82 172.33,189.1 172.53,189.29 172.81,189.29 173.27,188.83 173.54,188.83 173.74,189.03 173.74,189.31 173.28,189.77 173.28,190.04 173.47,190.24 173.75,190.24 174.21,189.78 174.48,189.78 174.98,190.27 176.33,190.27 177.14,189.46 177.93,189.46 178.8,190.32 180.26,190.32 181.08,189.51 182.25,189.51 183.08,190.35 184.33,190.35 185.18,191.2
M_CHA_DQ27: length 66.9
  TOP w0.102: CON_XMM3.188 181.96,193.69 182.22,193.95 182.45,193.95 182.8,193.61 182.94,193.61 183.23,193.89 184.49,193.89 184.58,193.8 184.58,193.52 184.99,193.11 ; XU1.AW35 142.96,175.94 143.56,175.94 143.64,175.87 144.75,175.87 ; 178.33,193.36 178.02,193.05 177.11,193.05 177.05,193.11 ; 184.99,193.11 185.09,193.01 186.08,193.01 186.76,193.7 CON_XMM1.188 ; 184.99,193.11 184.77,192.88 184.64,192.88 184.03,193.49 183.41,193.49 183.32,193.41
  TOP w0.159: 183.32,193.41 183.12,193.2 181.85,193.2 181.66,193.01 180.88,193.01 180.37,193.52 179.5,193.52 179.34,193.36 178.33,193.36 ; 177.05,193.11 176.77,193.38 176.39,193.38 176.22,193.55 175.54,193.55 174.78,192.79 173.2,192.79 166.2,185.78 164.66,185.78 164.21,186.23 163.09,186.23 157.92,181.06 157.92,180.78 158.68,180.02 158.68,179.74 158.48,179.55 158.21,179.55 157.44,180.31 157.17,180.31 156.97,180.11 156.97,179.84 157.73,179.07 157.73,178.8 157.54,178.6 157.26,178.6 156.5,179.36 156.22,179.36 156.03,179.17 156.03,178.89 156.79,178.13 156.79,177.85 155.08,176.15 145.03,176.15 144.75,175.87
M_CHA_DQ28: length 68.6
  TOP w0.102: 183.37,198.99 184.34,198.99 184.99,199.65 CON_XMM1.181 ; 183.37,198.99 183.21,198.88 182.22,198.88 181.66,199.44 181.05,199.44 180.82,199.21 180.27,199.21 180.06,199.01 179.46,199.01 179.22,199.24 ; 183.37,198.99 183.08,199.28 183.08,199.67 182.98,199.77 182.75,199.77 182.33,199.35 182.23,199.35 181.94,199.65 CON_XMM3.181 ; XU1.AU37 141.48,178.13 142.06,178.13 142.35,178.42 142.35,178.65 142.88,179.19 142.98,179.19 143.24,179.46 143.24,179.6
  TOP w0.159: 143.24,179.6 143.24,180.2 144.45,181.41 146.54,181.41 147.68,182.55 149.38,182.55 149.98,183.16 150.52,183.16 150.76,183.4 150.76,183.68 150.42,184.02 150.42,184.28 150.61,184.47 151.85,184.47 152.06,184.67 152.06,184.96 151.89,185.12 151.89,185.4 152.09,185.59 152.37,185.59 152.52,185.44 152.8,185.44 152.99,185.63 152.99,185.91 152.84,186.06 152.84,186.34 153.03,186.53 153.31,186.53 153.46,186.38 153.74,186.38 153.94,186.57 153.94,186.85 153.78,187.01 153.78,187.28 153.98,187.48 154.25,187.48 154.41,187.32 154.68,187.32 154.88,187.52 154.88,187.79 154.72,187.95 154.72,188.23 154.92,188.42 155.2,188.42 155.35,188.27 155.63,188.27 155.82,188.46 155.82,188.74 155.67,188.89 155.67,189.17 155.86,189.36 156.14,189.36 156.29,189.21 156.57,189.21 156.77,189.41 156.77,189.68 156.61,189.84 156.61,190.11 156.81,190.31 157.08,190.31 157.24,190.15 157.51,190.15 157.71,190.35 157.71,190.62 157.55,190.78 157.55,191.06 157.75,191.25 158.61,191.25 159.38,192.02 163.93,192.02 163.93,192.03 166.1,192.03 170.08,196.01 170.08,197.56 170.79,198.27 175.11,198.27 175.46,198.62 176.4,198.62 177.25,199.47 177.91,199.47 177.99,199.39 179.08,199.39 179.22,199.24
M_CHA_DQ29: length 67.4
  TOP w0.102: 180.98,198.27 180.71,198.54 180.71,198.72 180.62,198.81 178.91,198.81 178.81,198.71 178.81,198.59 178.71,198.49 178.5,198.49 178.41,198.58 178.41,198.98 178.32,199.07 178.11,199.07 CON_XMM3.38 ; 180.98,198.27 180.87,198.17 180.5,198.17 180.08,198.59 179.46,198.59 179.32,198.45 ; 180.98,198.27 181.1,198.15 181.56,198.15 183.52,198.59 183.6,198.6 CON_XMM1.38 ; 144.17,178.92 143.38,178.13 142.4,178.13 XU1.AV37
  TOP w0.159: 179.32,198.45 178.99,198.12 177.11,198.12 176.26,197.27 175.48,197.27 175.21,197.54 171.17,197.54 170.76,197.13 170.76,195.81 166.34,191.39 159.64,191.39 159.16,190.91 159.16,189.89 158.96,189.7 158.69,189.7 158.52,189.87 158.24,189.87 158.05,189.67 158.05,189.4 158.34,189.1 158.34,188.85 158.15,188.65 157.85,188.65 157.58,188.92 157.3,188.92 157.11,188.73 157.11,188.45 157.4,188.16 157.4,187.91 157.21,187.71 156.93,187.71 156.66,187.98 156.36,187.98 156.16,187.78 156.16,187.51 156.46,187.21 156.46,186.96 156.26,186.77 155.96,186.77 155.69,187.04 155.41,187.04 155.22,186.84 155.22,186.57 155.51,186.27 155.51,186.02 155.32,185.82 155.02,185.82 154.75,186.09 154.47,186.09 154.28,185.9 154.28,185.62 154.57,185.33 154.57,185.08 154.38,184.88 154.07,184.88 153.8,185.15 153.53,185.15 153.33,184.95 153.33,184.68 153.63,184.38 153.63,184.13 153.43,183.94 153.13,183.94 152.86,184.21 152.58,184.21 152.39,184.01 152.39,183.74 152.66,183.47 152.66,183.16 152.46,182.97 152.06,182.97 151.89,183.13 151.51,183.13 151.16,182.78 151.16,182.32 150.75,181.91 147.94,181.91 147,180.97 144.91,180.97 144.17,180.24 144.17,178.92
M_CHA_DQ30: length 70
  TOP w0.102: 179.47,193.89 180.07,193.89 181.57,194.55 CON_XMM1.43 ; 179.47,193.89 178.96,194.4 178.96,194.65 178.88,194.73 178.76,194.73 178.68,194.65 178.68,194.47 178.59,194.38 178.42,194.38 178.06,194.74 176.57,194.74 CON_XMM3.43 ; 179.47,193.89 179.3,193.85 178.7,193.85 ; 144.22,176.15 142.61,176.15 142.4,176.35 140.59,176.35 140.52,176.28 140.52,175.7 140.39,175.57 140.22,175.57 140.09,175.71 XU1.AT35
  TOP w0.159: 144.22,176.15 145.04,176.96 152.91,176.96 153.3,177.35 153.3,178.82 153.49,179.02 153.77,179.02 154.06,178.72 154.34,178.72 154.53,178.92 154.53,179.19 154.24,179.49 154.24,179.77 154.43,179.96 154.71,179.96 155.01,179.67 155.28,179.67 155.48,179.86 155.48,180.14 155.18,180.43 155.18,180.71 155.38,180.91 155.65,180.91 155.95,180.61 156.23,180.61 156.42,180.81 156.42,181.08 156.13,181.38 156.13,181.65 156.32,181.85 156.6,181.85 156.89,181.55 157.17,181.55 157.36,181.75 157.36,182.03 157.07,182.32 157.07,182.6 157.26,182.79 157.54,182.79 157.84,182.5 158.11,182.5 158.31,182.69 158.31,182.97 158.01,183.26 158.01,183.54 158.21,183.74 158.48,183.74 158.78,183.44 159.06,183.44 159.25,183.64 159.25,183.91 158.96,184.21 158.96,184.48 159.15,184.68 159.43,184.68 159.72,184.38 160,184.38 160.19,184.58 160.19,184.86 159.9,185.15 159.9,185.43 160.09,185.62 160.37,185.62 160.67,185.33 160.94,185.33 161.14,185.52 161.14,185.8 160.84,186.09 160.84,186.37 161.04,186.57 161.31,186.57 161.61,186.27 161.89,186.27 162.08,186.47 162.08,186.74 161.79,187.04 161.79,187.31 161.98,187.51 162.26,187.51 162.55,187.21 162.96,187.21 163.19,187.45 163.19,188.37 163.41,188.58 163.9,188.58 164.14,188.35 164.14,187.85 164.33,187.66 166.75,187.66 172.96,193.86 176.26,193.86 176.46,194.06 176.81,194.06 177.12,194.37 177.86,194.37 178.38,193.85 178.7,193.85
M_CHA_DQ31: length 68.8
  TOP w0.102: 144.44,175.63 143.32,175.63 143.18,175.49 142.48,175.49 142.38,175.59 142.38,176.07 142.3,176.15 141.1,176.15 141,176.05 XU1.AU35 ; CON_XMM3.45 177.87,192.85 178.22,192.49 178.47,192.49 178.57,192.59 178.57,192.78 178.67,192.88 178.9,192.88 178.99,192.79 178.99,192.48 179.49,191.98 179.86,191.98 180.29,192.15 181.17,192.68 183.28,192.68 CON_XMM1.45
  TOP w0.159: 179.49,191.98 178.69,191.19 177.04,191.19 176.28,191.95 173.71,191.95 166.51,184.75 164.38,184.75 163.64,185.49 163.36,185.49 163.17,185.29 163.17,185.01 163.97,184.21 163.97,183.94 163.78,183.74 163.5,183.74 162.7,184.54 162.42,184.54 162.22,184.35 162.22,184.07 163.03,183.27 163.03,182.99 162.83,182.8 162.56,182.8 161.75,183.6 161.48,183.6 161.28,183.4 161.28,183.13 162.08,182.33 162.08,182.05 161.89,181.85 161.61,181.85 160.81,182.66 160.53,182.66 160.34,182.46 160.34,182.18 161.14,181.38 161.14,181.11 160.95,180.91 160.67,180.91 159.87,181.71 159.59,181.71 159.39,181.52 159.39,181.24 160.17,180.47 160.17,180.13 155.4,175.36 144.7,175.36 144.44,175.63
M_CHA_DQ32: length 60
  TOP w0.102: CON_XMM1.97 183.19,143.36 181.08,143.36 180.01,142.89 179.49,142.89 ; 145.14,148.74 144.35,148.74 144.15,148.94 142.84,148.94 XU1.AY8 ; 179.49,142.89 179.23,142.79 178.45,142.79 177.9,143.34 177.26,143.34 177.09,143.17 ; 179.49,142.89 179.11,143.27 179.11,143.47 179.03,143.55 178.9,143.55 178.82,143.47 178.82,143.29 178.73,143.2 178.6,143.2 178.5,143.29 178.5,143.46 178.42,143.55 CON_XMM3.97
  TOP w0.159: 145.14,148.74 147.99,145.89 151.16,145.89 157.32,139.73 158.92,139.73 159.08,139.89 159.08,140.75 159.23,140.91 159.69,140.91 159.84,140.75 159.84,139.52 160.05,139.32 164.95,139.32 165.3,139.67 165.3,140.73 165.43,140.86 166.03,140.86 166.19,140.69 166.19,139.27 166.32,139.14 166.98,139.14 167.11,139.27 167.11,140.68 167.27,140.84 167.87,140.84 168.03,140.68 168.03,139.36 168.53,138.86 169.82,138.86 174.19,143.23 175.27,143.23 175.62,142.87 176.26,142.87 176.41,143.03 176.95,143.03 177.09,143.17
M_CHA_DQ33: length 60.9
  TOP w0.102: XU1.AW8 142.14,148.93 142.49,149.27 143,149.27 143.1,149.17 144.32,149.17 144.47,149.02 ; CON_XMM1.240 186.58,144.4 186.39,144.2 186.39,143.92 186.21,143.74 185.2,143.74 ; 177.14,143.88 177.27,143.75 177.92,143.75 178.24,144.07 178.33,144.07 ; 185.2,143.74 185.2,143.57 185.09,143.46 184.81,143.46 184.07,144.2 183.38,144.2 183.3,144.11 ; 185.2,143.74 185.07,143.74 184.27,144.54 183.25,144.54 183.03,144.75 182.5,144.75 182.14,144.4 CON_XMM3.240
  TOP w0.159: 183.3,144.11 183.09,143.91 181.85,143.91 181.66,143.72 180.82,143.72 180.31,144.23 179.51,144.23 179.35,144.07 178.33,144.07 ; 177.14,143.88 176.92,144.09 176.44,144.09 176.31,144.23 175.54,144.23 175.36,144.05 174.12,144.05 171.2,141.12 168.48,141.12 168.12,141.48 165.17,141.48 164.54,140.86 164.54,140.28 164.2,139.95 160.76,139.95 160.48,140.23 160.48,141.01 159.95,141.54 158.97,141.54 158.24,140.8 157.14,140.8 151.42,146.52 147.81,146.52 145.31,149.02 144.47,149.02
M_CHA_DQ34: length 60
  TOP w0.102: XU1.AV6 141.37,147.1 141.71,146.76 144.12,146.76 144.22,146.66 ; CON_XMM1.104 184.48,137.7 183.45,137.79 181.64,138.24 181.08,138.24 ; CON_XMM3.104 177.91,137.77 178.61,137.77 178.75,137.91 178.75,138.17 178.84,138.26 179.02,138.26 179.11,138.17 179.11,138.07 179.38,137.8 180.08,137.8 180.53,138.24 181.08,138.24 ; 178.96,137.47 179.09,137.6 180.44,137.6 180.9,138.05 181.08,138.24
  TOP w0.159: 144.22,146.66 148.53,142.35 149.75,142.35 157.64,134.45 166.76,134.45 167.09,134.78 167.33,134.78 167.65,134.46 167.89,134.46 168.08,134.64 168.08,135.17 168.21,135.3 168.69,135.3 168.84,135.14 168.84,134.61 169,134.45 169.63,134.45 169.95,134.77 169.95,135.1 170.15,135.3 170.48,135.3 170.64,135.15 170.64,134.91 170.76,134.78 171.04,134.78 172.46,136.21 172.46,136.49 172.69,136.72 172.97,136.72 173.72,137.47 173.72,137.72 173.85,137.85 174.52,137.85 174.65,137.97 174.65,138.33 174.8,138.48 175.03,138.48 175.16,138.35 175.16,137.92 175.31,137.77 176.45,137.77 177.29,136.92 177.86,136.92 178.03,137.09 178.58,137.09 178.96,137.47
M_CHA_DQ35: length 61
  TOP w0.102: 183.3,137.32 183.45,137.4 183.91,137.4 185.41,136.86 186.89,136.75 CON_XMM1.249 ; 183.3,137.32 182.4,137.32 182.03,136.95 180.88,136.95 180.68,137.15 180.3,137.15 180.05,137.39 179.46,137.39 179.28,137.22 ; 183.3,137.32 183.13,137.13 182.73,136.73 182.73,136.42 182.54,136.24 182.17,136.24 181.79,136.63 180.57,136.63 180.45,136.75 CON_XMM3.249 ; XU1.AU6 140.48,146.7 141.39,146.7 141.57,146.53 143.8,146.53 144.08,146.24
  TOP w0.159: 144.08,146.24 148.53,141.8 148.91,141.8 148.99,141.72 149.48,141.72 157.37,133.83 168.15,133.83 168.28,133.96 168.62,133.96 168.75,133.83 169.92,133.83 170.22,134.12 170.47,134.12 170.77,133.83 170.97,133.83 173.72,136.58 174.09,136.58 174.24,136.73 174.24,137.1 174.56,137.42 176.27,137.42 177.12,136.58 177.87,136.58 178.12,136.32 178.84,136.32 179.04,136.52 179.04,136.98 179.28,137.22
M_CHA_DQ36: length 62.9
  TOP w0.102: CON_XMM1.95 183.15,145.06 181.14,145.06 179.98,144.55 179.43,144.55 179.27,144.4 178.69,144.4 178.01,145.08 177.13,145.08 176.66,144.6 176.28,144.6 175.98,144.9 CON_XMM3.95 ; XU1.AU8 140.63,149.48 143.13,149.48 143.23,149.38 145.03,149.38
  TOP w0.159: 179.43,144.55 178.56,145.41 177.16,145.41 176.56,146.02 174.65,146.02 174.22,145.59 174.22,145.03 173.68,144.5 173.51,144.5 173.13,144.88 172.77,144.88 171.32,143.43 171.32,142.14 171.02,141.83 170.41,141.83 170.23,142.01 170.23,142.7 169.88,143.05 169.42,143.05 169.16,142.8 169.16,142.34 168.94,142.11 164.24,142.11 163.86,141.73 163.86,140.7 163.73,140.58 163.28,140.58 163.09,140.76 163.09,141.94 162.92,142.11 162.33,142.11 162.13,141.91 162.13,140.75 161.95,140.58 161.3,140.58 161.11,140.77 161.11,142.02 160.96,142.18 158.1,142.18 157.81,141.88 157.81,141.59 157.65,141.43 157.41,141.43 151.68,147.16 147.64,147.16 145.41,149.38 145.03,149.38
M_CHA_DQ37: length 61.7
  TOP w0.102: 185.08,142.05 184.53,142.6 184.53,142.72 184.36,142.89 183.2,142.89 183.06,142.75 182.58,142.75 182.42,142.9 182.17,142.9 181.97,142.7 CON_XMM3.242 ; 185.08,142.05 184.81,141.86 184.68,141.86 184.03,142.51 183.4,142.51 183.31,142.41 ; 185.08,142.05 186.29,142.05 186.94,142.7 CON_XMM1.242 ; XU1.AV8 141.32,148.93 141.65,148.6 143.07,148.6 143.19,148.73 144.03,148.73 144.27,148.49 144.93,148.49
  TOP w0.159: 144.93,148.49 148.17,145.25 150.89,145.25 157.94,138.2 158.16,138.2 158.27,138.3 158.27,138.9 158.43,139.06 158.76,139.06 158.93,138.9 158.93,138.36 159.14,138.14 170.13,138.14 173.78,141.78 174.36,141.78 174.93,142.35 175.43,142.35 175.63,142.55 176.26,142.55 176.41,142.4 176.67,142.4 177.06,142.01 178.13,142.01 178.47,142.35 179.3,142.35 179.48,142.53 180.41,142.53 180.63,142.31 180.76,142.31 181.07,142 181.75,142 181.96,142.21 183.11,142.21 183.31,142.41
M_CHA_DQ38: length 59
  TOP w0.102: 180.95,139.95 181.58,139.95 181.97,139.73 181.97,139.73 183.64,139.5 184.25,139.42 184.76,139.3 CON_XMM1.102 ; 180.95,139.95 180.8,139.95 180.51,139.95 180.06,139.5 179.5,139.5 179.12,139.88 179.12,140.07 179.03,140.16 178.84,140.16 178.74,140.06 178.74,139.73 178.64,139.63 178.46,139.63 178.12,139.3 CON_XMM3.102 ; 180.95,139.95 180.95,139.83 180.41,139.28 179.98,139.28 178.61,139.28 178.53,139.2 ; 144.7,147.24 143.21,147.24 143.01,147.44 142.26,147.44 XU1.AW6
  TOP w0.159: 178.53,139.2 177.95,138.62 177.3,138.62 176.45,139.46 175.24,139.46 175.11,139.6 173.79,139.6 170.75,136.56 166.74,136.56 165.89,135.71 165.56,135.71 165.13,136.14 165.13,136.4 164.97,136.56 164.37,136.56 164.21,136.4 164.21,135.87 164.05,135.71 163.45,135.71 163.29,135.87 163.29,136.4 163.13,136.56 162.53,136.56 162.37,136.4 162.37,135.87 162.21,135.71 161.61,135.71 161.47,135.85 161.47,136.29 161.26,136.5 160.9,136.5 160.12,135.71 158.18,135.71 150.27,143.62 148.33,143.62 144.7,147.24
M_CHA_DQ39: length 57.7
  TOP w0.102: 179.3,138.93 179.45,139.08 180.06,139.08 180.23,138.91 180.84,138.91 181.1,138.65 181.67,138.65 182.23,139.21 183.36,139.21 183.45,139.2 ; XU1.AY6 142.95,146.98 144.43,146.98 ; 183.45,139.2 183.16,138.96 182.99,138.8 182.99,138.7 182.83,138.53 182.68,138.53 182.4,138.81 182.27,138.81 181.9,138.45 180.91,138.45 180.8,138.56 180.45,138.56 180.34,138.45 CON_XMM3.247 ; 183.45,139.2 184.01,139.1 184.44,138.98 184.97,138.45 CON_XMM1.247
  TOP w0.159: 179.3,138.93 179.15,138.78 178.7,138.78 178.19,138.28 177.13,138.28 176.28,139.12 175.52,139.12 175.31,138.91 175.06,138.91 174.93,139.04 174.32,139.04 174.03,138.75 173.84,138.75 173.09,138.01 173.09,137.73 172.71,137.35 172.43,137.35 171.83,136.75 171.83,136.47 171.29,135.93 167.09,135.93 166.25,135.08 165.22,135.08 165.02,135.28 164.57,135.28 164.37,135.08 157.91,135.08 150.01,142.99 148.43,142.99 144.43,146.98
M_CHA_DQ40: length 61.8
  TOP w0.102: 183.39,134.39 184.35,134.39 185.01,135.05 CON_XMM1.251 ; 183.39,134.39 182.45,134.26 182.23,134.26 181.66,134.84 181.09,134.84 180.87,134.62 180.27,134.62 180.06,134.41 179.47,134.41 179.22,134.65 ; 183.39,134.39 182.99,134.79 182.99,135.03 182.9,135.13 182.65,135.13 182.55,135.03 182.55,134.85 182.45,134.75 182.25,134.75 181.95,135.05 CON_XMM3.251
  TOP w0.159: 179.22,134.65 179.07,134.8 177.98,134.8 177.91,134.88 177.3,134.88 176.37,134.42 176.26,134.37 175.34,134.37 175.21,134.5 175.21,135.45 175.04,135.62 174.59,135.62 174.4,135.42 174.4,135.03 174.65,134.77 174.65,134.37 174.4,134.11 173.31,134.11 171.77,132.57 156.85,132.57 156.44,132.98 155.93,132.98 155.25,133.66 155.25,133.98 155.06,134.17 154.75,134.17 154.16,134.75 154.16,135.24 149.02,140.38 148.53,140.38 147.77,141.15 147.33,141.15 147.15,141.33 147.15,141.56 147.23,141.64 147.23,141.85 147.06,142.01 146.84,142.01 146.71,141.88 146.59,141.88 146.32,142.15 146.32,142.39 146.44,142.51 146.44,142.74 146.17,143.02 146,143.02 145.86,142.87 145.62,142.87 145.46,143.03 145.46,143.27 145.55,143.36 145.55,143.6 145.38,143.77 145.18,143.77 145.18,143.77 144.99,143.59 144.81,143.59 144.57,143.82 144.57,144.01 144.7,144.14 144.7,144.38 144.48,144.6 144.24,144.6 144.17,144.53 143.93,144.53 143.74,144.72 143.74,144.83 143.77,144.86 143.77,145.1 143.6,145.27 XU1.AY4
M_CHA_DQ41: length 63.7
  TOP w0.102: 180.95,133.68 180.71,133.92 180.71,134.2 180.62,134.29 180.42,134.29 180.32,134.2 178.88,134.2 178.81,134.13 178.81,134.04 178.7,133.93 178.51,133.93 178.41,134.04 178.41,134.39 178.32,134.48 178.11,134.48 CON_XMM3.108 ; 180.95,133.68 180.85,133.58 180.5,133.58 180.09,133.99 179.45,133.99 179.32,133.85 ; 180.95,133.68 181.08,133.55 181.52,133.55 183.52,134 CON_XMM1.108 ; 143.01,144.76 142.66,144.76 142.44,144.98 142.26,144.98 142.06,144.78 141.85,144.78 141.61,145.02 141.46,145.02 141.2,144.75 140.63,144.75 140.46,144.93 140.46,145.14 140.59,145.27 XU1.AV4
  TOP w0.159: 179.32,133.85 178.98,133.52 177,133.52 176.83,133.68 176.83,133.88 176.69,134.03 175.46,134.03 175.34,133.91 174.99,133.91 174.83,133.75 174.83,133.48 175.23,133.07 175.23,132.69 174.98,132.44 174.4,132.44 174.27,132.56 174.27,133.37 174.16,133.48 173.57,133.48 173.4,133.31 173.4,132.76 173.27,132.63 172.72,132.63 172.03,131.94 156.07,131.94 153.53,134.48 153.53,134.98 148.76,139.75 148.24,139.75 147.56,140.43 147.56,140.72 147.44,140.84 147.24,140.84 147.04,140.64 146.84,140.64 146.64,140.85 146.64,141.05 146.89,141.3 146.89,141.48 146.76,141.6 146.41,141.6 146.02,141.99 146.02,142.47 145.9,142.6 145.35,142.6 145.19,142.76 145.19,143.17 145.05,143.31 144.79,143.31 144.67,143.18 144.67,143.06 144.55,142.95 144.37,142.95 144.1,143.23 144.1,143.41 144.27,143.58 144.27,143.79 144.14,143.92 143.85,143.92 143.7,144.07 143.7,144.31 143.43,144.58 143.43,144.74 143.31,144.87 143.12,144.87 143.01,144.76
M_CHA_DQ42: length 62.3
  TOP w0.102: 179.49,127.59 179.23,127.49 178.53,127.49 177.98,128.04 177.26,128.04 177.1,127.88 ; 179.49,127.59 179.11,127.96 179.11,128.17 179.04,128.24 178.9,128.24 178.82,128.16 178.82,127.99 178.73,127.9 178.62,127.9 178.53,127.99 178.53,128.17 178.45,128.25 CON_XMM3.115 ; 179.49,127.59 179.89,127.59 181.04,128.05 183.15,128.05 CON_XMM1.115 ; XU1.AT1 139.37,142.53 139.48,142.43 139.48,142.19 139.37,142.09 139.28,142.09 139.18,141.99 139.18,141.83 139.26,141.75 139.4,141.75 139.48,141.67 139.48,141.53 140.18,140.83 141.55,140.83 141.66,140.72 141.66,140.38 141.76,140.28 141.96,140.28 142.11,140.43 142.11,140.67 142.21,140.77 142.59,140.77
  TOP w0.159: 142.59,140.77 142.7,140.65 142.7,140.42 142.27,139.98 142.27,139.7 142.58,139.39 142.81,139.39 142.94,139.51 142.94,139.84 143.08,139.98 143.32,139.98 143.51,139.79 143.51,139.32 146.19,136.64 150.49,132.35 151.42,131.41 154.33,128.5 166.57,128.5 167.35,127.72 173.14,127.72 173.3,127.89 173.3,128.03 173.56,128.28 173.78,128.28 173.96,128.09 173.96,127.89 174.09,127.76 174.32,127.76 174.45,127.89 174.45,128.49 174.57,128.61 174.96,128.61 175.13,128.44 175.13,127.95 174.89,127.71 174.89,127.48 175.02,127.36 175.29,127.36 175.48,127.55 176.34,127.55 176.49,127.7 176.92,127.7 177.1,127.88
M_CHA_DQ43: length 63
  TOP w0.102: 179.48,129.3 179.1,129.26 178.7,129.26 ; 179.48,129.3 179.94,129.3 181.43,129.95 CON_XMM1.113 ; 179.48,129.3 178.96,129.81 178.96,130.01 178.88,130.1 178.74,130.1 178.66,130.01 178.66,129.89 178.56,129.79 178.41,129.79 178.31,129.9 178.31,130.03 178.19,130.15 176.55,130.15 CON_XMM3.113 ; XU1.AT2 139.61,143.01 140.18,143.01 140.55,142.64 140.55,142.21 140.72,142.05 140.72,141.81 140.54,141.63 140.54,141.45 140.68,141.31 140.85,141.31 141.13,141.59 141.36,141.59 141.66,141.3 142.7,141.3 142.82,141.42 142.82,141.57 142.99,141.73 143.17,141.73 143.31,141.59 143.31,141.35
  TOP w0.159: 143.31,141.35 143.31,141.07 143.44,140.94 143.62,140.94 143.9,141.22 144.08,141.22 144.23,141.07 144.23,140.83 143.95,140.54 143.95,140.36 144.1,140.21 144.66,140.21 144.98,139.89 144.98,139.64 145.3,139.32 145.55,139.32 145.95,138.92 145.95,138.67 146.46,138.16 146.72,138.16 147.07,137.8 147.07,137.55 147.54,137.08 147.79,137.08 155.12,129.76 167.87,129.76 168.03,129.6 168.03,129.14 168.19,128.98 168.79,128.98 168.95,129.14 168.95,129.6 169.11,129.76 169.72,129.76 169.87,129.6 169.87,129.14 170.03,128.98 170.64,128.98 170.79,129.14 170.79,129.6 170.95,129.76 171.56,129.76 171.72,129.6 171.72,129.14 171.87,128.98 172.48,128.98 172.64,129.14 172.64,129.6 172.79,129.76 173.27,129.76 173.46,129.56 174.06,129.56 174.7,130.2 175.03,130.2 175.18,130.04 175.18,129.71 175.63,129.27 176.49,129.27 176.99,129.77 177.88,129.77 178.4,129.26 178.7,129.26
M_CHA_DQ44: length 63.3
  TOP w0.102: 183.48,132.7 184.34,132.7 185.06,133.43 186.39,133.43 186.47,133.35 CON_XMM1.253 ; 183.48,132.7 182.87,133.31 182.71,133.31 182.63,133.22 182.63,133.05 182.52,132.94 182.3,132.94 181.89,133.35 CON_XMM3.253 ; 183.48,132.7 183.01,132.59 182.21,132.59 181.65,133.14 181.06,133.14 180.9,132.98 ; 142.16,143.9 141.74,143.9 141.28,144.36 XU1.AV3
  TOP w0.159: 180.9,132.98 180.77,132.86 180.27,132.86 180.08,132.67 179.46,132.67 179.2,132.93 178.13,132.93 177.88,133.18 177.29,133.18 176.64,132.53 175.76,132.53 175.26,132.03 175.26,131.5 175.13,131.36 174.83,131.36 174.7,131.49 174.7,131.89 174.55,132.04 174.27,132.04 174.12,131.89 174.12,131.72 173.96,131.57 173.6,131.57 173.48,131.69 173.48,131.88 173.35,132 172.98,132 172.8,131.82 172.8,131.52 172.59,131.31 155.81,131.31 152.89,134.22 152.89,134.72 151.7,135.91 151.19,135.91 150.98,136.13 150.98,136.63 150.14,137.46 149.75,137.46 149.63,137.59 149.63,137.98 148.49,139.11 147.99,139.11 146.64,140.46 146.23,140.46 146.03,140.66 146.03,140.84 146.32,141.14 146.32,141.32 146.02,141.62 145.84,141.62 145.54,141.33 145.36,141.33 145.05,141.64 145.05,141.82 145.31,142.09 145.31,142.27 144.95,142.63 144.77,142.63 144.64,142.51 144.64,142.35 144.53,142.25 144.25,142.25 144.09,142.41 144.09,142.82 143.53,143.38 142.8,143.38 142.67,143.51 142.67,143.77 142.54,143.9 142.16,143.9
M_CHA_DQ45: length 62.7
  TOP w0.102: 144.08,145.87 143.87,145.87 143.76,145.77 143.76,145.62 143.65,145.51 143.17,145.51 143.08,145.6 143.08,145.77 142.99,145.86 142.66,145.86 142.56,145.76 142.56,145.61 142.45,145.5 142.31,145.5 142.19,145.62 142.19,145.77 142.11,145.85 141.45,145.85 141.35,145.75 141.35,145.39 141.47,145.27 XU1.AW4 ; CON_XMM3.106 178.09,136.07 178.22,136.07 178.33,135.97 178.33,135.71 178.43,135.61 178.69,135.61 179.13,136.04 180.09,136.04 180.21,136.17 180.57,136.17 180.71,136.03 180.71,135.64 180.96,135.39 ; CON_XMM1.106 183.52,135.77 181.52,135.25 181.1,135.25 180.96,135.39 ; 180.96,135.39 180.85,135.28 180.52,135.28 180.1,135.7 179.38,135.7 179.29,135.6
  TOP w0.159: 144.08,145.87 144.25,145.7 144.25,145.44 144.5,145.19 144.72,145.19 144.88,145.02 144.88,144.64 145.05,144.47 145.34,144.47 145.72,144.09 145.72,143.8 146.03,143.49 146.42,143.49 146.71,143.21 146.71,142.81 147.11,142.41 147.4,142.41 147.68,142.14 147.68,141.85 148.17,141.35 148.46,141.35 148.73,141.08 149.22,141.08 154.8,135.5 154.8,135.01 155.02,134.8 155.51,134.8 155.88,134.43 155.88,133.92 156.19,133.61 156.7,133.61 157.11,133.2 171.51,133.2 171.85,133.54 171.85,133.81 172.14,134.11 172.42,134.11 172.72,134.41 172.72,134.69 173.02,134.99 173.24,134.99 173.49,134.74 173.9,134.74 174.02,134.87 174.02,135.12 173.74,135.41 173.74,135.6 174.07,135.93 174.54,135.93 174.7,136.09 174.7,136.93 174.83,137.06 175.08,137.06 175.18,136.96 175.18,136.07 175.41,135.84 176.17,135.84 176.3,135.97 176.48,135.97 177.23,135.22 178.02,135.22 178.12,135.32 179.01,135.32 179.29,135.6
M_CHA_DQ46: length 66
  TOP w0.102: XU1.AT4 138.64,144.74 138.64,142.08 140.15,140.56 140.98,140.56 141.08,140.46 ; CON_XMM1.260 187.01,127.4 186.35,126.74 185.07,126.74 ; 185.07,126.74 184.89,126.55 184.68,126.55 184.04,127.2 183.4,127.2 183.31,127.11 ; 185.07,126.74 184.22,127.6 183.17,127.6 183.06,127.48 182.83,127.48 182.63,127.69 182.42,127.69 182.33,127.59 182.33,127.51 182.21,127.4 CON_XMM3.260 ; 178.3,127.05 178.19,127.05 177.89,126.75 177.26,126.75 177.09,126.91
  TOP w0.159: 141.08,140.46 142.67,138.87 143.06,138.87 154.06,127.87 166.31,127.87 167.09,127.09 175.48,127.09 175.62,127.23 176.33,127.23 176.45,127.1 176.9,127.1 177.09,126.91 ; 183.31,127.11 183.03,126.82 181.76,126.82 181.66,126.72 181.09,126.72 180.81,127.01 180.54,127.01 180.31,127.23 179.5,127.23 179.31,127.05 178.3,127.05
M_CHA_DQ47: length 64.6
  TOP w0.102: 177.12,128.59 177.26,128.45 177.95,128.45 178.27,128.77 178.33,128.77 ; CON_XMM3.258 182.13,129.09 182.6,129.57 182.88,129.57 183.17,129.28 184.25,129.28 185.09,128.44 ; 183.32,128.82 183.4,128.9 184.04,128.9 184.61,128.32 184.97,128.32 185.09,128.44 ; 185.09,128.44 186.15,128.44 186.39,128.68 186.39,128.8 186.68,129.09 CON_XMM1.258 ; 142.67,141.06 140.24,141.06 139.68,141.63 139.68,142.54 139.23,142.98 139.11,142.98 138.84,143.26 138.84,143.81 139.17,144.14 XU1.AT3
  TOP w0.159: 142.67,141.06 142.81,140.92 142.82,140.92 142.97,140.76 142.97,140.76 147.97,135.76 147.97,135.75 154.59,129.13 166.83,129.13 167.61,128.35 172.74,128.35 173.32,128.93 174.27,128.93 174.55,129.21 175.01,129.21 175.29,128.93 176.25,128.93 176.39,128.79 176.92,128.79 177.12,128.59 ; 183.32,128.82 183.11,128.6 181.84,128.6 181.66,128.42 181.09,128.42 180.86,128.66 180.56,128.66 180.29,128.93 179.5,128.93 179.34,128.77 178.33,128.77
M_CHA_DQ48: length 73.1
  TOP w0.102: 185.18,125.05 186.31,125.05 186.49,125.22 186.49,125.5 186.68,125.7 CON_XMM1.262 ; 185.18,125.05 185.08,125.05 184.23,125.9 183.17,125.9 183.01,126.06 182.5,126.06 182.13,125.7 CON_XMM3.262 ; 185.18,125.05 185.18,124.83 185.09,124.74 184.8,124.74 184.04,125.49 183.4,125.49 183.31,125.4 ; 138.95,140.75 138.71,140.99 138.16,140.99 137.69,141.46 137.69,142.71 137.34,143.05 XU1.AP2 ; 178.3,125.35 178.23,125.35 177.93,125.05 177.26,125.05 177.09,125.21
  TOP w0.159: 183.31,125.4 183.1,125.19 181.83,125.19 181.66,125.02 181.09,125.02 180.83,125.29 180.63,125.29 180.39,125.53 179.47,125.53 179.18,125.24 178.82,125.24 178.71,125.35 178.3,125.35 ; 177.09,125.21 176.9,125.4 176.48,125.4 176.35,125.53 175.32,125.53 175.12,125.34 166.74,125.34 166.55,125.15 166.55,124.99 166.28,124.72 165.88,124.72 165.59,125.01 165.59,126.13 165.3,126.42 161.68,126.42 159.9,124.64 159.36,124.64 159.21,124.49 159.21,123.69 159.02,123.5 158.52,123.5 158.37,123.64 158.37,124.46 158.19,124.64 157.55,124.64 157.39,124.48 157.39,123.66 157.23,123.5 156.63,123.5 156.47,123.66 156.47,124.48 156.31,124.64 155.5,124.64 140.26,139.88 139.82,139.88 138.95,140.75
