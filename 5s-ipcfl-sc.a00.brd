# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OCB5#: length 456.8
  TOP w0.089: 183.83,52.02 182.97,51.16 181.34,51.16 PCH.AC44
  TOP w0.102: v1(25.07,224.09) UR69726.2 UR69725.1 22.36,224.09 22.3,224.03 UU47.3 ; v1(57.33,17.37) 57.33,16.94 57.56,16.71 57.56,13.02 v1(57.33,12.79) ; 183.83,52.02 v1(185.04,53.23) ; v1(200.46,52.75) 200.46,51.36 199.75,50.65 199.75,43.79 199.52,43.56 199.52,36.07 199,35.55 199,34.1 199.67,33.43 199.67,26.9 v1(199.8,26.77)
  BOTTOM w0.102: v1(57.33,17.37) 56.92,16.97 56.33,16.97 55.1,18.2 41.56,18.2 30.31,29.45 30.31,33.95 31.03,34.66 31.03,36.49 23.58,43.93 23.58,57.48 22.03,59.03 22.03,113.07 21.76,113.35 21.76,119.45 23.53,121.23 23.53,123.15 23.99,123.6 23.99,124.48 23.83,124.65 23.83,126.91 24.7,127.79 24.7,135.88 24.05,136.53 24.05,137.82 21.59,140.28 21.59,142.65 22.77,143.83 22.77,148.34 23.01,148.59 23.01,149.71 22.96,149.76 22.96,155.1 18.31,159.74 18.31,175.26 20.25,177.19 21.59,177.19 22.76,178.36 22.76,193.95 29.51,200.7 29.51,202.4 30.94,203.83 30.94,211.09 27.43,214.6 27.43,217.45 26.24,218.64 26.24,222.92 v1(25.07,224.09) ; v1(200.46,52.75) 200.66,52.95 200.66,53.64 v2(200.28,54.02) 199.68,54.62 194.63,54.62 193.48,53.47 189.55,53.47 188.7,54.32 184.93,54.32 184.66,54.05 184.66,53.62 184.67,53.6 v1(185.04,53.23) ; v1(199.8,26.77) 199.24,26.22 199.24,24.05 197.07,21.88 196.23,21.88 194.98,23.13 182.47,23.13 180.64,21.3 177.95,21.3 176.63,19.98 169.15,19.98 168.4,20.73 159.7,20.73 157.29,18.32 155.57,18.32 154.61,17.35 149.11,17.35 148.89,17.14 137.42,17.14 133.53,13.24 130.23,13.24 129.64,12.65 123.26,12.65 122.66,13.25 105.51,13.25 105.03,13.73 92.44,13.73 91.16,12.45 86.54,12.45 85.69,13.29 62.22,13.29 62.13,13.2 59.87,13.2 59.64,13.43 57.97,13.43 v1(57.33,12.79)
USBN1: length 283.2
  TOP w0.102: PCH.AH5 162.07,49.05 162.28,49.05 162.31,49.02 162.31,48.79 162.5,48.6 162.5,48.37 v1(162.28,48.16) ; v1(29.03,182.6) 28.83,182.4 28.3,182.4 28.12,182.57 UL66.3
  BOTTOM w0.102: 25.98,171.88 v2(26.29,171.88) ; 25.98,171.88 25.98,175.04 28.15,179.79 29.82,181.46 29.82,182.07 29.54,182.35 29.29,182.35 v1(29.03,182.6) ; 25.98,171.88 25.98,160.99 26.24,160.74 26.24,147.41 25.54,146.71 25.54,145.75 25.18,145.4 25.18,139.27 25.88,138.58 25.88,137.29 26.53,136.64 26.53,123.38 26.03,122.88 25.76,119.97 25.76,117.58 26.53,116.17 27.3,114.76 27.3,113.9 26.55,112.34 26.55,105.91 26.81,105.65 26.81,65.52 32.18,60.15 32.18,49.2 45.64,35.74 56.31,35.74 56.77,36.2 79.83,36.2 80.28,36.64 129.17,36.64 130.39,37.86 137.79,37.86 139.67,39.75 141.43,39.75 144.17,42.49 147.92,42.49 148.26,42.84 152.46,42.84 152.46,42.84 153.43,42.84 154,43.4 154.98,43.4 159.4,47.83 162.2,47.83 162.28,47.9 v1(162.28,48.16)
USBN2: length 266.2
  TOP w0.102: URN137.3 28.06,181.12 28.39,180.8 29.92,180.8 31.01,179.71 33.5,179.71 v1(33.69,179.9) ; v1(162.31,50.55) 162.31,50.35 PCH.AE5
  BOTTOM w0.102: 31.94,171.83 31.94,178.7 32.9,179.66 33.46,179.66 v1(33.69,179.9) ; 31.94,171.83 31.94,169.69 29.9,167.65 29.9,163.01 30.62,162.29 30.62,153.12 31.26,152.48 31.26,149.6 30.2,148.54 30.2,145.19 29.67,144.65 29.67,142.05 30.48,141.24 30.48,136.98 31.43,136.03 31.43,120.13 32.97,118.59 32.97,102.04 31.52,100.59 31.52,72.24 42.01,61.75 42.01,59.06 48.14,52.93 58.35,52.93 60.33,50.95 62.66,50.95 63.8,49.82 83.5,49.82 86.38,46.93 100.29,46.93 101.13,47.78 117.8,47.78 118.18,48.16 131.29,48.16 134.21,51.08 153.62,51.08 154.51,51.97 161.74,51.97 162.31,51.4 v1(162.31,50.55) ; 31.94,171.83 v2(31.65,171.83)
USBN3: length 273.1
  TOP w0.102: PCH.AH8 163.4,49.17 v1(163,49.57) ; URN139.3 28.05,185.92 28.28,185.7 32.79,185.7 33.5,184.99 34.04,184.99 v1(34.26,185.22)
  BOTTOM w0.102: v2(29.64,161.19) 29.93,161.19 ; 29.93,161.19 29.93,150.06 29.51,149.64 29.51,146.12 28.98,145.59 28.98,141.77 29.78,140.97 29.78,135.78 30.75,134.81 30.75,119.82 32.21,118.36 32.21,102.25 30.84,100.88 30.84,71.84 41.33,61.35 41.33,58.78 47.86,52.24 58.04,52.24 60.02,50.27 62.38,50.27 63.51,49.13 83.21,49.13 86.27,46.08 100.53,46.08 101.54,47.09 118.08,47.09 118.46,47.47 131.57,47.47 134.49,50.39 153.9,50.39 154.75,51.24 160.17,51.24 161.53,49.89 162.69,49.89 v1(163,49.57) ; 29.93,161.19 29.93,161.78 29.21,162.5 29.21,169.45 29.82,170.06 29.82,176.92 30.99,178.97 33.43,181.4 33.43,184.38 v1(34.26,185.22)
USBN4: length 267.9
  TOP w0.089: 158.06,49.71 158.37,49.71 158.57,49.91 159.2,49.91 159.54,49.9 159.95,50.15 160.12,50.22 160.19,50.25 160.32,50.31 PCH.AE2
  TOP w0.102: v1(31.75,184.37) 31.54,184.16 28.29,184.16 28.12,184.34 UL68.3 ; v1(140.92,48.75) 140.92,49.05 141.6,49.73 144.31,49.73 144.44,49.86 154.67,49.86 155.35,49.17 157.28,49.17 157.81,49.71 158.06,49.71
  BOTTOM w0.102: v1(31.75,184.37) 31.56,184.18 31.27,184.18 30.99,183.9 30.99,180.95 29.76,179.72 27.74,175.96 27.74,158.17 27.41,157.84 27.41,146.92 26.92,146.44 26.92,145.48 26.43,144.98 26.43,139.68 27.05,139.06 27.05,137.78 27.71,137.11 27.71,122.57 27.99,122.29 27.99,121.08 ; v1(140.92,48.75) 140.62,48.75 139.39,47.52 133.55,47.52 132.11,46.08 119.01,46.08 118.63,45.69 116.42,45.69 116.04,45.31 102.25,45.31 101.42,44.49 85.91,44.49 82.65,47.76 62.94,47.76 62.23,48.47 58.84,48.47 58.36,48.96 56.42,48.96 52.86,48.96 51.4,50.42 47.74,50.42 39.95,58.21 39.95,60.72 29.46,71.21 29.46,102.05 30.16,102.74 30.16,109.46 29.11,110.51 29.11,118.16 27.99,119.28 27.99,121.08 ; v2(27.69,121.08) 27.99,121.08
USBN5: length 276.8
  TOP w0.089: 159.64,51.41 159.66,51.43 160.27,51.43 PCH.AC2
  TOP w0.102: 159.64,51.41 158.32,51.41 157.91,51 156.67,51 156.22,50.55 139.55,50.55 138.69,49.68 138.69,49.58 v1(138.91,49.36) ; UL8.3 31.14,195.78 31.32,195.61 31.7,195.61 v1(31.91,195.81)
  BOTTOM w0.102: 32.36,185.88 32.36,186.69 31.19,187.86 31.19,195.43 31.42,195.66 31.75,195.66 v1(31.91,195.81) ; 32.36,185.88 32.36,181.33 30.47,179.44 29.13,177.1 29.13,170.37 28.52,169.76 28.52,160.71 29.25,159.98 29.25,150.4 28.83,149.98 28.83,146.41 28.3,145.87 28.3,139.75 28.59,139.46 28.59,138.17 29.08,137.68 29.08,134.64 30.06,133.66 30.06,119.49 31.32,118.23 31.32,102.78 30.15,101.61 30.15,71.55 40.64,61.06 40.64,58.49 47.67,51.46 57.6,51.46 58.34,50.72 58.34,49.94 59.13,49.16 62.52,49.16 63.23,48.45 82.93,48.45 86.14,45.23 101.03,45.23 101.8,46 115.45,46 115.86,46.41 118.36,46.41 118.72,46.76 131.83,46.76 133.68,48.62 138.44,48.62 138.69,48.86 138.69,49.15 v1(138.91,49.36) ; 32.36,185.88 v2(32.05,185.88)
USBN6: length 281
  TOP w0.089: 158.48,49.5 158.68,49.69 159.68,49.69 159.85,49.87 160.13,49.87 160.38,49.62 PCH.AF2
  TOP w0.102: v1(143.03,49.23) 143.56,48.69 144.42,48.69 145.11,49.38 154.47,49.38 155.16,48.68 157.33,48.68 157.9,49.25 158.23,49.25 158.48,49.5 ; v1(31.9,197.36) 31.7,197.15 31.29,197.15 31.14,197.3 UL7.3
  BOTTOM w0.102: v1(31.9,197.36) 31.8,197.26 31.34,197.26 30.3,196.22 30.3,188.95 ; 30.3,188.95 v2(30,188.95) ; 30.3,188.95 30.3,181.24 28.7,179.63 27.05,176.19 27.05,158.5 26.72,158.17 26.72,147.21 26.02,146.51 26.02,145.55 25.67,145.2 25.67,139.47 26.36,138.78 26.36,137.49 27.01,136.84 27.01,123.08 26.7,122.76 26.7,119.6 28.4,117.9 28.4,110.13 29.47,109.05 29.47,103.03 28.78,102.34 28.78,70.88 39.27,60.39 39.27,57.92 47.46,49.73 51,49.73 52.46,48.27 56.7,48.27 58.07,48.27 58.56,47.79 61.95,47.79 62.66,47.07 82.36,47.07 85.71,43.73 101.7,43.73 102.58,44.6 117.94,44.6 118.35,45.01 132.02,45.01 133.54,46.53 139.74,46.53 140.64,47.43 142,47.43 143.03,48.46 v1(143.03,49.23)
USBN7: length 159.5
  TOP w0.089: 158.12,52.18 160.1,52.18 160.38,51.9 PCH.AB2
  TOP w0.102: v1(175.36,91.82) 175.25,91.71 158.26,91.71 156.97,90.43 151.14,90.43 149.76,89.05 148.63,89.05 142.01,82.44 142.01,73.59 138.51,70.08 138.51,56.13 143.2,51.44 155.87,51.44 156.22,51.79 157.42,51.79 157.82,52.18 158.12,52.18 ; U942691.2 222.87,113.98 222.63,113.74 222.4,113.74 v1(222.28,113.86)
  BOTTOM w0.102: 177.06,92.24 181.7,92.24 187.43,88.62 189.7,88.62 190.09,89.01 194.9,89.01 195.29,88.62 199.78,88.62 200.6,89.45 207.82,89.45 208.51,88.76 211.96,88.76 214.39,91.19 214.39,94.14 221.72,101.47 221.72,103.43 223.32,110.91 223.32,113.35 223,113.67 222.47,113.67 v1(222.28,113.86) ; 177.06,92.24 176.02,92.24 175.6,91.82 v1(175.36,91.82) ; 177.06,92.24 v2(177.06,91.95)
USBN8: length 235.3
  TOP w0.089: v1(163.79,46.15) 163.79,46.31 PCH.AM8
  TOP w0.102: v1(24.43,118.47) 24.29,118.61 24.29,119.61 25.59,120.9 27.21,120.9 28.34,122.03 28.34,122.44 28.42,122.53 J60.5
  BOTTOM w0.102: 25.36,115.7 25.36,114.78 25.18,114.6 25.18,105.34 25.44,105.08 25.44,63.5 26.49,62.45 26.49,46.56 34.71,38.34 36.13,38.34 42.95,31.52 42.95,30.02 43.97,29.01 110.16,29.01 110.59,28.58 114.2,28.58 114.55,28.23 118,28.23 118.67,28.91 119.81,28.91 120.17,29.26 129.21,29.26 131.55,31.6 140.56,31.6 143.78,34.81 145.24,34.81 148.03,37.6 149.26,37.6 152.26,40.6 153.14,40.6 154.48,41.95 155.51,41.95 160.47,46.91 162.64,46.91 162.97,46.57 163.37,46.57 v1(163.79,46.15) ; 25.36,115.7 v2(25.65,115.7) ; 25.36,115.7 25.36,116.26 24.47,117.14 24.47,118.43 v1(24.43,118.47)
USBN9: length 180.3
  TOP w0.102: UL74.3 230.91,132.46 230.73,132.28 230.73,131.85 v1(231.01,131.57) ; PCH.Y3 160.65,52.22 160.32,52.22 160.1,52.45 159.72,52.45 159.61,52.55 157.51,52.55 157.15,52.2 155.86,52.2 155.59,51.92 143.4,51.92 139.04,56.28 139.04,69.93 142.49,73.39 142.49,82.21 148.78,88.49 150.01,88.49 151.35,89.83 157.06,89.83 158.08,90.86 170.19,90.86 170.68,90.36 176.72,90.36 v1(176.96,90.61)
  BOTTOM w0.102: v2(229.62,128.96) 229.4,129.17 ; 229.4,129.17 227.7,127.47 227.7,124.7 225.5,122.5 225.5,108.15 224.84,107.48 224.84,106.3 224.24,105.7 224.24,104.2 222.4,102.36 222.4,101.18 215.08,93.86 215.08,90.68 212.46,88.06 208.24,88.06 207.54,88.76 206.08,88.76 205.26,87.93 195.01,87.93 194.61,88.33 190.39,88.33 190,87.93 185.85,87.93 183.84,89.95 177.33,89.95 177.14,90.14 177.14,90.42 v1(176.96,90.61) ; 229.4,129.17 231.01,130.78 v1(231.01,131.57)
USBN10: length 226.8
  TOP w0.102: v1(26.11,113.49) 25.07,113.49 23.14,115.42 22.01,115.42 21.39,116.04 21.39,116.25 21.24,116.4 UL10.4 ; v1(163.86,47.02) 163.5,47.37 PCH.AK8
  BOTTOM w0.102: v1(163.86,47.02) 163.44,47.43 159.98,47.43 155.26,42.72 154.28,42.72 152.85,41.29 151.97,41.29 150.88,40.2 149.32,40.2 146.27,37.15 ; v1(26.11,113.49) 25.87,113.24 25.87,105.62 26.12,105.37 26.12,64.22 27.2,63.14 27.2,46.82 35,39.03 36.42,39.03 43.75,31.69 59.8,31.69 60.5,30.99 64.54,30.99 64.86,31.31 88.53,31.31 89.39,30.45 96.17,30.45 96.93,29.69 110.44,29.69 110.87,29.27 114.49,29.27 114.84,28.92 117.71,28.92 118.38,29.59 119.53,29.59 119.88,29.95 128.82,29.95 131.16,32.28 140.13,32.28 143.86,36.02 145.14,36.02 146.27,37.15 ; v2(146.06,37.35) 146.27,37.15
USBN11: length 178.7
  TOP w0.102: v1(232.66,130.23) 232.44,130.45 232.44,130.78 232.66,131.01 URN144.3 ; PCH.W2 160.55,53.04 160.17,53.41 157.24,53.41 156.94,53.11 155.5,53.11 155.19,52.81 143.79,52.81 139.98,56.62 139.98,69.61 143.38,73.02 143.38,81.67 149.3,87.59 150.44,87.59 151.74,88.88 157.41,88.88 158.5,89.97 169.46,89.97 171.06,88.36 178.44,88.36 178.62,88.54 v1(178.99,88.54)
  BOTTOM w0.102: 183.67,88.49 180.87,88.49 180.41,88.95 179.07,88.95 178.99,88.87 v1(178.99,88.54) ; 183.67,88.49 184.27,88.49 185.51,87.25 190.3,87.25 190.7,87.64 194.33,87.64 194.72,87.25 212.97,87.25 216.13,90.41 219.46,90.41 221.22,92.17 221.22,98.46 223.14,100.38 223.14,102.13 224.93,103.92 224.93,105.41 225.53,106.01 225.53,107.18 226.19,107.84 226.19,121.73 228.46,124 228.46,125.69 232.42,129.65 232.42,129.98 v1(232.66,130.23) ; 183.67,88.49 v2(183.67,88.2)
USBN12: length 218.9
  TOP w0.089: PCH.AD3 160.83,51.03 160.27,51.03 160.16,51.14 159.45,51.14 159.43,51.16 159.41,51.16
  TOP w0.102: v1(156.31,50.04) 156.74,50.47 156.87,50.47 157.07,50.67 158.13,50.67 158.61,51.16 159.41,51.16 ; UL9.4 14.8,117.94 14.98,118.11 15.34,118.11 26.74,106.71 28.58,106.71 28.78,106.9 28.78,107.39 v1(28.89,107.49)
  BOTTOM w0.102: 129.22,38.63 129.82,39.24 137.1,39.24 139.47,41.61 141.32,41.61 143.6,43.89 147.34,43.89 147.65,44.21 152.86,44.21 154.22,45.57 154.22,46.81 156.57,49.16 156.57,49.78 v1(156.31,50.04) ; 129.22,38.63 v2(129.01,38.84) ; 129.22,38.63 128.6,38.01 81.53,38.01 80.7,38.84 55.18,38.84 54.53,39.48 54.53,40.06 53.64,40.94 44.44,40.94 33.68,51.7 33.68,60.68 28.24,66.12 28.24,102.88 28.89,103.52 v1(28.89,107.49)
USBN13: length 146.8
  TOP w0.102: v1(224.26,102.31) 224.47,102.1 U51.2 ; PCH.V3 160.62,53.86 155.23,53.86 154.86,53.49 144.09,53.49 140.69,56.9 140.69,69.3 144.07,72.68 144.07,81.39 149.54,86.86 150.85,86.86 152.19,88.2 157.72,88.2 158.8,89.28 169.1,89.28 171.7,86.68 179.74,86.68 v1(180.3,87.24)
  BOTTOM w0.102: v1(224.26,102.31) 224.41,102.16 224.74,102.16 224.97,101.93 224.97,101.23 222.28,98.54 222.28,95.63 ; 222.28,95.63 222.28,95.12 222.81,94.59 222.81,92.68 219.84,89.71 216.4,89.71 213.25,86.56 194.44,86.56 194.05,86.96 191,86.96 190.61,86.56 185.04,86.56 184.36,87.24 v1(180.3,87.24) ; 222.28,95.63 v2(222.57,95.63)
USBN14: length 218.1
  TOP w0.102: v1(165.18,48.39) 165.48,48.08 165.48,47.78 165.28,47.58 PCH.AK11 ; UL75.4 22.74,114.33 22.89,114.48 23.1,114.48 25.66,111.91 27.25,111.91 v1(27.81,112.47)
  BOTTOM w0.102: 27.25,110.62 v2(27.56,110.62) ; 27.25,110.62 27.25,111.68 27.53,111.96 27.53,112.19 v1(27.81,112.47) ; 27.25,110.62 27.25,107.06 27.56,106.76 27.56,65.79 32.89,60.45 32.89,49.48 45.95,36.42 56.01,36.42 56.46,36.88 79.55,36.88 80,37.33 128.88,37.33 130.11,38.55 137.39,38.55 139.76,40.92 141.62,40.92 143.88,43.18 147.64,43.18 147.98,43.52 152.74,43.52 152.75,43.52 153.14,43.52 153.15,43.52 154.91,45.28 154.91,46.48 157.75,49.33 160.01,49.33 160.36,48.97 161.9,48.97 162.09,48.78 164.23,48.78 164.85,48.16 165.06,48.16 165.18,48.27 v1(165.18,48.39)
USBP1: length 283.3
  TOP w0.102: UL66.2 28.11,182.02 28.29,182.19 28.75,182.19 v1(29.01,181.94) ; v1(162.99,48.16) 162.7,48.45 162.7,48.84 PCH.AH7
  BOTTOM w0.102: 25.78,163.53 25.78,160.91 26.04,160.66 26.04,147.49 25.34,146.79 25.34,145.84 24.98,145.48 24.98,139.19 25.67,138.49 25.67,137.21 26.33,136.55 26.33,123.46 25.83,122.97 25.55,119.98 25.55,117.53 27.1,114.7 27.1,113.95 26.35,112.39 26.35,105.82 26.61,105.57 26.61,65.43 31.98,60.06 31.98,49.12 45.56,35.53 56.4,35.53 56.85,35.99 79.92,35.99 80.36,36.44 129.25,36.44 130.48,37.66 137.87,37.66 139.76,39.55 141.51,39.55 144.25,42.29 148.01,42.29 148.35,42.63 152.38,42.63 153.51,42.63 154.08,43.2 155.06,43.2 159.48,47.62 162.46,47.62 v1(162.99,48.16) ; 25.78,163.53 25.78,175.09 27.98,179.91 29.62,181.54 29.62,181.98 29.46,182.14 29.21,182.14 v1(29.01,181.94) ; 25.78,163.53 v2(25.48,163.53)
USBP2: length 266.2
  TOP w0.102: v1(162.94,50.55) 162.64,50.24 PCH.AE7 ; URN137.1 28.12,180.47 28.24,180.59 29.84,180.59 30.93,179.5 33.46,179.5 v1(33.71,179.25)
  BOTTOM w0.102: v1(162.94,50.55) 162.94,50.95 162.84,51.05 162.56,51.05 162.51,51.1 162.51,51.49 161.82,52.17 154.42,52.17 153.53,51.28 134.12,51.28 131.2,48.36 118.09,48.36 117.71,47.98 101.05,47.98 100.21,47.14 86.47,47.14 83.58,50.02 63.88,50.02 62.75,51.16 60.41,51.16 58.43,53.13 48.23,53.13 42.21,59.14 42.21,61.83 31.72,72.32 31.72,100.51 33.17,101.96 33.17,118.68 31.64,120.21 31.64,136.11 30.68,137.07 30.68,141.33 29.87,142.14 29.87,144.57 30.4,145.1 30.4,148.45 31.46,149.51 31.46,152.56 30.82,153.2 30.82,162.37 30.1,163.1 30.1,167.56 32.14,169.61 32.14,178.21 ; 32.14,178.21 32.14,178.62 32.99,179.46 33.51,179.46 v1(33.71,179.25) ; 32.14,178.21 v2(32.44,178.21)
USBP3: length 273.1
  TOP w0.102: PCH.AH10 163.77,49.3 v1(163.77,49.57) ; URN139.1 28.05,185.27 28.27,185.5 32.71,185.5 33.41,184.79 34.03,184.79 v1(34.26,184.56)
  BOTTOM w0.102: v1(34.26,184.56) 33.89,184.56 33.63,184.3 33.63,181.32 31.15,178.85 30.02,176.86 30.02,169.98 29.41,169.37 29.41,168.78 ; v2(29.72,168.78) 29.41,168.78 ; 29.41,168.78 29.41,162.59 30.14,161.86 30.14,149.97 29.72,149.55 29.72,146.04 29.18,145.5 29.18,141.85 29.98,141.05 29.98,135.86 30.95,134.89 30.95,119.9 32.41,118.44 32.41,102.16 31.04,100.79 31.04,71.92 41.53,61.43 41.53,58.86 47.94,52.45 58.13,52.45 60.1,50.47 62.46,50.47 63.6,49.33 83.3,49.33 86.35,46.28 100.45,46.28 101.46,47.29 118,47.29 118.38,47.68 131.49,47.68 134.41,50.6 153.82,50.6 154.67,51.45 160.26,51.45 161.61,50.09 163.25,50.09 v1(163.77,49.57)
USBP4: length 267.9
  TOP w0.089: 158.15,49.91 158.32,49.91 158.5,50.09 159.12,50.09 159.49,50.09 159.87,50.32 160.04,50.39 160.15,50.45 160.24,50.51 160.29,50.53 160.47,50.53 160.51,50.52 160.52,50.52 160.64,50.42 160.72,50.35 PCH.AE3
  TOP w0.102: 158.15,49.91 157.73,49.91 157.19,49.38 155.44,49.38 154.75,50.06 144.36,50.06 144.23,49.94 141.52,49.94 140.78,49.2 v1(140.48,49.2) ; UL68.2 28.1,183.79 28.28,183.96 31.54,183.96 v1(31.78,183.73)
  BOTTOM w0.102: v1(140.48,49.2) 140.48,48.89 139.3,47.72 133.47,47.72 132.03,46.28 118.93,46.28 118.55,45.9 116.33,45.9 115.95,45.52 102.16,45.52 101.34,44.69 86,44.69 82.73,47.96 63.03,47.96 62.32,48.67 58.93,48.67 58.44,49.16 56.33,49.16 52.95,49.16 51.49,50.62 51.32,50.62 47.83,50.62 40.16,58.29 40.16,60.81 29.67,71.3 29.67,101.97 30.36,102.66 30.36,109.54 29.31,110.59 29.31,118.25 28.19,119.36 28.19,122.38 27.91,122.66 27.91,137.19 27.25,137.86 27.25,139.15 26.63,139.77 26.63,144.9 27.13,145.4 27.13,146.36 27.61,146.84 27.61,156.59 ; 27.61,156.59 27.61,157.76 27.94,158.09 27.94,175.91 29.92,179.6 31.19,180.87 31.19,183.81 31.35,183.97 31.53,183.97 v1(31.78,183.73) ; 27.61,156.59 v2(27.91,156.59)
USBP5: length 276.8
  TOP w0.089: PCH.AC3 160.6,51.61 159.65,51.61 159.64,51.61
  TOP w0.102: 159.64,51.61 158.23,51.61 157.82,51.2 156.59,51.2 156.13,50.75 139.47,50.75 138.48,49.77 138.48,49.58 v1(138.27,49.36) ; v1(31.91,195.17) 31.67,195.4 31.32,195.4 31.14,195.23 UL8.2
  BOTTOM w0.102: v1(31.91,195.17) 31.62,195.45 31.5,195.45 31.39,195.34 31.39,190.83 ; 31.39,190.83 31.39,187.94 32.56,186.77 32.56,181.25 30.63,179.32 29.98,178.18 29.34,177.05 29.34,170.28 28.73,169.67 28.73,160.79 29.45,160.07 29.45,150.32 29.03,149.9 29.03,146.32 28.5,145.79 28.5,139.84 28.8,139.54 28.8,138.25 29.29,137.76 29.29,134.72 30.26,133.74 30.26,119.57 31.52,118.31 31.52,102.69 30.35,101.52 30.35,71.64 40.84,61.15 40.84,58.58 47.76,51.66 57.68,51.66 58.55,50.8 58.55,50.02 59.21,49.36 62.6,49.36 63.31,48.65 83.01,48.65 86.23,45.44 100.95,45.44 101.72,46.2 115.37,46.2 115.77,46.61 118.28,46.61 118.64,46.96 131.75,46.96 133.6,48.82 138.36,48.82 138.49,48.95 138.49,49.15 v1(138.27,49.36) ; 31.39,190.83 v2(31.7,190.83)
USBP6: length 281
  TOP w0.089: 158.62,49.35 158.79,49.52 159.78,49.52 159.89,49.62 PCH.AF1
  TOP w0.102: UL7.2 31.17,196.75 31.34,196.93 31.67,196.93 31.9,196.7 v1(31.9,196.62) ; v1(142.39,49.23) 142.39,48.87 142.47,48.79 143.17,48.79 143.48,48.49 144.51,48.49 145.19,49.17 154.38,49.17 155.08,48.48 157.42,48.48 157.99,49.05 158.32,49.05 158.62,49.35
  BOTTOM w0.102: 30.51,187.3 30.51,181.15 28.87,179.51 27.25,176.14 27.25,158.42 26.92,158.09 26.92,147.12 26.23,146.43 26.23,145.47 25.87,145.11 25.87,139.55 26.56,138.86 26.56,137.58 27.22,136.92 27.22,122.99 26.9,122.67 26.9,119.68 28.6,117.98 28.6,110.21 29.67,109.14 29.67,102.94 28.98,102.25 28.98,70.97 39.47,60.48 39.47,58.01 47.54,49.94 51.08,49.94 52.54,48.48 56.62,48.48 58.16,48.48 58.64,47.99 62.03,47.99 62.74,47.28 82.45,47.28 85.79,43.93 101.62,43.93 102.49,44.81 117.86,44.81 118.26,45.21 131.93,45.21 133.46,46.74 139.66,46.74 140.56,47.64 141.92,47.64 142.82,48.54 142.82,48.74 142.75,48.82 142.47,48.82 142.39,48.9 v1(142.39,49.23) ; 30.51,187.3 v2(30.81,187.3) ; 30.51,187.3 30.51,196.14 31.42,197.05 31.6,197.05 31.9,196.75 v1(31.9,196.62)
USBP7: length 159.4
  TOP w0.089: 158.12,51.98 158.13,51.99 159.91,51.99 PCH.AB1
  TOP w0.102: U942691.3 222.56,113.48 v1(222.3,113.22) ; v1(174.89,92.27) 174.89,91.99 174.82,91.92 158.17,91.92 156.89,90.63 151.05,90.63 149.67,89.26 148.54,89.26 141.81,82.52 141.81,73.67 138.3,70.17 138.3,56.04 143.12,51.23 155.96,51.23 156.31,51.58 157.5,51.58 157.9,51.98 158.12,51.98
  BOTTOM w0.102: v1(222.3,113.22) 222.54,113.46 222.92,113.46 223.11,113.26 223.11,110.93 221.51,103.45 221.51,101.55 214.19,94.23 214.19,91.28 211.88,88.96 208.59,88.96 207.91,89.65 200.52,89.65 199.69,88.82 195.38,88.82 194.98,89.22 190,89.22 189.61,88.82 187.49,88.82 181.76,92.44 178.94,92.44 ; 178.94,92.44 175.94,92.44 175.7,92.2 175.54,92.2 175.41,92.33 175.41,92.46 175.31,92.56 175.03,92.56 174.89,92.42 v1(174.89,92.27) ; 178.94,92.44 v2(178.94,92.74)
USBP8: length 235.3
  TOP w0.089: v1(163.11,46.15) 162.94,46.15 162.74,46.35 PCH.AM7
  TOP w0.102: J60.3 27.92,122.56 28.13,122.35 28.13,122.11 27.13,121.11 25.51,121.11 24.09,119.69 24.09,118.76 v1(23.8,118.47)
  BOTTOM w0.102: 24.27,117.35 24.27,117.06 25.16,116.17 25.16,114.87 24.98,114.69 24.98,105.25 25.23,105 25.23,63.42 26.29,62.36 26.29,46.48 34.63,38.14 36.05,38.14 42.75,31.44 42.75,29.94 43.88,28.8 110.08,28.8 110.5,28.38 114.12,28.38 114.47,28.03 118.08,28.03 118.75,28.7 119.9,28.7 120.25,29.06 129.29,29.06 131.63,31.39 140.64,31.39 143.86,34.61 145.33,34.61 148.12,37.4 149.34,37.4 152.34,40.4 153.22,40.4 154.57,41.75 155.6,41.75 160.55,46.71 162.55,46.71 v1(163.11,46.15) ; 24.27,117.35 v2(23.98,117.35) ; 24.27,117.35 24.27,118 v1(23.8,118.47)
USBP9: length 180.3
  TOP w0.102: UL74.2 230.36,132.48 230.53,132.31 230.53,131.75 v1(230.35,131.57) ; v1(177.6,90.61) 177.77,90.61 178,90.37 178,90.25 177.92,90.16 170.59,90.16 170.1,90.65 158.17,90.65 157.14,89.63 151.44,89.63 150.09,88.29 148.86,88.29 142.7,82.12 142.7,73.3 139.24,69.85 139.24,56.36 143.48,52.12 155.5,52.12 155.78,52.4 157.07,52.4 157.42,52.76 159.7,52.76 159.8,52.65 160.18,52.65 160.28,52.56 PCH.Y2
  BOTTOM w0.102: v1(230.35,131.57) 230.35,131.24 230.45,131.14 230.71,131.14 230.81,131.04 230.81,130.86 227.5,127.55 227.5,124.78 225.3,122.58 225.3,108.23 224.64,107.57 224.64,106.38 224.04,105.79 224.04,104.75 ; 224.04,104.75 v2(223.75,104.75) ; 224.04,104.75 224.04,104.29 222.2,102.45 222.2,101.27 214.88,93.94 214.88,90.76 212.38,88.27 208.32,88.27 207.62,88.96 206,88.96 205.17,88.14 195.09,88.14 194.7,88.53 190.31,88.53 189.92,88.14 185.94,88.14 183.92,90.15 177.42,90.15 177.35,90.23 177.35,90.36 v1(177.6,90.61)
USBP10: length 226.9
  TOP w0.089: PCH.AK7 162.88,47.58 163.14,47.31 v1(163.14,47.02)
  TOP w0.102: v1(25.86,114.12) 25.86,113.85 25.7,113.69 25.15,113.69 23.22,115.62 22.1,115.62 21.59,116.13 21.59,116.21 21.79,116.4 UL10.1
  BOTTOM w0.102: v2(144.37,35.51) 144.37,35.81 ; 144.37,35.81 145.22,35.81 149.4,39.99 150.96,39.99 152.06,41.08 152.94,41.08 154.37,42.51 155.34,42.51 160.06,47.23 162.93,47.23 v1(163.14,47.02) ; 144.37,35.81 143.94,35.81 140.21,32.08 131.24,32.08 128.91,29.74 119.97,29.74 119.61,29.39 118.47,29.39 117.8,28.71 114.75,28.71 114.4,29.06 110.79,29.06 110.36,29.49 96.85,29.49 96.09,30.25 89.3,30.25 88.44,31.11 64.95,31.11 64.62,30.78 60.42,30.78 59.71,31.49 43.67,31.49 36.34,38.82 34.91,38.82 27,46.74 27,63.06 25.92,64.14 25.92,105.28 25.67,105.54 25.67,113.92 v1(25.86,114.12)
USBP11: length 178.7
  TOP w0.102: v1(232.03,130.2) 232.23,130.4 232.23,130.76 232.01,130.98 URN144.1 ; PCH.W1 160.1,52.94 160.17,53.01 160.17,53.13 160.09,53.21 157.33,53.21 157.02,52.91 155.58,52.91 155.28,52.6 143.7,52.6 139.78,56.53 139.78,69.7 143.18,73.1 143.18,81.76 149.21,87.79 150.36,87.79 151.65,89.09 157.33,89.09 158.41,90.17 169.54,90.17 171.15,88.56 178.35,88.56 178.52,88.73 v1(178.52,88.99)
  BOTTOM w0.102: v1(232.03,130.2) 232.21,130.02 232.21,129.73 228.26,125.78 228.26,124.09 225.98,121.81 225.98,107.92 225.32,107.26 225.32,106.1 224.73,105.5 224.73,104 222.94,102.21 222.94,100.47 221.01,98.54 221.01,92.25 219.38,90.62 216.05,90.62 212.88,87.45 194.81,87.45 194.41,87.85 190.61,87.85 190.22,87.45 185.6,87.45 184.35,88.7 182.07,88.7 ; 182.07,88.7 v2(182.07,88.99) ; 182.07,88.7 180.95,88.7 180.49,89.15 178.99,89.15 178.83,88.99 v1(178.52,88.99)
USBP12: length 218.9
  TOP w0.089: 159.41,50.95 159.43,50.95 159.45,50.97 160.08,50.97 160.2,50.85 160.5,50.85 PCH.AD2
  TOP w0.102: v1(156.95,50.04) 156.95,50.26 157.16,50.47 158.22,50.47 158.7,50.95 159.41,50.95 ; v1(28.22,107.49) 28.57,107.14 28.57,106.99 28.5,106.91 26.83,106.91 15.43,118.31 14.98,118.31 14.81,118.49 UL9.1
  BOTTOM w0.102: 28.68,105.16 v2(28.37,105.16) ; 28.68,105.16 28.68,106.85 28.57,106.96 28.04,106.96 27.94,107.06 27.94,107.21 v1(28.22,107.49) ; 28.68,105.16 28.68,103.61 28.04,102.97 28.04,66.03 33.48,60.6 33.48,51.62 44.35,40.74 53.56,40.74 54.33,39.97 54.33,39.4 55.09,38.63 80.62,38.63 81.45,37.81 128.68,37.81 129.91,39.03 137.19,39.03 139.56,41.4 141.4,41.4 143.69,43.69 147.42,43.69 147.74,44.01 152.95,44.01 154.42,45.48 154.42,46.73 156.77,49.07 156.77,49.86 v1(156.95,50.04)
USBP13: length 146.8
  TOP w0.102: U51.3 224.33,101.6 v1(224.26,101.68) ; PCH.V2 160.32,53.66 155.32,53.66 154.95,53.29 144.01,53.29 140.49,56.81 140.49,69.38 143.87,72.76 143.87,81.47 149.46,87.07 150.77,87.07 152.1,88.4 157.63,88.4 158.72,89.48 169.18,89.48 171.78,86.88 179.65,86.88 179.83,87.06 v1(179.83,87.7)
  BOTTOM w0.102: 222.07,98.27 222.07,98.62 224.76,101.32 224.76,101.85 224.65,101.96 224.54,101.96 v1(224.26,101.68) ; 222.07,98.27 v2(221.78,98.27) ; 222.07,98.27 222.07,95.04 222.61,94.51 222.61,92.76 219.76,89.92 216.32,89.92 213.17,86.77 194.52,86.77 194.13,87.16 190.92,87.16 190.53,86.77 185.12,86.77 184.45,87.44 180.69,87.44 180.43,87.7 v1(179.83,87.7)
USBP14: length 218.1
  TOP w0.102: v1(165.87,48.32) 165.68,48.13 165.68,47.68 PCH.AK13 ; v1(27.17,112.5) 27.17,112.23 27.05,112.12 25.75,112.12 23.18,114.69 22.96,114.69 22.76,114.88 UL75.1
  BOTTOM w0.102: 27.36,106.3 v2(27.05,106.3) ; 27.36,106.3 27.36,106.67 27.05,106.98 27.05,111.76 27.33,112.04 27.33,112.33 v1(27.17,112.5) ; 27.36,106.3 27.36,65.7 32.69,60.37 32.69,49.39 45.86,36.22 56.09,36.22 56.55,36.68 79.63,36.68 80.08,37.12 128.97,37.12 130.19,38.35 137.47,38.35 139.84,40.72 141.71,40.72 143.97,42.98 147.72,42.98 148.06,43.32 152.66,43.32 153.23,43.32 155.11,45.2 155.11,46.4 157.84,49.12 159.92,49.12 160.28,48.77 161.82,48.77 162.01,48.58 164.14,48.58 164.77,47.96 165.51,47.96 v1(165.87,48.32)
UU45_EN: length 4.6
  TOP w0.102: v1(13.97,140.17) 14.61,140.81 UU45.4 15.58,140.81 15.68,140.7 UR30.2 16.18,140.26 15.95,140.03 CB4107.1
  BOTTOM w0.102: v2(13.34,140.61) 13.53,140.61 v1(13.97,140.17)
UU47_EN: length 3.9
  TOP w0.102: UU47.4 22.25,226.93 22.53,227.2 CB4115.1 23.27,227.2 23.43,227.37 UR69711.1 v1(24.56,227.37)
  BOTTOM w0.102: v1(24.56,227.37) v2(23.71,227.37)
UU49_48_EN: length 5.3
  TOP w0.102: CR19.2 39.1,200.58 39.37,200.58 v1(39.57,200.38) 39.78,200.58 41.5,200.58 41.72,200.8 TUU2.4
  BOTTOM w0.102: v2(40.31,200.71) 39.9,200.71 v1(39.57,200.38)
UU51_EN: length 4.8
  TOP w0.102: v1(228.5,139.05) UR69714.2 UR69729.2 CB4122.1 227.72,136.75 227.72,136.75 UU51.4
  BOTTOM w0.102: v2(229.21,138.58) 228.97,138.58 v1(228.5,139.05)
UU54_EN: length 55.5
  TOP w0.102: U5.31 19.8,145.46 20.66,144.59 21.27,144.59 21.92,143.94 22.33,143.94 22.42,144.03 CB4128.1 23.53,144.03 CB4127.1 APR112.2 23.83,144.67 22.24,144.67 v1(22.07,144.5) ; UU54.4 36.26,161.48 35.8,161.95 35.8,165.27 35.13,165.94 30.56,165.94 26.79,162.17 v1(16.99,162.17)
  BOTTOM w0.102: v1(16.99,162.17) 16.99,160.46 v2(17.51,159.93) 22.53,154.92 22.53,149.59 22.58,149.53 22.58,148.77 22.34,148.52 22.34,144.77 v1(22.07,144.5)
V_IN: length 7.9
  TOP w0.102: U104.46 224.14,31.64 v1(224.18,31.68) 224.38,31.88 224.38,32.42 224.92,32.96 226.78,32.96 226.9,32.84 O2CB19.1 227.5,33.01 O2R2.1 228.24,33.38 228.33,33.46 O2R22.2
  BOTTOM w0.102: v2(224.95,31.68) v1(224.18,31.68)
VCORE_EN: length 848.3
  TOP w0.102: v1(26.16,34.42) 21.97,38.61 21.97,56.69 24.51,59.23 24.51,62.49 24.1,62.9 24.1,95.02 35.92,106.85 44.51,106.85 47.09,109.42 49.86,109.42 53.31,112.87 58.08,112.87 60.1,114.89 60.47,114.89 60.71,115.14 60.71,115.51 60.82,115.61 60.82,121.06 PR70228.2 PR70189.2 ; PR70238.2 125.01,91.91 125.22,91.69 126.11,91.69 126.97,90.83 130.47,90.83 130.9,91.26 132.88,91.26 132.93,91.21 137.49,91.21 140.84,94.56 140.84,95.88 143.56,98.59 151.09,98.59 v1(151.64,98.04) ; v1(216.47,97.55) 214.4,95.47 214.4,90.15 219.47,85.07 219.47,78.91 222.99,75.39 222.99,70.86 213.4,61.26 213.4,56.63 v1(212.85,56.08) ; v1(131.95,15.13) 131.95,13.98 138.18,7.75 145.02,7.75 145.55,7.21 150.37,7.21 150.56,7.02 169.72,7.02 172.68,9.99 172.68,11 172.29,11.4 172.29,12.65 v1(172.48,12.84) ; v1(69.95,221.84) 69.89,221.91 PR5859.1
  BOTTOM w0.102: v1(212.85,56.08) 212.62,55.85 212.62,52.57 215.46,49.73 215.46,46.57 216.42,45.61 216.42,41.72 217.23,40.91 217.23,36.25 216.42,35.44 216.42,32.5 216.5,32.42 216.5,31.62 216.34,31.46 216.34,28.8 212.44,24.89 208.3,24.89 205.13,21.72 205.13,19.99 203.54,18.4 203.54,17.5 202.17,16.13 200.75,16.13 200.22,15.59 197.95,15.59 197.59,15.96 189.54,15.96 188.17,14.59 183.62,14.59 182.82,13.79 182.05,13.79 180.42,13.79 176.04,13.79 174.78,13.79 174.49,13.5 173.14,13.5 v1(172.48,12.84) ; v1(26.16,34.42) v2(26.16,33.45) 26.16,29.75 28.83,27.09 28.83,26 40.75,14.08 59.9,14.08 60.14,13.85 61.86,13.85 61.95,13.94 88.02,13.94 88.42,13.54 90.94,13.54 91.2,13.54 92.04,14.37 105.39,14.37 105.79,13.97 105.87,13.97 105.87,13.97 106.05,13.97 121.96,13.97 122.72,14.73 130.23,14.73 131.04,15.54 131.54,15.54 v1(131.95,15.13) ; v1(69.95,221.84) 70.21,222.1 70.21,225.62 71.91,227.33 71.91,228.63 76.62,233.35 86.28,233.35 89.7,236.77 100.52,236.77 101.96,235.33 103.81,235.33 106.85,232.29 117.34,232.29 118.27,231.36 130.52,231.36 132,232.84 143.93,232.84 144.59,232.18 145.92,232.18 146.18,232.44 154.6,232.44 159.26,227.77 169.17,227.77 175.41,234.02 208.73,234.02 208.88,234.18 210.49,234.18 215.99,228.68 224.52,228.68 230.39,222.81 230.39,214.29 229.79,213.69 229.79,213.29 229.79,204.6 227.97,202.77 227.97,191.33 226.39,189.75 226.39,188.23 226.11,187.95 226.11,185.57 227.46,184.23 227.46,175.88 227.53,175.8 227.53,167.44 226.02,165.93 226.02,150.04 229.81,146.26 229.81,143.27 225.56,139.03 225.56,133.93 220.48,128.85 220.48,126.03 222.2,124.32 222.2,121.5 219.08,118.38 219.08,111.76 216.54,109.22 216.54,107 217.43,106.11 217.43,102.38 216.85,101.8 216.85,99.36 217,99.21 217,98.08 v1(216.47,97.55) 216.47,97.22 213.71,94.45 213.71,91.48 211.68,89.45 208.93,89.45 207.38,91 207.38,93.92 206.59,94.7 201.85,94.7 200.89,95.67 198.23,95.67 196.7,94.14 190.51,94.14 189.2,92.84 184.48,92.84 183.35,93.97 173.15,93.97 170.45,96.67 153.01,96.67 v1(151.64,98.04)
VGT_COMP_A: length 6
  TOP w0.203: PU581.34 79.44,222.4
  TOP w0.254: PR5851.2 81.18,225.45 81.06,225.34 PC5823.2 80.62,224.35 80.61,224.35 v1(80.28,224.02) 79.44,223.18 79.44,222.4
  BOTTOM w0.254: v1(80.28,224.02) 80.28,224.55 v2(80.54,224.82)
VGT_COMP_R_A: length 2.7
  TOP w0.254: v1(81.64,227.58) 81.18,227.13 PR5851.1 PR5849.2
  BOTTOM w0.102: v1(81.64,227.58) v2(82.4,227.58)
VGT_FB_A: length 9.3
  TOP w0.203: PU581.35 79.04,222.66
  TOP w0.254: 79.04,222.66 79.04,223.41 79.63,224 79.63,224.19 PC5823.1 80.23,225.34 80.26,225.37 PR5849.1 79.55,226.61 v1(79.55,227.32) 79.55,227.47 PC5821.2 PR5850.2
  BOTTOM w0.254: v2(80.47,227.51) 79.74,227.51 v1(79.55,227.32)
VGT_IMON_A: length 6.1
  TOP w0.203: PU581.22 82.36,218.73 82.71,219.07
  TOP w0.254: 82.71,219.07 84.06,219.07 v1(85.1,220.11) 85.49,220.5 85.59,220.5 PR5866.2
  BOTTOM w0.254: v1(85.1,220.11) 85.1,220.81 v2(85.17,220.88)
VGT_IMON_F: length 2.7
  TOP w0.254: PR5866.1 86.98,220.85 v1(87.44,221.32) 87.56,221.44 PR5869.2
  BOTTOM w0.102: v2(86.56,221.97) 87.22,221.32 v1(87.44,221.32)
VGT_IMON_NTC_A: length 12
  TOP w0.254: PRT582.2 99.81,216.6 99.78,216.57 v1(99.21,216.57) 98.54,215.9 95.7,215.9 91.97,219.63 91.94,219.63 PR5865.1
  BOTTOM w0.102: v1(99.21,216.57) v2(99.21,215.65)
VGT_IMON_R2_A: length 3.7
  TOP w0.254: PR5869.1 89.31,221.44 89.48,221.62 v1(89.92,221.62) 90.2,221.34 90.2,221.3 PR5864.2 PR5865.2
  BOTTOM w0.102: v1(89.92,221.62) 89.92,220.93 v2(90.04,220.8)
VGT_ISEN1_N_A: length 5
  TOP w0.203: PU581.39 77.44,222.92
  TOP w0.254: 77.44,222.92 v1(76.17,224.18) 75.93,224.18 75.7,224.41 PR5807.1
  BOTTOM w0.102: v2(76.61,223.55) 76.17,223.98 v1(76.17,224.18)
VGT_ISEN1_P_A: length 8.9
  TOP w0.203: PU581.38 77.84,222.66
  TOP w0.254: PR5883.1 76.81,227.9 PR5813.1 76.2,227.29 76.2,225.71 PC5807.1 76.9,224.47 v1(77.08,224.29) 77.84,223.53 77.84,222.66
  BOTTOM w0.102: v2(76.99,225.45) 76.95,225.41 76.95,224.42 v1(77.08,224.29)
VGT_ISEN1N_A: length 44.3
  TOP w0.254: PC5807.2 76.9,227.04 v1(77.01,227.15) ; PR5807.2 75.7,227.23 PR5813.2 75.9,227.83 PC5808.1 75.36,228.47 v1(75.21,228.32)
  BOTTOM w0.254: PJP612.2 104.19,215.72 101.42,215.72 98.78,218.36 94.69,218.36 92.62,220.44 92.62,224.69 89.09,228.22 85.81,228.22 83.88,226.29 77.88,226.29 v1(77.01,227.15) v2(76.45,227.71) 75.84,228.32 v1(75.21,228.32)
VGT_ISEN1P_A: length 42.9
  TOP w0.254: v1(77.28,229.76) 76.81,229.29 PR5883.2
  BOTTOM w0.254: PJP611.2 105.18,216.15 101.63,216.15 98.93,218.85 95.03,218.85 93.12,220.76 93.12,224.81 89.2,228.73 85.6,228.73 83.58,226.71 79.29,226.71 v2(78.64,227.36) 77.28,228.72 v1(77.28,229.76)
VGT_ISEN2_N_A: length 4.7
  TOP w0.203: PU581.36 78.64,223.62
  TOP w0.254: 78.64,223.62 79.07,224.05 v1(79.07,224.23) 79.07,224.68 PR5877.1
  BOTTOM w0.102: v1(79.07,224.23) 79.07,223.57 v2(79.35,223.29)
VGT_ISEN2_P_A: length 8.2
  TOP w0.203: PU581.37 78.24,222.96
  TOP w0.254: PR5884.1 77.72,227.89 77.79,227.83 PR5808.1 77.58,227.23 77.58,225.69 PC5809.1 78.27,224.29 v1(78.26,224.28) 78.24,224.26 78.24,222.96
  BOTTOM w0.102: v2(78.71,225.17) 78.71,224.76 78.26,224.3 v1(78.26,224.28)
VGT_ISEN2N_A: length 62.9
  TOP w0.254: v1(99.76,219.13) 99.76,218.38 102.18,215.95 104.62,215.95 108.41,212.17 115.47,212.17 116.56,213.26 v1(117.04,213.26) ; v1(79.32,228.24) 79.1,228.47 PC5810.1 78.64,227.9 78.63,227.89 PR5808.2 78.27,227.08 PC5809.2 78.83,225.79 PR5877.2
  BOTTOM w0.254: PJP614.2 125.88,215.77 122.17,215.77 v2(120.6,214.2) 119.66,213.26 v1(117.04,213.26) ; v1(79.32,228.24) 83.67,228.24 84.66,229.24 89.31,229.24 93.52,225.02 96,225.02 99.76,221.26 v1(99.76,219.13)
VGT_ISEN2P_A: length 66.2
  TOP w0.254: PR5884.2 78.22,229.64 79.86,229.64 v1(80.01,229.49) ; v1(100.3,219.63) 100.3,218.47 102.39,216.38 104.8,216.38 108.64,212.55 115.29,212.55 v1(116.56,213.82)
  BOTTOM w0.254: v1(80.01,229.49) 80.51,228.99 81.78,228.99 82.52,229.74 89.43,229.74 93.42,225.76 95.99,225.76 100.3,221.44 v1(100.3,219.63) ; v2(130.23,211.73) 130.23,212.78 PJP613.2 126.72,216.28 122.16,216.28 121.06,215.18 120.31,215.18 118.95,213.82 v1(116.56,213.82)
VGT_ISEN3_N_A: length 20.3
  TOP w0.203: PU581.40 77.04,222.17 v1(76.86,222.35) 76.64,222.13 PU581.41
  TOP w0.254: PR5809.1 79.02,205.97 79.71,206.65 79.71,207.39 v1(79.93,207.62)
  BOTTOM w0.254: v1(79.93,207.62) v2(78.69,208.86) 77.55,210.01 77.55,221.67 v1(76.86,222.35)
VGT_PWM1_A: length 35.2
  TOP w0.203: PU581.47 75.2,219.93 75.08,220.04 v1(74.65,220.04)
  TOP w0.254: v1(93.7,228.12) 94.11,227.71 PU611.2
  BOTTOM w0.254: v1(93.7,228.12) 93.7,228.47 93.09,229.08 90.73,229.08 89.57,230.24 89.57,230.6 89.25,230.92 75.95,230.92 74.55,229.53 v2(74.55,227.51) 74.55,226.59 72.3,224.35 72.3,223.74 74.94,221.09 74.94,220.33 v1(74.65,220.04)
VGT_PWM1_BOT_C: length 0.9
  BOTTOM w0.102: v1(94.51,228.9) 94.51,229.59 v2(94.67,229.74)
VGT_PWM1_BOTR_C: length 1
  BOTTOM w0.102: v1(95.94,229.72) v2(96.9,229.72)
VGT_PWM1_HG_D: length 38.9
  TOP w0.635: PR6103.1 v3(117.97,215.58)
  BOTTOM w0.635: v3(96.65,228.85) v2(99.57,228.85) 101.78,228.85 102.46,229.54 114.88,229.54 117.78,226.64 117.78,220.95 118.31,220.42 119.79,220.42 120.27,219.94 120.27,216.99 118.86,215.58 v3(117.97,215.58)
VGT_PWM1_HGR_D: length 0.8
  BOTTOM w0.635: v2(121.54,217.98) v1(121.54,217.17)
VGT_PWM1_LG_D: length 11.7
  TOP w0.279: PU611.5 97.32,225.74
  TOP w0.635: 97.32,225.74 v3(101.16,225.74)
  BOTTOM w0.635: v3(101.16,225.74) 101.85,225.04 v2(104.6,225.04) v3(107.37,225.04)
VGT_PWM1_SN: length 0.8
  BOTTOM w0.508: v2(114.83,222.17) v1(114.83,222.96)
VGT_PWM1_SW_C: length 35.3
  TOP w0.889: 110.08,214.04 PL611.1 ; PL611.1 108.75,215.38 ; PL611.1 110.08,216.71 ; PL611.1 111.41,215.38
  BOTTOM w0.635: v3(99.92,226.82) 101.58,226.82 103.54,228.78 114.38,228.78 116.05,227.1 v3(116.05,220.5)
  BOTTOM w0.889: 111.5,215.38 PL611.1 ; PL611.1 110.08,216.8 ; PL611.1 108.66,215.38 ; PL611.1 110.08,213.95
  vias: v2(102.87,220.68) v3(102.21,218.57) v3(103.91,217.7) v3(105.97,217.02) v3(107.14,219.46) v3(107.16,223.75) v3(107.16,221.67) v3(107.29,215.72) v3(108.25,217.75) v3(111.84,217.83) v3(112.67,214.96) v3(113.16,223.72) v3(113.16,219.53) v3(115.39,217.25) v3(117.88,217.22) v3(118.95,218.62)
VGT_PWM1_VCC_C: length 11
  TOP w0.254: PR6102.2 90.85,228.87 90.5,228.52 90.5,224.43 v1(90.91,224.03)
  TOP w0.279: PU611.4 93.98,226.71 93.87,226.59 PC6108.1
  TOP w0.508: PC6108.1 93.28,226.59 91.54,228.33 PR6102.2
  BOTTOM w0.102: v1(90.91,224.03) 90.91,223.62 90.63,223.34 v2(90.55,223.34)
VGT_PWM2_A: length 91.3
  TOP w0.203: PU581.46 75.19,220.33 74.88,220.64 74.59,220.64 v1(74.4,220.83)
  TOP w0.254: v1(148.29,230.33) 148.29,230.23 147.98,229.93 PU612.2
  BOTTOM w0.254: v1(148.29,230.33) 148.29,229.87 148.01,229.59 146.09,229.59 145.51,230.16 143.88,230.16 143.41,229.7 v2(137.03,229.7) 136.56,230.16 117.83,230.16 116.99,231 98.62,231 97.45,232.17 75.86,232.17 73.41,229.72 73.41,228.87 73.62,228.65 73.62,226.23 71.79,224.4 71.79,223.43 v1(74.4,220.83)
VGT_PWM2_BOT_C: length 0.8
  BOTTOM w0.508: v2(151.66,229.59) v1(150.9,229.59)
VGT_PWM2_BOTR_C: length 0.8
  BOTTOM w0.508: v2(151.46,227.25) v1(150.67,227.25)
VGT_PWM2_HG_D: length 19.9
  TOP w0.635: v3(144.86,225.04) 144.65,224.84 144.65,216.1 141.66,213.11 140.4,213.11
  BOTTOM w0.635: v3(149.17,227.58) v2(148.29,226.7) 148.2,226.61 147.53,226.61 147.53,226.61 146.8,226.61 145.24,225.04 v3(144.86,225.04)
VGT_PWM2_HGR_D: length 0.8
  BOTTOM w0.635: v2(142.53,218.1) v1(143.08,218.64)
VGT_PWM2_LG_D: length 24.8
  BOTTOM w0.635: v3(146.13,227.61) 146.08,227.56 v2(141,227.56) 138.36,227.56 135.87,225.07 v3(128.78,225.07) v3(122.4,225.07)
VGT_PWM2_SN: length 0.8
  BOTTOM w0.508: v2(136.91,222.2) v1(136.91,222.99)
VGT_PWM2_SW_C: length 23.5
  TOP w0.635: 148.16,226.42 147.85,226.11 144.12,226.11 v3(143.81,225.81)
  TOP w0.889: PL612.1 131.8,216.71 ; PL612.1 130.46,215.38 ; PL612.1 131.8,214.04 ; PL612.1 133.13,215.38
  BOTTOM w0.635: 140.78,220.28 142.68,220.28 v2(143.1,220.7) 143.56,221.16 143.56,225.55 v3(143.81,225.81)
  BOTTOM w0.889: PL612.1 131.8,216.8 ; PL612.1 133.22,215.38 ; PL612.1 131.8,213.95 ; PL612.1 130.37,215.38
  vias: v3(122.33,219.18) v3(122.38,223.6) v3(123.49,217.93) v3(125.27,217.32) v3(127.66,216.97) v3(128.42,221.54) v3(128.37,219.48) v3(128.5,223.7) v3(129.29,215.49) v3(129.95,217.83) v3(133.73,213.82) v3(134.44,217.6) v3(134.65,219.51) v3(134.87,223.04) v3(135.13,215.21) v3(137.11,217.27) v3(137.31,219.38) v3(139.5,217.32) v3(140.23,218.59)
VGT_PWM2_VCC_C: length 0.8
  BOTTOM w0.508: v2(144.48,229.59) v1(145.31,229.59)
VGT_SET1_A: length 6.6
  TOP w0.203: PU581.18 82.73,217.13
  TOP w0.254: 82.73,217.13 83.7,216.15 v1(85.17,216.15) PR5841.2 PR5833.2
  BOTTOM w0.102: v2(85.14,215.29) 85.17,215.32 v1(85.17,216.15)
VGT_SET1_R1_A: length 5
  TOP w0.254: PR5833.1 87.31,215.24 v1(87.49,215.06) 87.67,215.24 PR5832.2
  BOTTOM w0.102: v2(86.06,212.14) 86.74,212.83 86.74,214.31 v1(87.49,215.06)
VGT_SET1_R2_A: length 4.6
  TOP w0.254: PR5840.2 87.63,216.15 v1(87.45,216.33) 87.27,216.15 PR5841.1
  BOTTOM w0.102: v2(86.18,213.89) 86.18,215.24 87.27,216.33 v1(87.45,216.33)
VGT_SET2_A: length 6.5
  TOP w0.203: PU581.19 83.01,217.53
  TOP w0.254: 83.01,217.53 83.49,217.04 v1(85.19,217.04) 85.57,217.04 85.6,217.07 PR5838.2 PR5835.2
  BOTTOM w0.102: v2(84.45,217.45) 84.86,217.04 v1(85.19,217.04)
VGT_SET2_R1_A: length 6.6
  TOP w0.254: PR5838.1 v1(87.48,217.07) PR5839.2
  BOTTOM w0.102: v1(87.48,217.07) 85.7,215.29 85.7,215.11 84.56,213.97 v2(84.56,213.03)
VGT_SET2_R2_A: length 3.3
  TOP w0.254: PR5834.2 87.63,217.98 v1(87.45,217.8) 87.27,217.98 PR5835.1
  BOTTOM w0.102: v2(86.08,216.79) 87.1,217.8 v1(87.45,217.8)
VGT_TON_A: length 40.6
  TOP w0.254: PR5854.2 71.13,227.5 v1(70.99,227.63) ; PJP615.1 103.5,235.97 103.12,236.35 v1(102.36,236.35)
  BOTTOM w0.254: v1(70.99,227.63) v2(70.99,228.47) 70.99,229.43 75.71,234.15 85.56,234.15 89.43,238.02 100.69,238.02 v1(102.36,236.35)
VGT_TONSET_A: length 5.1
  TOP w0.203: PU581.43 75.84,222.15
  TOP w0.254: 75.84,222.15 74.48,223.51 v1(74.48,224.14) PR5855.2
  BOTTOM w0.102: v1(74.48,224.14) 74.08,224.54 v2(73.63,224.54)
VGT_TONSET_R_A: length 4.2
  TOP w0.254: v1(71.78,225.93) 71.86,226.01 PR5854.1 PC5826.2 73.39,226.66 73.71,226.34 PR5855.1
  BOTTOM w0.102: v2(71.16,225.41) 71.68,225.93 v1(71.78,225.93)
VGT_TSEN_A: length 7.4
  TOP w0.203: PU581.42 76.24,222.61
  TOP w0.254: PR5872.2 74.21,226.85 74.21,225.45 PR5873.2 75.07,224.59 75.07,224.17 v1(75.35,223.89) 76.24,223 76.24,222.61
  BOTTOM w0.102: v1(75.35,223.89) 75.35,224.88 v2(75.34,224.89)
VGT_TSEN_R1_A: length 31.3
  TOP w0.254: PR5872.1 74.45,228.78 v1(74,229.22) ; v1(99.16,230.38) 101.03,228.51 PRT584.2
  BOTTOM w0.254: v1(74,229.22) 74,229.5 76,231.5 v2(89.79,231.5) 97.38,231.5 98.5,230.38 v1(99.16,230.38)
VGT_VSEN_A: length 11.2
  TOP w0.203: PU581.33 79.84,222.64
  TOP w0.254: 79.84,222.64 v1(81.27,224.07) 81.69,224.49 81.69,224.6 PC5824.1 81.88,225.31 PR5848.2 81.71,226.14 81.71,226.89 82.18,227.36 82.18,228.09 PC5822.1 81.51,228.77 PR5850.1 PC5821.1
  BOTTOM w0.102: v2(81.93,223.66) 81.52,224.07 v1(81.27,224.07)
VIDALERT#: length 20
  TOP w0.102: PR5858.2 87.02,222.68 v1(87.43,223.09) 87.63,223.29 PR5821.2 ; HR20.1 HR33.2 90.09,208.47 90.09,210.85 v1(90.83,211.58)
  BOTTOM w0.102: v1(90.83,211.58) 90.26,212.15 90.26,212.26 v2(89.92,212.6) 88.95,213.56 88.95,222.03 87.9,223.09 v1(87.43,223.09)
VIDSCLK: length 19.9
  TOP w0.102: HR17.2 89.51,211.1 90.83,212.42 v1(91.06,212.42) ; PR5820.2 87.21,224.66 v1(87.44,224.89) 87.67,225.12 PR5817.2
  BOTTOM w0.102: v1(87.44,224.89) 87.99,224.35 87.99,223.68 89.43,222.23 89.43,219.13 89.56,219 v2(89.56,218.54) 89.56,218.11 89.43,217.98 89.43,214.05 v1(91.06,212.42)
VIDSOUT: length 21.1
  TOP w0.102: PR5819.2 87.22,223.62 v1(87.44,223.84) 87.81,224.21 PR5818.2 ; HR18.1 91.44,207.42 91.54,207.52 HR32.2 91.11,208.47 91.11,209.3 91.31,209.5 91.31,210.26 v1(90.75,210.82)
  BOTTOM w0.102: v1(90.75,210.82) 89.2,212.37 89.2,212.63 88.47,213.36 88.47,221.75 v2(88.31,221.91) 87.64,222.58 87.27,222.58 86.96,222.89 86.96,223.36 v1(87.44,223.84)
VPP_PWRGD: length 126.2
  TOP w0.102: PR11.1 216.5,228.13 216.53,228.09 PR12.1 217,228.64 215.29,230.35 211.3,230.35 210.72,229.77 210.72,229.39 210.4,229.07 210.4,225.81 210,225.41 209.03,225.41 208.1,224.49 208.1,221.92 209.3,220.73 209.3,219 207.52,217.22 207.52,197.64 208.13,197.03 v1(208.13,186.74) ; PU7.4 212.34,123.71 213.03,123.01 213.86,123.01 v1(214.03,123.19) PR6607.2
  BOTTOM w0.102: v1(208.13,186.74) 208.13,184.66 207.48,184.01 207.48,169.53 208.84,168.17 208.84,160.3 212.2,156.93 212.2,142.28 213.89,140.59 213.89,140.16 213.16,139.42 213.16,129.9 214.85,128.21 214.85,127.35 213.74,126.24 v2(213.74,125.12) 213.74,123.83 214.03,123.53 v1(214.03,123.19)
VREF: length 6.9
  TOP w0.254: AC23.1 8.62,16.59 9.4,16.59 10.13,17.32 AU1.27 v1(13.08,17.32)
  BOTTOM w0.254: v1(13.08,17.32) 13.4,17.64 13.4,18.58 v2(13.18,18.8)
VRM_ALERT#: length 6.9
  TOP w0.102: PR5858.1 85.09,221.83 85.09,221.62 v1(84.31,220.85) 83.38,219.91 82.5,219.91 82.11,219.53 PU581.24
  BOTTOM w0.102: v1(84.31,220.85) 84.11,220.85 v2(83.52,221.44)
VRM_COMP_A: length 5.3
  TOP w0.203: PU581.11 79.84,215.26
  TOP w0.254: PR5847.2 80.98,212.72 80.94,212.76 PC5816.2 80.94,213.42 v1(80.1,214.26) 79.84,214.52 79.84,215.26
  BOTTOM w0.102: v2(79.78,215.11) 80.1,214.8 v1(80.1,214.26)
VRM_COMP_R_A: length 2.5
  TOP w0.102: PR5846.2 80.01,210.72 80.23,210.5 v1(80.24,210.5)
  TOP w0.254: PR5847.1 80.48,211.19 80.45,211.16 PR5846.2
  BOTTOM w0.102: v1(80.24,210.5) v2(80.24,209.73)
VRM_DVD_A: length 8.3
  TOP w0.203: 75.07,221.1 75.44,220.73 PU581.45
  TOP w0.254: 75.07,221.1 74.42,221.74 PC5830.1 PR5870.2 73.61,223.07 v1(73.61,223.3) 73.61,224.04 73.01,224.64 72.19,224.64 PR5875.2
  BOTTOM w0.102: v1(73.61,223.3) 74.22,222.69 v2(74.22,222.63)
VRM_EN_A: length 31
  TOP w0.203: v1(86.72,226.52) 86.36,226.16 86.36,226 PC5828.1 85.37,225.01 85.37,224.26 81.84,220.73 PU581.27
  TOP w0.254: v1(72.85,224) 72.67,223.82 70.37,223.82 PR5860.2 70.73,222.91 PR5859.2 ; PR70231.2 87.15,226.44 87.07,226.52 v1(86.72,226.52)
  BOTTOM w0.254: v1(72.85,224) 73,223.85 73.94,223.85 74.85,222.94 77.24,222.94 78.32,221.86 v2(81.1,221.86) 81.34,221.86 84.58,225.09 84.58,226.21 85.45,227.08 86.16,227.08 v1(86.72,226.52)
VRM_EN_DISCHARGE: length 2.9
  TOP w0.254: PR2.2 v1(65.96,217.68) PQ2.3
  BOTTOM w0.102: v2(65.96,216.92) v1(65.96,217.68)
VRM_EN_R_A: length 34.2
  TOP w0.254: PR70231.1 89.05,226.44 89.53,226.92 89.53,228.85 89.03,229.36 v1(89.03,230.38) ; PR2.1 v1(65.96,221.41) ; v1(76.33,229.77) 72.64,229.77 71.45,228.57 71.07,228.57 70.18,227.69 v1(70.18,226.95)
  BOTTOM w0.254: v1(70.18,226.95) 69.55,226.31 69.55,224.99 v1(65.96,221.41) ; v1(76.33,229.77) 76.94,230.38 78.49,230.38 v2(78.61,230.25) 78.74,230.38 v1(89.03,230.38)
VRM_FB_A: length 8.5
  TOP w0.203: PU581.10 79.44,215.14
  TOP w0.254: PR5845.2 PC5818.2 79.48,210.38 79.48,211.47 PR5846.1 v1(80.01,212.66) 80.1,212.75 PC5816.1 79.44,214.02 79.44,215.14
  BOTTOM w0.102: v1(80.01,212.66) v2(80.01,211.84)
VRM_IBIAS_A: length 8
  TOP w0.203: 80.87,222.17 80.64,221.94 PU581.31
  TOP w0.254: PR5856.2 84.02,226.5 84.02,225.39 v1(83.6,224.97) 83.6,224.86 80.92,222.17 80.87,222.17
  BOTTOM w0.102: v1(83.6,224.97) 83.21,224.97 v2(82.85,225.32)
VRM_IMON_A: length 5.9
  TOP w0.203: PU581.20 82.6,217.93
  TOP w0.254: PR5867.2 85.62,218.9 v1(85.1,218.38) 84.65,217.93 82.6,217.93
  BOTTOM w0.102: v1(85.1,218.38) 85.1,218.91 84.81,219.2 v2(84.68,219.2)
VRM_IMON_F: length 2.9
  TOP w0.254: PR5868.2 v1(87.5,218.95) 87.48,218.95 87.43,218.9 PR5867.1
  BOTTOM w0.102: v1(87.5,218.95) 86.72,218.95 v2(86.28,218.52)
VRM_IMON_NTC_A: length 44.4
  TOP w0.254: PRT581.2 75.6,184.06 v1(76.11,184.57) ; PR5863.1 91.72,216.85 91.72,214.22 88.93,211.43 88.93,209.57 81.34,201.98 78.03,201.98 v1(77.77,202.23)
  BOTTOM w0.254: v1(76.11,184.57) v2(76.11,186.94) 76.11,187.29 79.73,190.91 79.73,200.28 v1(77.77,202.23)
VRM_IMON_R2_A: length 5.6
  TOP w0.254: PR5868.1 89.37,218.64 89.85,218.64 PR5862.2 PR5863.2 91.88,217.92 92.51,217.3 v1(92.51,216.71)
  BOTTOM w0.102: v1(92.51,216.71) v2(92.51,215.8)
VRM_ISEN1_N_A: length 5.9
  TOP w0.203: 74.83,213.77 75.8,213.77 77.04,215 PU581.4
  TOP w0.254: 74.83,213.77 74.42,213.36 v1(74.3,213.36) 74.21,213.36 PR5811.1
  BOTTOM w0.102: v1(74.3,213.36) v2(74.3,212.57)
VRM_ISEN1_P_A: length 9
  TOP w0.203: v1(75.11,213.23) 75.72,213.23 77.44,214.96 PU581.5
  TOP w0.254: PR5801.1 73.79,210.48 PR5810.1 73.95,210.82 PC5802.1 73.95,211.97 74.47,212.5 74.47,212.6 v1(75.11,213.23)
  BOTTOM w0.102: v2(75.95,213.46) 75.72,213.23 v1(75.11,213.23)
VRM_ISEN1N_A: length 43
  TOP w0.254: PR5811.2 72.61,212.6 PC5802.2 72.61,210.82 PR5810.2 72.64,210.35 PC5801.1 72.97,209.55 73.15,209.37 73.15,208.53 73.66,208.03 73.66,206.5 74.02,206.15 v1(74.68,206.15)
  BOTTOM w0.254: v1(74.68,206.15) 75.41,206.15 80.72,200.84 80.72,188.95 v2(78.71,186.94) 78.71,184.9 77.24,183.43 76.65,183.43 74.24,181.03 73.18,181.03 72.26,180.11 72.26,179.76 72.44,179.58 PJP592.2
VRM_ISEN1P_A: length 38.8
  TOP w0.254: v1(74.24,206.91) 74.24,208.42 PR5801.2
  BOTTOM w0.254: PJP591.2 71.88,178.24 71.88,180.31 73.01,181.43 74.04,181.43 v2(77.5,184.89) 77.5,187.86 80.21,190.57 80.21,200.72 75.44,205.49 74.55,205.49 73.91,206.12 73.91,206.58 v1(74.24,206.91)
VRM_ISEN2_N_A: length 5.5
  TOP w0.216: PU581.7 78.24,214.88
  TOP w0.254: 78.24,214.88 78.24,214.64 76.68,213.08 v1(76.68,212.65) 76.68,212.18 PR5803.1
  BOTTOM w0.102: v1(76.68,212.65) v2(76.68,211.89)
VRM_ISEN2_P_A: length 9.7
  TOP w0.216: PU581.6 77.84,215.15
  TOP w0.254: 77.84,215.15 77.84,214.83 PC5803.1 74.68,211.67 74.68,211.65 v1(74.66,211.63) 74.55,211.52 74.55,210.65 PR5802.1 75.15,209.3 PR5880.1
  BOTTOM w0.102: v2(75.26,210.72) 75.26,211.03 v1(74.66,211.63)
VRM_ISEN2N_A: length 22.5
  TOP w0.254: PC5803.2 75.86,210.96 75.93,211.04 PR5803.2 76.38,210.45 PR5802.2 75.98,209.49 76.07,209.4 PC5804.1 75.74,208.91 75.56,208.74 75.56,206.93 76.2,206.3 76.2,204.22 74.42,202.44 73.15,202.44 72.03,201.32 72.03,196.52 v1(72.21,196.34)
  BOTTOM w0.254: v1(72.21,196.34) 72.44,196.34 72.73,196.63 PJP594.2 72.73,197.9 v2(71.75,198.88)
VRM_ISEN2P_A: length 17.7
  TOP w0.254: PR5880.2 74.93,206.88 75.82,205.99 75.82,204.4 74.24,202.82 72.69,202.82 71.48,201.6 v1(71.48,196.34)
  BOTTOM w0.254: v2(72.07,193.87) 71.51,194.42 PJP593.2 71.51,196.3 v1(71.48,196.34)
VRM_ISEN3_N_A: length 5.6
  TOP w0.203: PU581.3 76.64,215.09 76.31,214.77
  TOP w0.254: 76.31,214.77 75.84,214.3 v1(75.26,214.3) 74.45,214.3 73.91,213.77 PR5805.1
  BOTTOM w0.102: v2(75.79,215.21) 75.26,214.68 v1(75.26,214.3)
VRM_ISEN3_P_A: length 8.2
  TOP w0.203: PU581.2 76.24,215.38 75.72,214.86
  TOP w0.254: PR5881.1 PR5804.1 71.67,215.6 72.88,215.6 PC5805.1 74.27,214.83 v1(74.37,214.93) 74.45,214.86 75.72,214.86
  BOTTOM w0.102: v2(73.56,214.17) 73.61,214.17 v1(74.37,214.93)
VRM_ISEN3N_A: length 65.9
  TOP w0.254: PR5805.2 72.63,214.51 PC5805.2 71.81,214.34 PR5804.2 71.25,213.66 PC5806.1 71.07,212.9 71.5,212.47 v1(71.83,212.47)
  BOTTOM w0.254: v1(71.83,212.47) 72.44,212.47 75.59,209.32 75.59,207.31 81.76,201.14 81.76,185.52 78.61,182.37 78.61,179.32 76.86,177.57 v2(76.86,169.29) 76.86,165.96 73.89,162.99 72.09,162.99 71.79,162.7 71.79,162.22 72.09,161.93 PJP10.2
VRM_ISEN3P_A: length 65.5
  TOP w0.254: v1(71.83,211.71) 70.66,211.71 69.77,212.6 69.77,213.78 PR5881.2
  BOTTOM w0.254: PJP9.2 71.26,162.92 71.86,163.53 73.66,163.53 76.28,166.14 v2(76.28,167.13) 76.28,177.75 78.04,179.51 78.04,182.59 81.22,185.78 81.22,201.05 74.65,207.62 74.65,209.4 72.34,211.71 v1(71.83,211.71)
VRM_ISEN4_N_A: length 5.4
  TOP w0.203: PU581.8 78.64,215.14
  TOP w0.254: PR5815.1 77.29,212.86 PR5878.1 78.39,213.96 v1(78.39,213.97) 78.64,214.22 78.64,215.14
  BOTTOM w0.102: v1(78.39,213.97) v2(78.39,213.13)
VRM_ISEN4_P_A: length 10
  TOP w0.203: PU581.9 79.04,215.14
  TOP w0.254: PR5806.1 PR5882.1 78.18,209.36 78.14,209.4 PR5814.1 78.71,209.98 v1(78.83,210.1) 79.04,210.31 79.04,211.67 PC5811.1 78.36,213.09 PR5878.2 79.04,213.77 79.04,215.14
  BOTTOM w0.102: v2(78.44,210.82) 78.83,210.43 v1(78.83,210.1)
