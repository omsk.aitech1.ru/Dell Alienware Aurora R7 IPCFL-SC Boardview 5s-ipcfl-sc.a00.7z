# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_DQ49: length 75.7
  TOP w0.102: 183.11,118.7 183.91,118.7 184.98,118.32 185.5,118.17 186.92,118.05 CON_XMM1.271 ; 183.11,118.7 183.11,118.41 182.66,117.97 182.66,117.54 182.55,117.42 182.13,117.42 181.71,117.85 180.86,117.85 180.66,118.05 CON_XMM3.271 ; 183.11,118.7 182.4,118.7 181.95,118.24 181.02,118.24 180.81,118.45 180.3,118.45 180.05,118.69 179.46,118.69 179.28,118.52 ; 135.31,140.59 135.07,140.82 135.07,142.06 134.98,142.15 134.98,144.74 XU1.AM4
  TOP w0.159: 179.28,118.52 177.81,117.88 177.13,117.88 176.29,118.72 174.5,118.72 174.35,118.87 173.43,118.87 173.28,118.72 170.65,118.72 168.01,116.08 157.29,116.08 136.25,137.13 136.25,139.65 135.31,140.59
M_CHA_DQ50: length 74.5
  TOP w0.102: XU1.AP3 137.91,143.79 137.91,141.53 138.23,141.21 139.04,141.21 139.18,141.06 ; 179.48,125.9 179.12,126.26 179.12,126.47 179.04,126.56 178.9,126.56 178.82,126.47 178.82,126.29 178.73,126.2 178.6,126.2 178.5,126.29 178.5,126.47 178.43,126.55 CON_XMM3.117 ; 179.48,125.9 179.92,125.9 181.01,126.35 183.18,126.35 CON_XMM1.117 ; 179.48,125.9 179.07,125.76 178.44,125.76 177.86,126.34 177.25,126.34 177.09,126.18
  TOP w0.159: 139.18,141.06 140.06,140.19 140.85,140.19 153.79,127.24 155.41,127.24 155.58,127.07 155.58,125.45 155.74,125.29 156.34,125.29 156.5,125.45 156.5,127.11 156.63,127.24 157.23,127.24 157.42,127.06 157.42,125.45 157.58,125.29 158.18,125.29 158.34,125.45 158.34,127.11 158.47,127.24 159.03,127.24 159.26,127.02 159.26,125.68 159.46,125.48 159.85,125.48 160.22,125.85 160.22,127.08 160.39,127.24 160.69,127.24 160.97,126.97 161.37,126.97 161.65,127.24 162.17,127.24 162.31,127.1 163.03,127.1 163.17,127.24 166.05,127.24 166.22,127.08 166.22,126.19 166.37,126.04 166.83,126.04 166.94,126.15 166.94,126.38 167.03,126.46 167.46,126.46 167.62,126.3 167.62,126.12 167.78,125.96 168.38,125.96 168.54,126.12 168.54,126.3 168.7,126.46 169.3,126.46 169.46,126.3 169.46,126.12 169.62,125.96 170.22,125.96 170.38,126.12 170.38,126.3 170.54,126.46 171.14,126.46 171.3,126.3 171.3,126.12 171.46,125.96 172.06,125.96 172.22,126.12 172.22,126.3 172.38,126.46 172.95,126.46 173.1,126.31 173.1,126.09 173.23,125.96 173.71,125.96 173.84,126.09 173.84,126.26 174.04,126.46 174.59,126.46 174.74,126.32 174.74,126 174.87,125.87 176.37,125.87 176.52,126.03 176.93,126.03 177.09,126.18
M_CHA_DQ51: length 75.2
  TOP w0.102: 180.92,119.51 180.46,119.51 180.05,119.1 179.39,119.1 179.11,119.38 179.11,119.64 179.02,119.73 178.89,119.73 178.8,119.64 178.8,119.23 178.7,119.13 178.39,119.13 178.35,119.17 178.09,119.17 CON_XMM3.126 ; 180.92,119.51 181.09,119.51 181.13,119.54 181.65,119.54 183.45,119.1 184.59,119 184.85,118.98 CON_XMM1.126 ; 180.92,119.51 180.92,119.39 180.78,119.25 180.78,119.2 180.69,118.98 180.58,118.9 179.09,118.9 178.96,118.77 ; 135.42,140.96 135.27,141.1 135.27,142.21 135.18,142.31 135.18,142.72 135.31,142.84 135.31,143.13 135.18,143.25 135.18,144.03 XU1.AM3
  TOP w0.159: 178.96,118.77 178.46,118.77 177.91,118.22 177.3,118.22 176.45,119.07 175.34,119.07 174.31,120.1 173.73,120.1 173.25,120.59 172.89,120.59 172.75,120.45 172.75,119.52 172.59,119.35 172.19,119.35 172.01,119.53 172.01,120.25 171.76,120.5 171.46,120.5 171.25,120.29 171.25,119.58 171.02,119.35 170.39,119.35 167.75,116.71 157.56,116.71 136.88,137.39 136.88,138.57 136.73,138.72 136.73,139.65 135.42,140.96
M_CHA_DQ52: length 75.2
  TOP w0.102: CON_XMM1.264 186.83,124 186.56,123.72 186.56,123.57 186.33,123.34 185.07,123.34 ; CON_XMM3.264 182.01,124 182.37,124.36 182.55,124.36 182.91,124 183.11,124 183.3,124.2 184.22,124.2 185.07,123.34 ; 138.44,140.07 137.18,141.33 137.18,142.13 137.01,142.3 137.01,144.19 136.97,144.23 136.97,144.9 XU1.AP4 ; 185.07,123.34 184.94,123.2 184.64,123.2 184.04,123.8 183.42,123.8 183.3,123.68
  TOP w0.159: 183.3,123.68 183.14,123.52 181.9,123.52 181.71,123.32 181.1,123.32 180.92,123.5 180.74,123.5 180.41,123.83 179.48,123.83 179.17,123.52 178.54,123.52 178.33,123.32 176.99,123.32 176.47,123.83 175.37,123.83 175.29,123.75 175.29,123.37 175.11,123.19 174.79,123.19 174.61,123.37 174.61,123.55 174.48,123.67 167.77,123.67 167.44,123.34 167.44,122.58 164.42,119.56 161.49,119.56 161.37,119.68 160.68,119.68 160.56,119.56 158.76,119.56 158.53,119.79 158.53,119.97 158.88,120.32 158.88,120.48 158.75,120.61 157.74,120.61 140.08,138.26 140.08,138.53 138.63,139.98 138.53,139.98 138.44,140.07
M_CHA_DQ53: length 73.8
  TOP w0.102: CON_XMM1.124 184.75,120.6 183.92,120.78 183.61,120.78 182.92,120.87 181.58,121.25 180.95,121.25 ; 135.86,141.38 135.86,142.73 135.51,143.08 XU1.AM2 ; 178.53,120.5 178.62,120.6 180.47,120.6 180.8,120.93 180.8,120.98 180.95,121.13 180.95,121.25 ; 180.95,121.25 180.51,121.25 180.06,120.8 179.48,120.8 179.12,121.16 179.12,121.42 179.03,121.51 178.84,121.51 178.66,121.34 178.66,121.14 178.12,120.6 CON_XMM3.124
  TOP w0.159: 135.86,141.38 138.15,139.09 138.15,137.92 158.1,117.97 166.96,117.97 168.05,119.05 168.05,119.61 167.64,120.02 167.64,120.58 167.83,120.77 168.13,120.77 168.88,120.02 169.22,120.02 169.44,120.23 169.44,120.51 168.63,121.31 168.63,121.57 168.99,121.93 173.72,121.93 174.24,121.41 174.88,121.41 175.52,120.77 176.45,120.77 177.3,119.92 177.95,119.92 178.53,120.5
M_CHA_DQ54: length 72.5
  TOP w0.102: 177.08,124.48 177.23,124.64 177.95,124.64 178.53,124.06 179.07,124.06 179.48,124.2 ; 179.48,124.2 179.91,124.2 181.11,124.65 183.13,124.65 CON_XMM1.119 ; 179.48,124.2 179.12,124.56 179.12,124.77 179.04,124.85 178.93,124.85 178.85,124.77 178.85,124.6 178.75,124.5 178.62,124.5 178.53,124.6 178.53,124.76 178.45,124.85 CON_XMM3.119 ; XU1.AP1 137.4,142.47 137.4,141.45 138.38,140.46
  TOP w0.159: 177.08,124.48 176.92,124.33 176.52,124.33 176.37,124.17 175.6,124.17 175.26,124.51 174.4,124.51 174.22,124.33 173.91,124.33 173.54,124.71 173.21,124.71 173.07,124.57 173.07,124.39 172.99,124.3 172.57,124.3 172.42,124.45 172.42,124.59 172.29,124.71 171.87,124.71 171.75,124.6 171.75,124.43 171.63,124.3 171.18,124.3 171.04,124.43 171.04,124.58 170.92,124.71 170.45,124.71 170.33,124.59 170.33,124.43 170.21,124.31 170.21,124.3 169.67,124.3 169.54,124.43 169.54,124.58 169.42,124.71 168.99,124.71 168.85,124.57 168.85,124.4 168.75,124.3 168.15,124.3 167.84,124.61 167.41,124.61 167.18,124.38 167.18,123.98 167.06,123.85 166.42,123.85 166.24,123.67 166.24,123.34 166.37,123.22 166.69,123.22 166.8,123.1 166.8,122.83 164.16,120.19 161.75,120.19 161.29,120.65 160.76,120.65 160.3,120.19 159.94,120.19 159.79,120.35 159.79,121.11 159.66,121.23 158,121.23 157.71,121.52 157.71,121.89 157.84,122.02 159.56,122.02 159.79,122.25 159.79,122.63 159.55,122.87 156.37,122.87 138.78,140.46 138.38,140.46
M_CHA_DQ55: length 72.9
  TOP w0.102: 183.46,120.42 183.48,120.4 184.24,120.4 184.89,119.74 CON_XMM1.269 ; 183.46,120.42 183.36,120.51 182.23,120.51 181.66,119.95 181.11,119.95 180.84,120.21 180.25,120.21 180.07,120.39 179.45,120.39 179.3,120.24 ; 183.46,120.42 183.04,120 183.04,119.84 182.94,119.74 182.7,119.74 182.42,120.02 182.21,120.02 182.06,119.87 181.71,119.74 180.94,119.74 180.82,119.86 180.51,119.86 180.39,119.74 CON_XMM3.269 ; XU1.AM1 135.51,141.24 135.58,141.17
  TOP w0.159: 179.3,120.24 179.15,120.08 178.7,120.08 178.19,119.58 177.12,119.58 176.27,120.43 175.11,120.43 174.77,120.77 173.98,120.77 173.45,121.3 170.11,121.3 169.96,121.15 169.96,120.86 170.23,120.6 170.23,120.08 167.49,117.34 157.83,117.34 137.52,137.66 137.52,139.24 135.58,141.17
M_CHA_DQ56: length 84.6
  TOP w0.102: 180.94,116.7 181.09,116.55 181.51,116.55 183.19,116.99 183.95,117.1 CON_XMM1.128 ; 180.94,116.7 180.82,116.59 180.5,116.59 180.08,117 179.44,117 179.31,116.87 ; 180.94,116.7 180.71,116.93 180.71,117.44 180.61,117.54 180.22,117.54 180.08,117.4 179.18,117.4 178.75,116.97 178.48,116.97 178.33,117.12 178.33,117.27 178.22,117.38 178.09,117.38 CON_XMM3.128 ; XU1.AK3 134.24,143.8 134.24,142.21 134.14,142.11 134.14,141.28 134.43,140.99
  TOP w0.159: 134.43,140.99 135.59,139.83 135.59,136.89 157.02,115.45 169.29,115.45 169.42,115.58 169.42,116.6 169.74,116.92 170,116.92 170.13,116.8 170.13,115.59 170.27,115.45 170.68,115.45 170.81,115.59 170.81,117.83 171.08,118.09 171.47,118.09 171.65,117.91 171.65,115.61 171.81,115.45 172.12,115.45 172.36,115.7 172.36,117.89 172.57,118.09 173.02,118.09 173.2,117.91 173.2,117.03 173.38,116.86 173.68,116.86 173.83,117.01 173.83,117.97 173.96,118.09 174.96,118.09 175.69,117.37 176.45,117.37 177.3,116.52 177.87,116.52 177.97,116.63 179.06,116.63 179.31,116.87
M_CHA_DQ57: length 84.3
  TOP w0.102: 185.19,109.74 186.35,109.74 186.51,109.91 186.51,110.24 186.67,110.4 CON_XMM1.280 ; 185.19,109.74 185.07,109.74 184.25,110.57 183.21,110.57 182.96,110.82 182.52,110.82 182.1,110.4 CON_XMM3.280 ; 185.19,109.74 185.19,109.58 185.09,109.47 184.76,109.47 184.05,110.19 183.35,110.19 183.3,110.14 ; 178.33,110.07 178.19,110.07 177.87,109.75 177.25,109.75 177.11,109.88 ; XU1.AH1 131.86,142.32 131.72,142.18 131.72,141.8 131.48,141.57
  TOP w0.159: 177.11,109.88 176.9,110.09 176.39,110.09 176.25,110.23 175.58,110.23 175.33,109.98 174.47,109.98 174.3,109.81 169.17,109.81 168.96,109.6 168.69,109.6 168.48,109.81 167.35,109.81 167.13,109.6 166.85,109.6 166.63,109.81 165.53,109.81 165.34,110.01 165.01,110.01 164.82,109.81 163.64,109.81 163.47,109.99 163.12,109.99 162.95,109.81 161.8,109.81 161.58,110.03 161.3,110.03 161.08,109.81 159.93,109.81 159.73,110.02 159.46,110.02 159.25,109.81 158.13,109.81 157.79,110.16 157.45,110.16 157.11,109.81 156.81,109.81 155.75,110.87 155.75,111.2 155.6,111.36 155.27,111.36 131.29,135.34 131.29,139.31 131.6,139.62 131.6,139.85 131.12,140.33 131.12,141.2 131.48,141.57 ; 178.33,110.07 179.08,110.07 179.25,110.23 180.44,110.23 180.59,110.08 180.59,109.86 180.77,109.68 182.07,109.68 182.3,109.91 183.07,109.91 183.3,110.14
M_CHA_DQ58: length 85.4
  TOP w0.102: 183.4,113.98 184.24,113.98 184.9,114.65 CON_XMM1.275 ; 183.4,113.98 183.08,114.29 183.08,114.48 183.01,114.55 182.83,114.55 182.73,114.45 182.73,114.27 182.6,114.15 182.42,114.15 181.93,114.65 CON_XMM3.275 ; 183.4,113.98 182.98,113.84 182.4,113.84 181.8,114.44 181.06,114.44 180.9,114.29 ; XU1.AK4 133.68,145.66 133.36,145.99 133.19,145.99 133.02,145.82 133.02,145.62 133.2,145.44 133.2,144.68 133.32,144.56 133.32,141.33 133.35,141.3 133.35,140.39
  TOP w0.159: 180.9,114.29 180.77,114.16 180.3,114.16 180.11,113.97 179.42,113.97 179.16,114.24 178.19,114.24 177.95,114.48 176.92,114.48 176.76,114.33 176.76,113.94 176.63,113.82 175.54,113.82 175.42,113.7 175.42,113.33 175.1,113 174.8,113 174.29,113.51 173.89,113.51 173.65,113.28 173.65,112.91 173.76,112.8 174.01,112.8 174.14,112.67 174.14,112.43 173.75,112.04 167.1,112.04 166.86,112.28 166.86,112.76 166.06,113.57 164.91,113.57 164.47,113.13 164.04,113.13 163.61,113.57 162.13,113.57 162,113.44 162,113.1 161.78,112.88 161.6,112.88 161.29,113.19 161.29,113.41 161.13,113.57 156.22,113.57 133.6,136.18 133.6,139.29 133.28,139.62 133.28,139.8 133.51,140.04 133.51,140.22 133.35,140.39
M_CHA_DQ59: length 85.4
  TOP w0.102: CON_XMM1.135 182.78,111.25 181.71,111.06 181.03,111.06 179.91,110.58 179.5,110.58 ; XU1.AH2 132.08,143.44 132.21,143.32 132.21,142.35 132,142.14 132,141.46 ; 178.7,110.58 179.5,110.58 ; 179.5,110.58 178.96,111.12 178.96,111.27 178.88,111.35 178.76,111.35 178.68,111.27 178.68,111.17 178.59,111.08 178.46,111.08 178.37,111.17 178.37,111.33 178.25,111.45 176.55,111.45 CON_XMM3.135
  TOP w0.159: 178.7,110.58 178.39,110.58 177.89,111.07 176.93,111.07 176.78,110.92 176.78,110.72 176.64,110.57 175.38,110.57 175.18,110.77 175.18,111.07 175.06,111.2 174.8,111.2 174.63,111.04 174.63,110.56 174.52,110.44 165.8,110.44 165.64,110.6 165.64,110.8 165.44,111 164.84,111 164.72,110.87 164.72,110.6 164.56,110.44 163.93,110.44 163.77,110.6 163.77,110.8 163.35,111.23 162.99,111.23 162.85,111.08 162.85,110.6 162.69,110.44 162.06,110.44 161.9,110.6 161.9,110.83 161.74,110.99 161.14,110.99 160.98,110.83 160.98,110.6 160.82,110.44 160.19,110.44 160.05,110.59 160.05,111.86 159.92,111.98 159.31,111.98 159.15,111.83 159.15,110.6 158.99,110.44 158.39,110.44 158.23,110.6 158.23,111.83 158.07,111.98 157.45,111.98 157.3,111.83 157.3,110.87 157.12,110.69 156.82,110.69 156.59,110.92 156.59,111.86 156.46,111.98 155.58,111.98 131.93,135.63 131.93,139.17 132.23,139.47 132.23,140.28 132.05,140.46 131.72,140.46 131.58,140.61 131.58,140.86 132,141.29 132,141.46
M_CHA_DQ60: length 87.4
  TOP w0.102: XU1.AH4 131.28,144.7 131.28,142.23 130.12,141.07 ; CON_XMM3.282 181.96,108.7 182.53,108.13 182.73,108.13 183.24,108.64 184.48,108.64 185.04,108.08 185.04,108.03 186.21,108.03 186.88,108.7 CON_XMM1.282
  TOP w0.159: 185.04,108.03 184.1,107.09 183.61,107.09 182.18,107.57 180.82,108.02 180.33,108.52 179.31,108.52 178.46,107.67 177.12,107.67 176.97,107.57 176.26,107.09 175.73,107.09 172.2,108.05 157.48,108.05 156.18,108.65 130.02,134.81 130.02,140.97 130.12,141.07
M_CHA_DQ61: length 83.8
  TOP w0.102: 183.4,115.68 183.08,115.99 183.08,116.22 182.97,116.33 182.75,116.33 182.68,116.26 182.68,116.08 182.58,115.98 182.45,115.98 182.08,116.35 CON_XMM3.273 ; 183.4,115.68 183.2,115.59 182.35,115.59 181.8,116.14 181.08,116.14 180.87,115.92 180.27,115.92 180.05,115.7 179.48,115.7 179.22,115.96 ; 183.4,115.68 184.33,115.68 185,116.35 CON_XMM1.273 ; 133.96,140.87 133.82,141.01 133.82,142.12 134.03,142.33 134.03,143.1 XU1.AK2
  TOP w0.159: 179.22,115.96 179.07,116.11 177.98,116.11 177.91,116.18 177.13,116.18 176.29,117.02 175.39,117.02 174.84,117.58 174.37,117.58 174.29,117.5 174.29,115.04 174.08,114.83 173.79,114.83 173.66,114.95 173.66,116.03 173.46,116.23 173.16,116.23 173.03,116.1 173.03,115.04 172.81,114.83 170.47,114.83 170.31,114.67 170.31,113.82 170.15,113.66 169.55,113.66 169.39,113.82 169.39,114.67 169.23,114.83 168.6,114.83 168.44,114.67 168.44,113.89 168.28,113.73 167.68,113.73 167.52,113.89 167.52,114.67 167.36,114.83 156.75,114.83 134.93,136.65 134.93,139.9 133.96,140.87
M_CHA_DQ62: length 87.1
  TOP w0.102: 130.65,141.04 130.65,141.22 131.5,142.07 131.5,144.23 131.63,144.36 XU1.AH3 ; CON_XMM1.137 183.14,109.35 181.1,109.35 179.92,108.88 179.5,108.88 ; 179.5,108.88 179.23,108.79 178.82,108.79 ; 179.5,108.88 179.11,109.27 179.11,109.48 178.99,109.6 178.77,109.6 178.67,109.5 178.67,109.3 178.58,109.2 178.32,109.2 178.16,109.37 176.83,109.37 176.66,109.55 CON_XMM3.137
  TOP w0.159: 178.82,108.79 178.05,108.02 177.07,108.02 176.3,108.79 175.69,108.79 175.18,108.28 174.98,108.28 174.85,108.41 174.85,109.12 174.73,109.25 174.37,109.25 174.24,109.12 174.24,108.46 174.1,108.31 173.75,108.31 173.59,108.47 173.59,109.03 173.44,109.19 173.01,109.19 172.85,109.02 172.85,108.81 172.71,108.68 172.19,108.68 172.06,108.81 172.06,109.03 171.9,109.19 171.3,109.19 171.14,109.03 171.14,108.84 170.98,108.68 170.37,108.68 170.22,108.84 170.22,109.03 170.06,109.19 169.45,109.19 169.3,109.03 169.3,108.82 169.15,108.68 168.55,108.68 168.37,108.86 168.37,109.03 168.22,109.19 167.61,109.19 167.45,109.03 167.45,108.84 167.29,108.68 166.69,108.68 166.53,108.84 166.53,109.03 166.37,109.19 165.77,109.19 165.61,109.03 165.61,108.81 165.49,108.68 164.8,108.68 164.69,108.79 164.69,109.07 164.58,109.19 163.9,109.19 163.77,109.06 163.77,108.81 163.64,108.68 162.97,108.68 162.85,108.8 162.85,109.03 162.7,109.19 162.07,109.19 161.93,109.05 161.93,108.92 161.75,108.74 161.16,108.74 161.01,108.89 161.01,109.04 160.87,109.19 160.21,109.19 160.09,109.06 160.09,108.86 159.92,108.69 159.33,108.69 159.17,108.85 159.17,109.06 159.04,109.19 158.36,109.19 158.22,109.04 158.22,108.89 158.01,108.69 157.61,108.69 157.33,108.97 157.33,109.1 157.23,109.19 156.54,109.19 130.65,135.07 130.65,141.04
M_CHA_DQ63: length 83.5
  TOP w0.102: 180.97,114.98 181.11,114.85 181.51,114.85 183.52,115.3 184.7,115.44 CON_XMM1.130 ; 180.97,114.98 180.87,114.88 180.5,114.88 180.08,115.3 179.46,115.3 179.32,115.16 ; 180.97,114.98 180.71,115.25 180.71,115.51 180.62,115.6 180.42,115.6 180.32,115.5 179.03,115.5 178.74,115.21 178.5,115.21 178.41,115.3 178.41,115.69 178.32,115.79 178.11,115.79 CON_XMM3.130 ; 133.64,140.72 133.55,140.81 133.55,141.39 133.55,141.39 133.55,142.39 XU1.AK1
  TOP w0.159: 179.32,115.16 178.98,114.82 177.3,114.82 176.78,115.34 175.39,115.34 175.19,115.54 175.19,116.64 175.04,116.79 174.83,116.79 174.68,116.64 174.68,114.78 175.11,114.35 175.11,114.05 174.9,113.84 174.6,113.84 174.24,114.2 172.63,114.2 172.5,114.07 172.5,113.58 172.64,113.44 172.9,113.44 173.02,113.31 173.02,112.85 172.84,112.67 171.88,112.67 171.73,112.82 171.73,114.02 171.55,114.2 171.15,114.2 171.02,114.07 171.02,112.8 170.89,112.67 169.37,112.67 169.19,112.85 169.19,113.11 169.06,113.24 168.68,113.24 168.55,113.12 168.55,112.83 168.4,112.67 167.97,112.67 167.82,112.82 167.82,112.97 167.7,113.1 167.42,113.1 166.89,113.63 166.89,114.07 166.76,114.2 156.49,114.2 134.23,136.45 134.23,140.13 133.64,140.72
M_CHA_DQS0: length 94.9
  TOP w0.102: XU1.AF38 130.73,178.56 130.6,178.69 130.6,178.95 130.75,179.09 131.15,179.09 131.27,179.22 131.27,181.3 130.83,181.74 130.46,181.74
  TOP w0.171: CON_XMM1.153 186.99,223.45 186.83,223.28 184.96,223.28 184.1,224.14 183.35,224.14 182.95,223.73 181.82,223.73 181.7,223.61 181.06,223.61 180.78,223.9 180.23,223.9 CON_XMM3.153 179.33,223.9 178.63,223.9 178.03,223.3 177.16,223.3 176.31,224.15 175.69,224.15 174.11,222.57 170.82,222.57 168.36,220.11 167.28,220.11 165.98,218.81 163.54,218.81 163,219.36 160.15,219.36 159.97,219.17 159.97,218.31 159.64,217.98 158.83,217.98 158.5,218.31 158.5,219.3 158.31,219.49 157.76,219.49 157.58,219.31 157.58,218.34 157.22,217.98 156.39,217.98 155.91,218.46 154.81,218.46 150.82,214.47 149.11,214.47 128.01,193.38 128.01,184.18 130.46,181.74
M_CHA_DQS0#: length 94.9
  TOP w0.102: 130.3,181.47 130.3,181.04 130.6,180.75 130.6,180.17 130.94,179.83 XU1.AF39
  TOP w0.171: 130.3,181.47 130.3,181.49 127.73,184.07 127.73,193.49 148.99,214.76 150.7,214.76 154.69,218.74 156.03,218.74 156.51,218.27 157.1,218.27 157.3,218.46 157.3,219.43 157.64,219.77 158.43,219.77 158.78,219.42 158.78,218.43 158.94,218.27 159.52,218.27 159.68,218.43 159.68,219.29 160.03,219.64 163.12,219.64 163.66,219.1 165.86,219.1 167.16,220.4 168.24,220.4 170.71,222.86 173.99,222.86 175.57,224.43 176.43,224.43 177.27,223.59 177.91,223.59 178.51,224.18 181.26,224.18 CON_XMM3.152 181.66,224.02 182.83,224.02 183.23,224.42 184.22,224.42 185.08,223.57 186.71,223.57 187.27,224.13 188.98,224.13 CON_XMM1.152
M_CHA_DQS1: length 79.9
  TOP w0.102: XU1.AK38 134.94,178.9 134.94,180.8 135.02,180.88 135.02,181.28 134.91,181.39
  TOP w0.171: CON_XMM1.164 188.98,214.26 187.27,214.26 186.87,214.66 185.82,214.66 185.68,214.8 185.08,214.8 184.22,213.94 183.23,213.94 183.08,214.1 CON_XMM3.164 178.75,214.1 178.06,214.78 177.24,214.78 176.39,213.93 175.16,213.93 174.81,213.58 174.12,213.58 173.78,213.93 173.15,213.93 172.43,213.22 171.59,213.22 171.28,213.53 171.28,213.8 171.16,213.93 170.6,213.93 166.3,209.63 158.05,209.63 157.24,208.82 154.36,208.82 153.03,207.49 150.74,207.49 134.05,190.8 134.05,182.61 134.52,182.13 134.52,181.77 134.91,181.39
M_CHA_DQS1#: length 79.9
  TOP w0.102: 134.24,181.34 134.18,181.28 134.18,180.87 134.24,180.81 134.24,179.58 134.01,179.35 134.01,179.07 134.15,178.93 134.68,178.93 134.74,178.99 134.74,179.34 XU1.AK39
  TOP w0.171: 134.24,181.34 134.24,182.01 133.76,182.49 133.76,190.92 150.62,207.78 152.92,207.78 154.24,209.11 157.12,209.11 157.93,209.91 166.19,209.91 170.49,214.21 171.28,214.21 171.57,213.92 171.57,213.64 171.71,213.5 172.32,213.5 173.03,214.21 173.9,214.21 174.24,213.87 174.69,213.87 175.04,214.21 176.27,214.21 177.12,215.07 178.18,215.07 178.87,214.38 179.65,214.38 179.78,214.51 CON_XMM3.163 180.58,214.95 180.75,214.78 181.67,214.78 182.06,214.38 183.2,214.38 183.35,214.23 184.1,214.23 184.96,215.09 185.8,215.09 185.94,214.95 CON_XMM1.163
M_CHA_DQS2: length 71.4
  TOP w0.102: XU1.AP38 138.05,178.56 137.95,178.66 137.95,178.84 138.05,178.94 138.42,178.94 138.6,179.13 138.6,180.48 138.6,180.78 138.69,180.87 138.79,180.87 138.9,180.98 138.9,181.27 138.76,181.41 138.51,181.41 138.38,181.54
  TOP w0.171: 138.38,181.54 138.38,181.82 140.24,183.69 140.24,188.49 143.21,191.45 143.5,191.45 144.38,190.57 145.33,190.57 145.77,191.01 145.77,191.72 144.8,192.69 144.8,193.04 150.64,198.88 158.83,198.88 161.44,201.49 164.54,201.49 166.56,203.52 168.65,203.52 169.71,204.58 174.73,204.58 175.61,205.45 176.25,205.45 177.1,204.6 178.02,204.6 178.62,205.21 179.32,205.21 CON_XMM3.175 180.24,205.21 180.77,205.21 181.07,204.91 181.64,204.91 181.76,205.03 182.93,205.03 183.35,205.45 184.1,205.45 184.97,204.58 186.7,204.58 186.87,204.75 CON_XMM1.175
M_CHA_DQS2#: length 71.3
  TOP w0.102: XU1.AP39 138.26,179.86 137.91,180.21 137.91,180.84 137.86,180.89 137.86,181.26 138.08,181.49
  TOP w0.171: CON_XMM1.174 188.99,205.44 187.16,205.44 186.58,204.86 185.09,204.86 184.22,205.73 183.23,205.73 182.82,205.32 181.66,205.32 CON_XMM3.174 181.27,205.49 178.51,205.49 177.9,204.89 177.22,204.89 176.37,205.74 175.49,205.74 174.61,204.86 169.59,204.86 168.53,203.8 166.45,203.8 164.42,201.77 161.32,201.77 158.71,199.16 150.52,199.16 144.51,193.16 144.51,192.57 145.48,191.6 145.48,191.13 145.21,190.86 144.5,190.86 143.62,191.74 143.09,191.74 139.96,188.6 139.96,183.81 138.09,181.94 138.09,181.5 138.08,181.49
M_CHA_DQS3: length 63.7
  TOP w0.102: XU1.AV36 142.31,176.73 142.66,176.39 143.62,176.39 143.93,176.69
  TOP w0.171: 143.93,176.69 144.12,176.88 144.12,177.11 145.47,178.45 145.47,179.63 145.66,179.82 147.03,179.82 147.26,179.58 147.26,178.34 147.62,177.98 148.45,177.98 148.85,178.37 148.85,179.78 149.04,179.98 149.8,179.98 149.97,179.81 149.97,178.34 150.31,178 151.11,178 151.48,178.37 151.48,179.6 151.7,179.82 153.12,179.82 162.65,189.36 167.18,189.36 173.09,195.27 176.4,195.27 177.21,196.08 177.93,196.08 178.79,195.23 180.32,195.23 CON_XMM3.186 183.06,195.4 183.18,195.28 184.23,195.28 185.06,196.11 185.7,196.11 185.85,195.96 186.84,195.96 187.4,195.4 CON_XMM1.186
M_CHA_DQS3#: length 63.7
  TOP w0.102: 143.18,177.21 143.04,177.07 142.63,177.07 142.51,176.95 142.23,176.95 142.1,177.07 141.53,177.07 141.48,177.02 141.48,176.61 141.43,176.55 141.18,176.55 XU1.AU36
  TOP w0.171: CON_XMM1.185 185.97,196.25 185.82,196.39 184.94,196.39 184.11,195.56 183.3,195.56 183.18,195.68 182.09,195.68 181.69,196.09 180.92,196.09 180.76,196.25 CON_XMM3.185 179.78,195.91 179.39,195.52 178.9,195.52 178.05,196.37 177.09,196.37 176.28,195.55 172.97,195.55 167.06,189.64 162.53,189.64 153,180.11 151.58,180.11 151.19,179.72 151.19,178.49 150.99,178.29 150.43,178.29 150.26,178.46 150.26,179.92 149.92,180.27 148.93,180.27 148.56,179.9 148.56,178.49 148.34,178.26 147.74,178.26 147.55,178.46 147.55,179.7 147.15,180.11 145.54,180.11 145.18,179.75 145.18,178.57 143.92,177.31 143.28,177.31 143.18,177.21
M_CHA_DQS4: length 56.1
  TOP w0.102: 143.25,147.55 143.14,147.66 141.75,147.66 141.53,147.88 141.53,148.19 141.38,148.35 141.14,148.35 141,148.21 XU1.AV7
  TOP w0.171: CON_XMM1.245 186.86,140.15 186.71,139.99 184.96,139.99 184.1,140.85 183.35,140.85 182.99,140.49 181.84,140.49 181.66,140.31 181.1,140.31 180.87,140.54 180.18,140.54 CON_XMM3.245 179.12,140.8 178.85,140.8 178.06,140.01 177.12,140.01 176.27,140.86 174.16,140.86 170.49,137.19 160.05,137.19 159.91,137.05 159.91,136.82 159.54,136.45 158.71,136.45 158.34,136.82 158.34,136.99 158.15,137.19 157.63,137.19 150.5,144.31 148.15,144.31 144.55,147.9 144.07,147.9 143.71,147.55 143.25,147.55
M_CHA_DQS4#: length 56.1
  TOP w0.102: 143.18,148.36 142.26,148.36 XU1.AW7
  TOP w0.171: CON_XMM1.244 188.98,140.83 187.14,140.83 186.59,140.28 185.08,140.28 184.22,141.13 183.23,141.13 182.88,140.78 181.6,140.78 CON_XMM3.244 181.21,140.83 179.5,140.83 179.24,141.09 178.73,141.09 177.94,140.3 177.24,140.3 176.39,141.15 174.04,141.15 170.37,137.48 159.93,137.48 159.62,137.16 159.62,136.94 159.42,136.73 158.83,136.73 158.63,136.94 158.63,137.11 158.27,137.47 157.74,137.47 150.62,144.59 148.27,144.59 144.67,148.19 144.16,148.19 143.88,148.48 143.3,148.48 143.18,148.36
M_CHA_DQS5: length 58.8
  TOP w0.171: XU1.AU2 140.34,143.44 140.81,142.98 141.21,142.98 141.47,142.72 141.47,141.97 141.82,141.62 142.37,141.62 142.71,141.97 142.71,142.47 142.9,142.67 143.26,142.67 143.45,142.47 143.45,142.05 143.8,141.69 144.11,141.69 147.71,138.09 148.2,138.09 148.7,137.59 148.7,137.1 149.26,136.54 149.75,136.54 150.06,136.23 150.06,135.74 150.81,134.99 151.3,134.99 151.63,134.66 151.63,134.17 155.41,130.39 173.59,130.39 173.84,130.65 176.4,130.65 177.25,131.5 178.06,131.5 178.92,130.64 179.71,130.64 179.87,130.8 CON_XMM3.256 183.09,130.8 183.23,130.65 184.22,130.65 185.08,131.51 185.67,131.51 185.82,131.36 186.87,131.36 187.43,130.8 CON_XMM1.256
M_CHA_DQS5#: length 58.8
  TOP w0.171: CON_XMM1.255 185.94,131.65 185.79,131.8 184.96,131.8 184.1,130.94 183.35,130.94 183.21,131.08 182.08,131.08 181.68,131.48 180.71,131.48 180.55,131.65 CON_XMM3.255 179.78,131.11 179.59,130.92 179.04,130.92 178.18,131.78 177.13,131.78 176.28,130.93 173.72,130.93 173.47,130.68 155.53,130.68 151.92,134.29 151.92,134.78 151.42,135.27 150.93,135.27 150.34,135.86 150.34,136.35 149.87,136.83 149.38,136.83 148.99,137.22 148.99,137.71 148.32,138.37 147.83,138.37 144.23,141.98 143.92,141.98 143.74,142.16 143.74,142.59 143.38,142.95 142.78,142.95 142.42,142.59 142.42,142.08 142.25,141.91 141.94,141.91 141.76,142.09 141.76,142.84 141.45,143.15 141.45,143.72 141.25,143.92 140.82,143.92 140.59,144.15 140.59,144.46 140.46,144.59 140.2,144.59 140.09,144.48 XU1.AU3
M_CHA_DQS6: length 69.5
  TOP w0.102: XU1.AN2 136.58,143.59 136.58,143.84 136.42,143.99 136.28,143.99 136.17,144.09 135.99,144.09 135.86,143.96 135.86,143.05 136.08,142.84 136.08,141.67 136.64,141.11
  TOP w0.171: CON_XMM1.267 186.87,121.45 186.72,121.3 184.96,121.3 184.1,122.16 183.04,122.16 182.67,121.78 181.83,121.78 181.66,121.61 181.1,121.61 180.87,121.84 180.18,121.84 CON_XMM3.267 179.38,121.84 178.52,121.84 177.98,121.31 177.13,121.31 176.29,122.14 174.52,122.14 174.02,122.64 168.81,122.64 167,120.84 167,119.48 166.13,118.6 158.42,118.6 139.03,137.99 139.03,138.69 136.64,141.09 136.64,141.11
M_CHA_DQS6#: length 69.5
  TOP w0.102: 136.94,141.19 136.94,142.06 136.78,142.22 136.78,144 XU1.AN3
  TOP w0.171: 136.94,141.19 139.32,138.81 139.32,138.11 158.54,118.89 166.01,118.89 166.72,119.6 166.72,120.96 168.69,122.93 174.14,122.93 174.64,122.43 176.41,122.43 177.25,121.59 177.86,121.59 178.4,122.13 181.21,122.13 CON_XMM3.266 181.61,122.07 182.55,122.07 182.92,122.44 184.22,122.44 185.08,121.59 186.6,121.59 186.75,121.73 186.87,121.73 187.27,122.13 188.99,122.13 CON_XMM1.266
M_CHA_DQS7: length 79.7
  TOP w0.102: XU1.AJ2 132.77,143.06 132.41,142.71 132.41,142.24 132.25,142.08 132.25,141.56
  TOP w0.171: 132.25,141.56 132.59,141.22 132.59,135.87 155.84,112.62 160.56,112.62 160.78,112.4 160.78,111.92 161.07,111.63 162.27,111.63 162.57,111.92 162.57,112.37 162.74,112.54 163.33,112.54 163.5,112.37 163.5,111.98 163.87,111.62 164.7,111.62 165.01,111.93 165.01,112.37 165.26,112.62 165.69,112.62 165.94,112.37 165.94,111.43 166.25,111.12 174.13,111.12 174.15,111.14 174.96,111.95 176.42,111.95 177.26,112.8 178.17,112.8 179.02,111.94 179.66,111.94 179.82,112.1 CON_XMM3.278 183.1,112.1 183.24,111.96 184.22,111.96 185.08,112.82 186.01,112.82 186.17,112.66 186.87,112.66 187.27,112.26 188.98,112.26 CON_XMM1.278
M_CHA_DQS7#: length 79.7
  TOP w0.102: 132.89,141.22 133.1,141.43 133.1,142.01 133.1,142.01 133.1,143.68 132.89,143.89 132.48,143.89 132.35,144.02 132.35,144.23 132.48,144.36 XU1.AJ3
  TOP w0.171: CON_XMM1.277 186.29,112.95 186.13,113.11 184.96,113.11 184.1,112.25 183.35,112.25 183.22,112.38 182.08,112.38 181.68,112.78 180.77,112.78 180.6,112.95 CON_XMM3.277 179.78,112.46 179.54,112.22 179.14,112.22 178.28,113.08 177.14,113.08 176.3,112.24 174.85,112.24 174.01,111.41 166.37,111.41 166.23,111.55 166.23,112.49 165.81,112.91 165.15,112.91 164.72,112.49 164.72,112.05 164.58,111.9 163.99,111.9 163.79,112.1 163.79,112.49 163.45,112.83 162.62,112.83 162.29,112.49 162.29,112.04 162.16,111.91 161.19,111.91 161.06,112.04 161.06,112.52 160.68,112.91 155.96,112.91 132.87,135.99 132.87,141.21 132.89,141.22
M_CHA_MAA0: length 55.3
  TOP w0.102: 147.22,154.88 144.91,157.18 143.55,157.18 143.2,157.53 XU1.AW15
  TOP w0.159: CON_XMM3.79 176.69,158.84 176.87,159.02 177.88,159.02 178.06,159.2 178.73,159.2 179.08,159.54 180.04,159.54 180.91,158.68 182.48,158.68 182.64,158.84 CON_XMM1.79
  TOP w0.203: 147.22,154.88 147.5,154.88 147.94,154.43 154.83,154.43 155.12,154.14 156.15,154.14 156.44,154.43 157.31,154.43 157.53,154.22 157.53,153.92 157.4,153.8 157.01,153.8 156.88,153.67 156.88,153.36 157.02,153.23 158.76,153.23 158.88,153.34 158.88,153.55 159.09,153.77 159.36,153.77 159.56,153.57 159.56,153.37 159.7,153.23 160.87,153.23 161,153.35 161,153.66 161.18,153.84 161.74,153.84 161.96,153.62 161.96,153.36 162.09,153.23 162.61,153.23 162.74,153.35 162.74,154.28 162.92,154.46 163.32,154.46 163.45,154.33 163.45,153.45 163.63,153.27 163.97,153.27 164.15,153.45 164.15,154.06 164.84,154.75 165.45,154.75 165.67,154.97 165.67,155.58 166.39,156.31 171,156.31 171.13,156.43 171.13,156.84 171.41,157.12 171.82,157.12 172.26,157.57 172.26,157.98 172.59,158.3 172.97,158.3 173.1,158.43 173.1,158.76 173.25,158.91 173.48,158.91 173.74,158.64 174.09,158.64 174.27,158.82 174.27,159 173.94,159.33 173.94,159.53 174.31,159.9 175.17,159.9 175.34,159.74 175.34,159.49 175.13,159.28 175.13,158.97 175.26,158.84 CON_XMM3.79
M_CHA_MAA1: length 57.4
  TOP w0.102: 147.32,160.16 147.01,160.16 146.86,160.01 146.43,160.01 146.33,160.11 146.33,160.38 146.41,160.45 146.96,160.45 147.09,160.57 147.09,160.81 146.96,160.93 146.58,160.93 146.38,160.73 146.19,160.73 146.07,160.86 146.07,160.98 146.26,161.17 146.26,161.31 146.04,161.53 145.89,161.53 145.62,161.26 144.58,161.26 144.5,161.34 144.5,161.51 144.42,161.59 143.94,161.59 143.87,161.52 143.87,161.34 143.78,161.26 143.24,161.26 143.06,161.08 142.43,161.08 142.2,160.84 141.67,160.84 141.44,160.62 141.07,160.62 141,160.54 XU1.AU18
  TOP w0.159: CON_XMM3.72 178.7,169.9 179.1,170.06 180.38,170.06 180.68,170.37 180.85,170.37 181.06,170.57 181.69,170.57 182.08,170.18 183.35,170.18 183.47,170.06 184.04,170.06 184.25,170.27 184.98,170.27 CON_XMM1.72
  TOP w0.203: 147.32,160.16 161.49,160.16 166.94,165.61 168.25,165.61 168.6,165.27 169.11,165.27 169.63,165.79 169.63,166.36 170.84,167.56 170.84,167.84 171.02,168.02 171.91,168.02 172.11,168.22 172.11,168.61 171.91,168.81 170.99,168.81 170.76,169.04 170.76,169.49 171.03,169.76 176.61,169.76 176.75,169.9 CON_XMM3.72
M_CHA_MAA2: length 55.9
  TOP w0.102: XU1.AU17 141.53,159.89 141.53,160.41 141.75,160.63 142.3,160.63 142.53,160.86 143.17,160.86 143.36,161.05 145.58,161.05 146.1,160.54 146.1,160.05 146.38,159.78 147.32,159.78
  TOP w0.159: CON_XMM1.216 186.71,169.9 185.93,169.12 184.65,169.12 184.05,169.72 183.46,169.72 183.11,169.37 181.9,169.37 CON_XMM3.216 180.93,169.45 180.35,169.45 180.07,169.73 179.47,169.73 178.84,169.09 178.18,169.09
  TOP w0.203: 147.32,159.78 161.63,159.78 167.09,165.24 168.1,165.24 168.44,164.9 169.27,164.9 170,165.63 170,166.12 171.3,167.41 173.86,167.41 174.75,168.3 176.31,168.3 177.09,169.09 178.18,169.09
M_CHA_MAA3: length 58.3
  TOP w0.102: XU1.AV19 142.17,161.19 142.3,161.31 142.96,161.31 143.14,161.49 143.52,161.49 143.82,161.79 144.53,161.79 144.83,161.49 145.57,161.49 145.81,161.73 146.12,161.73 146.46,161.39 146.46,161.26 146.58,161.14 147.13,161.14
  TOP w0.159: CON_XMM3.71 176.15,170.57 178.62,170.57 179.47,171.42 180.08,171.42 180.44,171.06 180.94,171.06 181.09,170.91 182.16,170.91 182.33,170.75 CON_XMM1.71
  TOP w0.203: 147.13,161.14 147.35,160.92 147.35,160.68 147.49,160.54 148.13,160.54 148.23,160.64 148.84,160.64 148.95,160.54 149.46,160.54 149.57,160.64 150.1,160.64 150.21,160.54 150.78,160.54 150.89,160.64 151.42,160.64 151.53,160.54 152.19,160.54 152.3,160.64 152.9,160.64 153.01,160.54 153.74,160.54 153.85,160.64 154.45,160.64 154.56,160.54 155.2,160.54 155.31,160.64 155.85,160.64 155.96,160.54 156.54,160.54 156.64,160.64 157.32,160.64 157.43,160.54 158.05,160.54 158.15,160.64 158.84,160.64 158.94,160.54 159.61,160.54 159.72,160.64 161.45,160.64 161.72,160.9 161.72,161.19 161.52,161.38 161.52,161.67 161.92,162.07 162.21,162.07 162.4,161.87 162.69,161.87 163.08,162.27 163.08,162.56 162.89,162.75 162.89,163.04 163.28,163.43 163.57,163.43 163.76,163.24 164.05,163.24 164.45,163.63 164.45,163.92 164.25,164.11 164.25,164.4 164.65,164.8 164.94,164.8 165.13,164.6 165.42,164.6 165.71,164.9 165.71,165.15 165.56,165.3 165.56,165.56 166.09,166.09 169.04,166.09 169.27,166.32 169.27,166.73 169.08,166.91 168.51,166.91 168.34,167.08 168.34,170.11 168.57,170.33 169.09,170.33 169.32,170.1 169.32,169.01 169.49,168.83 169.85,168.83 170.08,169.06 170.08,170.11 170.21,170.23 175.47,170.23 CON_XMM3.71
M_CHA_MAA4: length 58.8
  TOP w0.102: XU1.AT19 140.45,160.82 141.15,160.82 141.51,161.17 141.51,161.3 141.74,161.53 142.85,161.53 143.01,161.7 143.43,161.7 143.73,161.99 144.61,161.99 144.91,161.7 145.49,161.7 145.72,161.93 146.21,161.93 146.67,161.47 146.72,161.47
  TOP w0.159: CON_XMM1.214 186.5,171.6 185.8,170.9 184.59,170.9 184.06,171.42 183.48,171.42 183.46,171.4 182.64,171.4 182.44,171.6 CON_XMM3.214 180.68,171.6 180.51,171.76 179.25,171.76 178.8,171.32 178.3,171.32 177.89,170.91 177.28,170.91 177.01,171.19 176.5,171.19 176.27,171.42 175.55,171.42 175.35,171.22
  TOP w0.203: 146.72,161.47 147.33,161.47 147.79,161.02 160.92,161.02 161.15,161.26 161.15,161.82 166.24,166.91 166.67,166.91 167.12,166.46 167.7,166.46 167.97,166.73 167.97,170.43 168.24,170.7 174.82,170.7 175.35,171.22
M_CHA_MAA5: length 58.8
  TOP w0.102: XU1.AU20 141.33,161.77 142.75,161.77 142.88,161.9 143.31,161.9 143.61,162.2 144.7,162.2 145,161.9 145.4,161.9 145.64,162.14 146.37,162.14 146.71,161.8
  TOP w0.159: CON_XMM1.213 186.96,172.45 186.83,172.57 186.83,172.69 186.71,172.82 186.42,172.82 186.3,172.69 186.3,172.55 186.17,172.42 185.07,172.42 184.66,172.02 184.29,172.02 184.04,171.76 183.44,171.76 183.22,171.99 181.98,171.99 181.69,172.27 181.1,172.27 181.09,172.26 179.97,172.26 CON_XMM3.213 ; 176.44,171.95 176.92,171.95 177.25,172.27 177.88,172.27 178.22,171.93 178.69,171.93 179.2,172.45
  TOP w0.165: 176.44,171.95 176.26,171.76 175.67,171.76 175.5,171.94 175.37,171.94 ; CON_XMM3.213 179.2,172.45
  TOP w0.203: 146.71,161.8 146.72,161.79 147.47,161.79 147.83,161.43 160.59,161.43 160.79,161.62 160.79,161.98 166.15,167.34 166.15,167.94 165.71,168.38 165.71,168.91 166,169.2 166.31,169.2 166.71,168.8 166.89,168.8 167.13,169.04 167.13,169.24 166.75,169.62 166.75,169.9 167.08,170.23 167.46,170.23 167.59,170.36 167.59,170.79 167.97,171.17 168.38,171.17 168.53,171.32 168.53,171.58 168.73,171.78 169.24,171.78 169.39,171.63 169.39,171.22 169.54,171.07 170.08,171.07 170.21,171.2 170.21,171.58 170.41,171.78 170.84,171.78 171.02,171.6 171.02,171.2 171.15,171.07 174.33,171.07 175.2,171.94 175.37,171.94
M_CHA_MAA6: length 58.3
  TOP w0.102: 143.46,162.46 143.1,162.1 142.8,162.1 142.67,161.97 142.04,161.97 XU1.AV20
  TOP w0.159: CON_XMM3.69 176.15,172.61 177.87,172.61 178.1,172.84 179.21,172.84 179.49,173.12 180.08,173.12 180.59,172.61 182.15,172.61 182.31,172.45 CON_XMM1.69
  TOP w0.203: CON_XMM3.69 174.76,172.45 174.27,171.96 174.27,171.58 174.13,171.44 173.16,171.44 172.86,171.74 172.51,171.74 172.2,171.44 171.7,171.44 171.05,172.09 171.05,173.35 170.92,173.47 170.34,173.47 169.98,173.11 169.98,172.85 170.28,172.54 170.28,172.17 169.96,171.86 169.7,171.86 169.57,171.98 169.57,172.26 169.44,172.39 169.04,172.39 168.8,172.15 168.34,172.15 168.1,172.39 167.79,172.39 167.53,172.12 167.53,171.94 167.77,171.7 167.77,171.49 167.47,171.19 167.29,171.19 167.06,171.42 166.83,171.42 166.49,171.08 166.49,170.9 166.75,170.63 166.75,170.42 166.43,170.1 166.25,170.1 165.99,170.36 165.76,170.36 165.38,169.98 165.38,169.8 165.64,169.54 165.64,169.36 165.34,169.06 165.34,168.22 165.78,167.78 165.78,167.49 165.52,167.23 165.3,167.23 164.67,167.87 164.39,167.87 164.2,167.68 164.2,167.17 164.67,166.7 164.67,166.38 160.1,161.81 147.9,161.81 147.6,162.11 146.78,162.11 146.43,162.46 145.59,162.46 145.35,162.22 145.05,162.22 144.81,162.46 143.46,162.46
M_CHA_MAA7: length 59.2
  TOP w0.102: 147.32,162.74 146.86,162.74 146.68,162.92 143.24,162.92 142.84,162.53 142.35,162.53 142.19,162.69 141.33,162.69 XU1.AU21
  TOP w0.159: CON_XMM1.211 187.55,174.14 186.92,174.14 186.67,173.89 186.01,173.89 185.93,173.97 184.92,173.97 184.64,173.69 184.27,173.69 184.05,173.46 183.44,173.46 182.59,174.31 179.95,174.31 CON_XMM3.211 179.61,173.97 177.24,173.97 176.97,173.7 176.51,173.7 176.28,173.46 175.61,173.46 175.46,173.62 174.97,173.62
  TOP w0.203: 147.32,162.74 148.11,162.74 148.28,162.57 159.82,162.57 163.47,166.22 163.47,168.23 164.6,169.37 164.6,170.24 167.49,173.13 168.95,173.13 170.24,174.42 171.61,174.42 171.95,174.08 171.95,173.67 172.08,173.54 173.03,173.54 173.17,173.4 173.17,173.22 173.02,173.07 171.91,173.07 171.79,172.94 171.79,172.71 171.91,172.58 173.63,172.58 174.59,173.54 174.89,173.54 174.97,173.62
M_CHA_MAA8: length 56.9
  TOP w0.102: XU1.AT20 140.09,162.41 140.46,162.79 140.6,162.79 140.92,162.47 142.06,162.47 142.21,162.32 142.94,162.32 143.34,162.72 146.58,162.72 146.88,162.43 147.32,162.43
  TOP w0.159: 174.56,172.99 175.5,172.99 175.63,173.12 176.5,173.12 176.58,173.05 177.33,173.05 CON_XMM3.68 177.75,173.46 180.06,173.46 180.22,173.62 180.73,173.62 181.08,173.97 181.67,173.97 182.52,173.12 184.04,173.12 184.25,172.92 184.97,172.92 CON_XMM1.68
  TOP w0.203: 174.56,172.99 173.96,172.39 173.96,171.96 173.81,171.81 173.41,171.81 173.28,171.94 173.28,172.06 173.12,172.21 172.46,172.21 172.05,171.81 171.85,171.81 171.42,172.24 171.42,173.77 171.13,174.05 170.4,174.05 169.1,172.76 167.64,172.76 164.97,170.09 164.97,169.21 163.83,168.07 163.83,166.07 159.96,162.19 148.13,162.19 147.89,162.43 147.32,162.43
M_CHA_MAA9: length 60.3
  TOP w0.102: XU1.AT22 140.09,164.34 140.18,164.44 140.51,164.44 140.69,164.26 141.3,164.26 141.4,164.16 141.4,163.82 141.64,163.57 143.17,163.57 143.42,163.33 146.42,163.33 146.64,163.55
  TOP w0.159: 175.01,175.39 175.41,175.39 175.64,175.16 177.41,175.16 CON_XMM3.66 177.75,175.17 180.35,175.17 180.57,175.39 180.79,175.39 181.08,175.67 181.67,175.67 181.94,175.41 183.22,175.41 183.46,175.16 184.03,175.16 184.23,175.36 184.99,175.36 CON_XMM1.66
  TOP w0.203: 146.64,163.55 148.48,163.55 148.69,163.33 158.09,163.33 158.3,163.55 158.3,164.09 158.54,164.33 158.86,164.33 159.08,164.11 159.08,163.69 159.3,163.47 159.64,163.47 160.11,163.95 160.11,164.25 159.44,164.92 159.44,165.23 159.75,165.53 160.05,165.53 160.73,164.86 161.03,164.86 161.34,165.17 161.34,165.47 160.88,165.93 160.88,166.42 161.07,166.61 161.43,166.61 161.83,166.2 162.01,166.2 162.44,166.63 162.44,166.81 161.89,167.37 161.89,167.69 163.78,169.58 163.78,170.45 167.23,173.91 168.69,173.91 170.57,175.79 171.88,175.79 172.09,175.59 172.09,175.28 172.21,175.15 174.77,175.15 175.01,175.39
M_CHA_MAA10: length 54.6
  TOP w0.102: 147.32,154.13 147.23,154.13 145.37,155.99 144.39,155.99 143.76,156.62 XU1.AY14
  TOP w0.159: 175.06,157.69 175.57,157.69 175.7,157.82 176.52,157.82 177.03,157.31 178.17,157.31 178.42,157.57 179.35,157.57 CON_XMM3.225 180.13,157.49 180.92,157.49 181.1,157.32 181.67,157.32 181.85,157.49 183.11,157.49 183.44,157.83 184.05,157.83 184.73,157.15 CON_XMM1.225
  TOP w0.203: 147.32,154.13 147.35,154.13 147.8,153.67 153.63,153.67 154.95,152.35 155.93,152.35 156.11,152.17 156.11,151.19 156.65,150.65 157.63,150.65 157.81,150.83 157.81,152.2 157.99,152.37 158.37,152.37 158.58,152.16 158.58,151.24 158.75,151.08 159.18,151.08 159.45,151.35 159.45,152.16 159.78,152.49 164.23,152.49 164.88,153.14 164.88,153.75 165.14,154.01 165.75,154.01 166.41,154.67 166.41,155.28 166.7,155.57 171.3,155.57 173.29,157.55 173.77,157.55 173.9,157.69 175.06,157.69
M_CHA_MAA11: length 58.2
  TOP w0.102: 147.32,163.13 143.32,163.13 143.07,163.37 141.56,163.37 XU1.AU22
  TOP w0.159: CON_XMM1.210 186.33,175 185.64,174.31 185.07,174.31 184.83,174.55 184.35,174.55 184.08,174.82 181.55,174.82 CON_XMM3.210 181.21,174.82 179.49,174.82 179.26,174.59 178.15,174.59 177.88,174.31 177.29,174.31 177.08,174.52 176.59,174.52 176.3,174.82 175.68,174.82 175.44,174.59 175.16,174.59
  TOP w0.203: 147.32,163.13 148.27,163.13 148.44,162.95 158.23,162.95 158.6,163.32 158.93,163.32 159.29,162.95 159.66,162.95 160.48,163.78 160.48,164.32 160.66,164.49 161.2,164.49 161.7,165 161.7,165.55 161.87,165.72 162.42,165.72 163.1,166.39 163.1,167.05 162.97,167.18 162.59,167.18 162.36,167.42 162.36,167.64 164.24,169.52 164.24,170.39 167.34,173.49 168.8,173.49 170.09,174.79 171.89,174.79 172,174.68 174.84,174.68 174.93,174.59 175.16,174.59
M_CHA_MAA12: length 57.2
  TOP w0.102: XU1.AV22 141.91,164.08 142.02,164.19 142.35,164.19 142.46,164.08 142.97,164.08 143.39,163.66 146.26,163.66
  TOP w0.159: CON_XMM1.65 183.58,176.02 180.93,176.02 180.42,176.52 179.14,176.52 178.29,175.67 176.15,175.67 CON_XMM3.65
  TOP w0.203: CON_XMM3.65 174.75,175.85 174.55,175.65 174.16,175.65 174.03,175.77 174.03,176.01 174.28,176.26 174.28,176.44 174.15,176.58 170.84,176.58 168.68,174.42 167.22,174.42 163.41,170.61 163.41,169.73 160.92,167.25 160.62,167.25 160.16,167.7 159.98,167.7 159.67,167.39 159.67,167.21 160.14,166.74 160.14,166.49 159.87,166.22 159.61,166.22 158.8,167.03 158.55,167.03 158.26,166.75 158.26,166.47 159.09,165.64 159.09,165.42 158.77,165.1 158.55,165.1 157.71,165.94 157.45,165.94 157.21,165.7 157.21,165.04 157.43,164.82 157.74,164.82 157.95,164.6 157.95,164.28 157.39,163.72 148.85,163.72 148.63,163.93 146.53,163.93 146.26,163.66
M_CHA_MAA13: length 54.8
  TOP w0.102: 147.32,150.76 145.78,152.3 143.88,152.3 142.38,153.8 142.38,154.32 XU1.AV12
  TOP w0.159: CON_XMM1.232 187.74,151.2 184.58,152.36 184.03,152.73 183.43,152.73 182.76,152.23 182.5,152.03 CON_XMM3.232 180.66,151.2 180.49,151.36 179.36,151.36 177.94,151.88 177.19,151.88 176.26,151.37 175.67,151.37 175.43,151.61 175.2,151.61
  TOP w0.203: 175.2,151.61 174.32,151.61 168.99,146.28 162.16,146.28 161.8,145.92 156.74,145.92 152.66,150 148.08,150 147.32,150.76
M_CHA_MAA14: length 57.6
  TOP w0.102: XU1.AV14 142.37,156.16 142.37,155.64 142.68,155.33 143.31,155.33 143.47,155.17 144.96,155.17 147.32,152.81
  TOP w0.159: CON_XMM1.228 186.68,154.6 185.98,155.3 184.84,155.3 184.31,154.77 183.15,154.77 182.85,155.07 181.85,155.07 CON_XMM3.228 180.94,155.04 180.34,155.04 180.06,154.77 179.5,154.77 179.18,155.08 178.21,155.08 177.79,155.5 177.03,155.5 176.67,155.87 176.58,155.87 176.31,156.13 174.24,156.13
  TOP w0.203: 174.24,156.13 173.46,156.13 171.79,154.46 170.87,154.46 168.87,152.47 168.59,152.47 168.43,152.63 168.14,152.63 167.75,152.23 167.75,151.94 167.9,151.79 167.9,151.5 167.53,151.13 167.24,151.13 166.87,151.5 166.58,151.5 166.19,151.1 166.19,150.81 166.56,150.44 166.56,150.16 165.32,148.92 156.76,148.92 153.15,152.53 147.6,152.53 147.32,152.81
M_CHA_MAA15: length 52.9
  TOP w0.102: XU1.AY11 144.04,153.87 144.1,153.82 145.09,153.82 147.32,151.59
  TOP w0.159: CON_XMM3.86 180.41,152.9 181.09,153.58 181.67,153.58 181.92,153.32 182.8,153.32 183.06,153.06 184.2,153.06 184.54,153.4 184.85,153.4 CON_XMM1.86
  TOP w0.203: 147.32,151.59 147.86,151.05 152.83,151.05 156.34,147.55 157.12,147.55 157.34,147.33 157.34,147.1 157.58,146.86 157.98,146.86 158.2,147.08 158.2,147.33 158.42,147.55 158.8,147.55 159.06,147.29 159.06,147 159.28,146.79 159.71,146.79 159.93,147 159.93,147.33 160.15,147.55 160.58,147.55 160.79,147.33 160.79,147 161.01,146.79 161.44,146.79 161.66,147 161.66,147.33 161.87,147.55 162.28,147.55 162.7,147.13 163.2,147.13 163.41,147.33 163.41,147.35 163.61,147.55 164.17,147.55 164.37,147.35 164.37,147.33 164.58,147.13 165.14,147.13 165.34,147.33 165.34,147.35 165.54,147.55 166.1,147.55 166.3,147.35 166.3,147.33 166.51,147.13 167.07,147.13 167.27,147.33 167.27,147.35 167.47,147.55 168.71,147.55 168.88,147.73 168.88,148.29 169.16,148.56 169.72,148.56 170.46,149.3 170.46,150.25 170.85,150.65 171.25,150.65 171.39,150.5 171.68,150.5 171.86,150.68 171.86,151.76 172.19,152.1 172.92,152.1 173.72,152.9 CON_XMM3.86
M_CHA_MAA16: length 56.1
  TOP w0.102: 147.32,153.26 145.21,155.37 143.56,155.37 143.23,155.7 XU1.AW13
  TOP w0.159: 175.32,156.47 177.41,156.47 CON_XMM3.82 178.01,155.86 179.17,155.86 179.43,156.13 180.1,156.13 180.64,155.59 182.01,155.59 182.33,155.92 182.89,155.92 183.27,156.3 CON_XMM1.82
  TOP w0.203: 147.32,153.26 147.67,152.91 153.31,152.91 156.89,149.33 157.23,149.33 157.61,149.71 158.09,149.71 158.5,149.3 159.05,149.3 159.46,149.71 159.92,149.71 160.32,149.3 161.62,149.3 162.03,149.71 162.33,149.71 162.74,149.3 163.66,149.3 163.93,149.57 163.93,150.7 164.16,150.93 164.52,150.93 164.72,150.72 164.72,150.04 164.87,149.89 165.16,149.89 165.53,150.26 165.53,151.17 166.21,151.85 166.21,152.14 165.65,152.69 165.65,152.98 165.92,153.25 166.46,153.25 166.89,152.82 167.18,152.82 167.58,153.22 167.58,153.51 167.09,153.99 167.09,154.3 167.44,154.65 167.8,154.65 168.26,154.19 168.55,154.19 169.19,154.83 171.61,154.83 173.39,156.61 174.99,156.61 175.14,156.47 175.32,156.47
M_CHA_ODT0: length 45.5
  TOP w0.159: CON_XMM3.87 175.73,152.29 174.14,152.29 173.24,151.39 172.45,151.39 172.28,151.22 172.28,150.43 171.91,150.06 171.13,150.06 170.88,149.81 170.88,149.04 169.98,148.13 169.52,148.13 169.31,147.92 169.31,147.46 168.55,146.71 168.23,146.71 168.12,146.81 168.12,147 168,147.13 167.67,147.13 167.25,146.71 166.33,146.71 166,147.04 165.71,147.04 165.38,146.71 164.29,146.71 164,146.99 163.8,146.99 163.52,146.71 162.53,146.71 162.33,146.9 162.15,146.9 161.61,146.35 160.83,146.35 160.48,146.71 160.24,146.71 159.89,146.35 159.1,146.35 158.75,146.7 158.44,146.7 158.09,146.35 157.01,146.35 156.91,146.46 156.91,146.95 156.74,147.12 156.16,147.12 155.92,147.36 152.65,150.62 152.3,150.62 152.11,150.43 151.77,150.43 151.58,150.62 151.16,150.62 150.97,150.43 150.53,150.43 150.34,150.62 149.91,150.62 149.72,150.43 149.34,150.43 149.15,150.62 148.84,150.62 148.65,150.43 148.37,150.43 148.18,150.62 147.88,150.62 145.54,152.96 145.34,152.96 145.2,152.82 145.2,152.65 145.08,152.53 144.87,152.53 144.75,152.65 144.75,153.01 144.92,153.18 144.92,153.41 144.75,153.58 144.36,153.58 144.25,153.47 144.25,152.68 144.13,152.56 143.96,152.56 143.64,152.88 143.64,153.31 143.51,153.44 143.07,153.44 142.83,153.68 XU1.AW11
M_CHA_ODT1: length 47.2
  TOP w0.102: 145.1,151.49 142.42,151.49 140.63,153.27 140.63,156.25 XU1.AU14
  TOP w0.159: 145.1,151.49 147.97,148.61 152.29,148.61 157.24,143.66 162.1,143.66 162.38,143.94 162.38,144.48 162.54,144.63 162.94,144.63 163.1,144.48 163.1,143.78 163.26,143.62 163.86,143.62 164.01,143.76 164.02,143.78 164.02,144.48 164.18,144.63 164.71,144.63 165.09,144.25 165.63,144.25 166.02,144.63 169.88,144.63 173.89,148.65 CON_XMM3.91
M_CHA_ODT2: length 56.5
  TOP w0.102: 147.31,150.24 145.51,152.04 142.43,152.04 141.38,153.1 141.38,154.05 141,154.43 XU1.AU12
  TOP w0.159: 147.31,150.24 148.05,149.5 151.61,149.5 151.68,149.57 152.48,149.57 156.61,145.44 161.96,145.44 162.38,145.86 162.78,145.86 162.94,145.7 162.94,145.59 163.1,145.43 163.7,145.43 163.86,145.59 163.86,145.7 164.02,145.86 164.62,145.86 164.78,145.7 164.78,145.59 164.94,145.43 165.54,145.43 165.7,145.59 165.7,145.7 165.86,145.86 166.47,145.86 166.62,145.7 166.62,145.56 166.75,145.43 167.39,145.43 167.55,145.59 167.55,145.7 167.7,145.86 168.13,145.86 168.28,145.72 168.28,145.56 168.4,145.43 168.85,145.43 168.96,145.54 168.96,145.71 169.11,145.86 169.33,145.86 174.38,150.91 175.47,150.91 175.58,151.03 176.27,151.03 176.93,150.37 177.9,150.37 178.46,149.81 178.73,149.81 178.91,149.99 178.91,150.69 179.24,151.02 180.3,151.02 180.58,150.74 180.83,150.74 181.05,150.52 181.67,150.52 182.62,151.46 182.97,151.46 183.3,151.13 183.93,151.13 184.16,150.89 184.47,150.89 184.65,151.07 184.65,151.34 184.35,151.64 184.16,151.64 CON_XMM1.87
M_CHA_ODT3: length 53.2
  TOP w0.159: XU1.AY10 142.96,150.89 143.95,150.89 144.14,150.7 144.14,150.21 144.31,150.05 144.54,150.05 144.7,150.21 144.7,150.66 144.81,150.76 144.99,150.76 147.96,147.79 151.95,147.79 156.93,142.81 167.58,142.81 168.1,143.33 168.1,143.68 168.26,143.83 170.21,143.83 172.94,146.56 173.2,146.56 173.56,146.2 173.91,146.2 174.09,146.38 174.09,146.56 173.65,147 173.65,147.26 173.82,147.43 174.16,147.43 174.52,147.07 174.78,147.07 175.34,147.63 176.4,147.63 176.98,147.05 178.17,147.05 178.99,147.87 180.26,147.87 181.15,148.76 182.11,148.76 182.3,148.57 182.3,147.23 182.48,147.05 182.77,147.05 182.95,147.23 182.95,148.48 183.12,148.65 CON_XMM1.91
M_CHA_PAR: length 54.3
  TOP w0.102: XU1.AY15 144.98,157.53 147.32,155.19
  TOP w0.159: CON_XMM1.222 188.43,160.41 182.87,160.41 182.15,159.7 CON_XMM3.222
  TOP w0.203: 147.32,155.19 147.63,155.19 147.98,154.84 157.73,154.84 157.91,154.66 157.91,154.08 158.09,153.9 158.7,153.9 158.88,154.08 158.88,154.66 159.05,154.84 159.53,154.84 159.71,154.66 159.71,153.94 159.89,153.76 160.4,153.76 160.58,153.94 160.58,154.66 160.75,154.84 161.26,154.84 161.44,154.66 161.44,154.38 161.62,154.2 162.13,154.2 162.3,154.38 162.3,154.66 162.52,154.87 164.44,154.87 166.24,156.67 170.44,156.67 173.97,160.21 176.69,160.21 176.87,160.39 177.87,160.39 178,160.26 179.76,160.26 179.95,160.45 181.25,160.45 181.38,160.32 CON_XMM3.222
M_CHB_ACT#: length 75.6
  TOP w0.102: XU1.AU28 141.38,169.42 141.74,169.05 142.15,169.05 142.18,169.07 143.91,169.07 144.08,169.24 145.92,169.24 145.98,169.18 147.05,169.18
  TOP w0.203: 147.05,169.18 147.81,168.42 153.4,168.42 157.48,172.5 157.48,174.11 157.15,174.44 156.66,174.44 156.41,174.18 156.41,173.76 156.79,173.37 v1(156.79,172.92)
  IN1 w0.178: CON_XMM2.62 199.51,178.4 198.81,179.09 197.25,179.09 196.72,178.56 194.97,178.56 194.8,178.4 CON_XMM4.62 193.82,178.23 192.99,178.23 192.81,178.41 192.05,178.41 191.47,178.99 189.89,178.99 189.61,179.27 188.73,179.27 187.94,180.06 187.17,180.06 186.41,179.3 184.95,179.3 184.19,180.06 183.41,180.06 182.63,179.27 181,179.27 180.21,180.06 179.43,180.06 178.66,179.3 177.17,179.3 176.53,179.93 175.49,179.93 175.33,179.78 166.73,179.78 165.39,178.44 159.94,178.44 156.79,175.29 v1(156.79,172.92)
M_CHB_ALERT#: length 70.6
  TOP w0.102: 147.32,167.6 146.04,166.32 144.39,166.32 144.03,166.67 XU1.AY25
  TOP w0.203: 147.32,167.6 147.67,167.95 153.62,167.95 155.76,170.09 156.16,170.09 156.5,170.43 156.5,170.85 157.09,171.44 v1(157.41,171.44)
  IN1 w0.178: v1(157.41,171.44) 158.79,171.44 164,176.66 170.69,176.66 170.89,176.86 176.44,176.86 177.29,176.01 177.97,176.01 178.82,176.86 180.24,176.86 181.09,176.01 181.66,176.01 182.51,176.86 184.22,176.86 185.07,176.01 185.74,176.01 186.59,176.86 188.01,176.86 188.86,176.01 189.57,176.01 190.09,176.53 193.04,176.53 193.56,176.01 194.55,176.01 195.4,176.86 197.62,176.86 CON_XMM4.208 199.4,176.7 199.57,176.53 200.66,176.53 201.3,175.9 202.26,175.9 203.06,176.7 CON_XMM2.208
