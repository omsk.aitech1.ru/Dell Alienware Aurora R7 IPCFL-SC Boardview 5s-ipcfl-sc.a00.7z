# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CTR: length 9.6
  TOP w0.254: LR20.1 23.36,219.15 v1(23.09,219.15)
  BOTTOM w0.254: J9.R10 22.61,211.52 22.61,218.67 v1(23.09,219.15)
V5_ALW_MON: length 8
  TOP w0.102: v1(216.36,19.51) OR5.1 215.68,19.98 215.7,19.99 OR6.1 215.7,20.99 215.65,21.04 215.65,22.38 215.73,22.47 AC39.1 216.08,22.91 215.6,23.39 215.11,23.39 214.54,23.97 U104.15
  BOTTOM w0.102: v2(215.6,19.51) v1(216.36,19.51)
VCC: length 4.6
  TOP w0.102: PU12.1 116.53,51.16 116.31,51.38 116.31,51.89 116.28,51.92 116.28,51.96 v1(116.28,51.96)
  TOP w0.356: PC568.1 116.95,50.16 116.93,50.17 PU12.1
  TOP w0.457: PR6601.2 PC568.1
  BOTTOM w0.102: v1(116.28,51.96) 115.5,51.96 v2(115.49,51.97)
VCC_SENSE: length 1.6
  TOP w0.254: XU1.C38 v1(109.48,179)
  BOTTOM w0.254: v1(109.48,179) 109.24,179.24 PJP621.2
VCCGT_SENSE: length 1.5
  TOP w0.254: XU1.F39 112.63,179.48 v1(112.19,179.91)
  BOTTOM w0.254: PJP623.2 112.19,180.06 v1(112.19,179.91)
VCCIO_PG: length 5.6
  TOP w0.102: ECQ12.1 128.6,92.14 ECC56.1 ECR105.2 130.76,93.38 v1(130.76,93.57) ECQ13.3
  BOTTOM w0.102: v2(130.71,92.81) 130.76,92.86 v1(130.76,93.57)
VCCIO_SENSE: length 58.8
  TOP w0.229: v1(128.66,144.78) 128.68,144.81 129.56,144.81 XU1.AF4
  TOP w0.254: v1(125.78,101.14) 125.54,101.38 PR313.2 ; v1(135.94,116.94) 135.92,116.97 134.19,116.97 133.4,117.75 v1(132.13,117.75)
  BOTTOM w0.254: v1(135.94,116.94) 135.94,127.29 128.89,134.34 128.89,139.47 129.2,139.78 129.2,144.23 v1(128.66,144.78) ; v1(132.13,117.75) 131.39,117.75 130.28,116.64 130.28,114.53 129.39,113.64 127.41,113.64 125.34,111.57 v2(125.34,102.36) 125.34,101.59 v1(125.78,101.14)
VCCSA_PWRGD: length 5.4
  TOP w0.102: PR70176.2 64.52,121.54 v1(64.87,121.89) 65.38,122.4 66.6,122.4 67.34,121.67 PU10.8
  BOTTOM w0.102: v2(65.33,122.73) 64.87,122.28 v1(64.87,121.89)
VCCSA_SENSE: length 164.8
  TOP w0.254: v1(76.42,101.58) 76.42,101.53 86.68,91.28 95.07,91.28 96.38,89.97 96.79,89.55 132.86,89.55 v1(132.97,89.66) ; XU1.AD5 127.78,145.77 v1(127.78,145.71) ; v1(60.29,115.31) 60.29,123.34 62,125.04 62,127.52 62.37,127.89 63.32,127.89 63.58,127.64 63.58,126.15 PR317.2
  BOTTOM w0.254: v1(60.29,115.31) 60.95,114.66 64.78,114.66 76.42,103.02 v1(76.42,101.58) ; v1(127.78,145.71) 128.16,145.34 128.16,143.37 128.73,142.8 128.73,139.83 128.52,139.62 128.52,134.19 134.92,127.79 134.92,122.83 132.41,120.32 132.41,119.1 133.62,117.89 133.62,109.78 136.25,107.15 v2(136.25,102.34) 136.09,102.18 136.09,95.71 133.55,93.17 133.55,90.04 133.17,89.66 v1(132.97,89.66)
VCCST&PCH_PWRGD: length 12.1
  TOP w0.102: OR51.2 HC29.1 206.12,54.19 205.41,54.19 205.18,53.96 205.18,52.63 205.33,52.48 PQ9777.3 205.33,51.03 204.6,50.29 204.6,48.9 204.98,48.51 v1(205.99,48.51) ; MQ28.2 v1(205.99,48.51) ; v1(205.99,48.51) MQ28.5
  BOTTOM w0.102: v2(205.23,48.51) v1(205.99,48.51)
VCCST_PWRGD_1P0V: length 163.4
  TOP w0.102: MQ28.6 205.34,49.9 205.49,50.04 207.3,50.04 OR52.2 208.24,50.04 v1(208.51,50.04) ; 137.74,112.85 137.06,112.17 134.75,112.17 134.4,112.51 HC25.1 132.38,112.31 132.38,111.91 132.77,111.53 PR4.1 ; 137.74,112.85 138.38,112.22 138.61,112.22 139.33,111.49 139.59,111.49 144,107.08 153.09,107.08 154.55,105.63 169.6,105.63 v1(170.07,105.16) ; 137.74,112.85 138.61,113.72 138.61,115.19 136.12,117.68 134.26,117.68 133.71,118.24 130.35,118.24 129.79,118.8 128.6,118.8 128.17,119.23 127.13,119.23 126.8,118.9 122.31,118.9 HR630.1 ; v1(208.11,58.95) 208.11,59.87 208.46,60.21 208.46,73.73 210.45,75.72 210.45,87.95 209.75,88.65 v1(209.75,90.81)
  BOTTOM w0.102: v1(208.11,58.95) 208.48,58.58 208.48,51.64 208.09,51.24 208.09,50.46 v1(208.51,50.04) ; v1(209.75,90.81) 210.92,91.97 210.92,93.39 206.75,97.56 v2(206.3,97.56) 205.74,97.56 203.62,99.69 201.67,99.69 200.44,98.46 197.88,98.46 196.66,99.69 193.42,99.69 193.26,99.53 188.71,99.53 187.98,100.26 174.91,100.26 174.46,99.81 172.8,99.81 170.07,102.55 v1(170.07,105.16)
VCCST_PWRGD_DISCHARGE: length 6.4
  TOP w0.102: v1(128.7,109.83) 128.88,110.01 MQ21.3 129.87,110.01 130.34,109.54 131.97,109.54 132.23,109.8 PR4.2
  BOTTOM w0.102: v2(129.49,108.56) 128.7,109.35 v1(128.7,109.83)
VDDQ_DAC: length 430.1
  TOP w0.102: v1(211.53,229.92) 211.07,229.46 211.07,228.97 210.82,228.72 PR70225.2 ; v1(196.9,22.3) 196.9,20.77 199.13,18.55 199.13,14.69 199.36,14.46 199.36,11.21 200,10.57 v1(200,9.27) ; v1(218.82,229.59) 217.47,230.94 v1(211.66,230.94) ; PU12.8 116.93,54.8 116.31,55.42 PC569.1 116.56,55.88 116.73,56.05 116.73,57.59 117.02,57.89 117.02,58.17 118.46,59.61 120.66,59.61 122.13,58.14 122.13,46.68 122.76,46.05 126.9,46.05 132.25,40.7 132.25,34.05 v1(148.73,17.57)
  BOTTOM w0.102: v1(200,9.27) 200.59,9.86 210.88,9.86 215.76,4.98 224.36,4.98 225.17,5.79 229.66,5.79 234.9,11.03 234.9,16.73 238.43,20.26 238.43,22.91 237.4,23.93 237.4,25.23 237.42,25.26 237.42,27.29 236.03,28.69 236.03,31.86 238.03,33.87 238.03,35.78 236.97,36.85 236.97,38.28 237.32,38.64 237.32,40.01 234.89,42.45 234.89,53.49 237.29,55.9 237.29,57.8 232.79,62.3 232.79,67.45 227.28,72.96 227.28,86.16 228.58,87.45 229.85,87.45 230.83,88.43 230.83,89.47 233.86,92.5 233.86,100.67 234.73,101.54 234.73,136.76 232.87,138.63 232.87,139.96 233.12,140.21 233.12,148.72 231.1,150.74 231.1,170.69 231.7,171.29 231.7,181.95 232.22,182.47 232.22,184.59 231.67,185.14 231.67,189.14 231.59,189.22 231.59,202.69 232.37,203.47 232.37,208.63 233.1,209.35 233.1,212.29 234.75,213.94 234.75,215.1 234.54,215.3 234.54,219.58 v2(233.35,220.78) 232.17,221.96 232.17,223.44 223.91,231.7 220.93,231.7 v1(218.82,229.59) ; v1(148.73,17.57) 154.52,17.57 155.48,18.53 157.2,18.53 159.61,20.95 168.49,20.95 169.24,20.19 176.54,20.19 177.86,21.51 180.55,21.51 182.38,23.34 195.12,23.34 196.16,22.3 v1(196.9,22.3) ; v1(211.66,230.94) 211.66,230.05 v1(211.53,229.92)
VDDQ_PWRGD: length 236.6
  TOP w0.102: U104.111 207.96,33.24 208.45,32.75 212.61,32.75 213.06,32.31 214.6,32.31 v1(214.63,32.33) ; v1(211.12,58.17) 211.12,73.11 214.35,76.33 214.35,88.41 213.12,89.65 213.12,92.57 v1(212.76,92.93) ; PU651.8 213.36,222.85 PR6506.2 214.5,224.03 214.92,224.45 214.92,227.04 v1(215.11,227.23)
  BOTTOM w0.102: v1(211.12,58.17) 210.88,57.92 210.88,53.35 214.78,49.45 214.78,46.29 215.68,45.39 215.68,34.08 214.63,33.02 v1(214.63,32.33) ; v1(212.76,92.93) 213.49,93.65 213.49,96.74 215.96,99.21 215.96,102.17 216.55,102.75 216.55,105.74 215.65,106.63 215.65,109.6 218.19,112.13 218.19,120.51 219.74,122.06 219.74,124.3 219.6,124.45 219.6,129.22 224.64,134.26 v2(224.64,140.55) 228.92,144.83 228.92,145.76 225.13,149.55 225.13,166.76 224.18,167.72 224.18,170.7 225.3,171.81 225.3,185.13 225.22,185.2 225.22,188.31 225.5,188.59 225.5,190.12 227.08,191.69 227.08,204.07 228.9,205.9 228.9,212.38 228.9,214.06 229.5,214.66 229.5,222.44 224.19,227.75 215.63,227.75 v1(215.11,227.23)
VDDQ_SET: length 4.6
  TOP w0.102: v1(118.68,55.05) 119.1,55.47 PR6602.2 R69694.1 118.19,54.68 118.23,54.64 PU12.6
  BOTTOM w0.102: v2(119.81,54.94) 119.7,55.05 v1(118.68,55.05)
VSS_SENSE: length 5.5
  TOP w0.254: XU1.D38 v1(110.34,178.08)
  BOTTOM w0.254: PJP622.2 107.7,180.85 108.08,180.85 108.52,180.4 108.82,180.4 110.34,178.87 v1(110.34,178.08)
VSSGT_SENSE: length 2.5
  TOP w0.254: v1(112.2,179.08) 112.65,178.63 XU1.F38
  BOTTOM w0.254: PJP624.2 111.61,180.01 111.61,179.78 112.19,179.2 112.19,179.11 112.2,179.09 v1(112.2,179.08)
+0P95V_CPUIO: length 126.1
  TOP w0.254: v1(84.07,96.98) 84.07,96.18 87.62,92.63 95.63,92.63 97.12,91.15 v1(125.73,91.15) ; v1(98.67,99.81) 98.67,101.63 98.01,102.29 v1(98.01,104.09) ; v1(133.11,157.07) 133.49,157.07 133.5,157.07 134.14,157.07 XU1.AK14 ; XU1.AK11 134.58,153.87 134.13,154.33 v1(133.22,154.33) ; v1(125.48,94.87) 125.68,95.07 130.63,95.07 131.06,95.5 131.06,95.69 ECR92.1 ; v1(103.12,116.91) HR29.1
  TOP w0.356: XU1.W8 123.81,149.11
  TOP w0.381: HR4.1 120.55,152.58 120.83,152.3 ; 120.28,151.02 HR6.1 120.75,151.66 ; XU1.M8 117.23,148.95 117.73,149.45
  TOP w0.457: 123.46,101.38 PR130.1 124.18,102.08
  TOP w0.635: 123.75,106.38 PCE14.1 ; PCE14.1 122.81,107.31 ; PCE14.1 122.81,105.44 ; PCE14.1 121.87,106.38
  BOTTOM w0.254: v1(124.66,104.42) 124.66,100.81 125.48,100 v1(125.48,94.87) 126.25,94.87 126.87,94.24 v2(126.87,93.45) 126.87,92.29 v1(125.73,91.15) ; v1(98.67,99.81) 89.42,99.81 88.85,100.38 86.29,100.38 84.07,98.17 v1(84.07,96.98) ; v1(103.12,116.91) 104.16,116.91 106.24,114.84 106.24,112.32 v1(98.01,104.09)
  BOTTOM w4.191: 125.42,139.7 125.42,131.83
  vias: v1(121.72,150.75) v1(121.72,150.11) v1(122.35,150.72) v1(122.35,150.09) v1(122.99,150.72) v1(122.99,150.09) v1(123.65,150.67) v1(123.65,150.04) v1(132.84,165.68) v1(132.87,164.9) v3(123.24,113.87) v3(123.32,112.98) v3(123.32,112.07) v3(123.77,114.68) v3(124.17,113.84) v3(124.23,112.93) v3(124.21,112.01)
+0P95V_DISCHARGE: length 17.8
  TOP w0.381: v1(127.71,111.15) 128.07,111.15 128.83,111.91 130.05,111.91 130.65,111.31 MQ21.6
  TOP w0.635: v1(127.71,111.15) 126.19,111.15 125.43,111.91 125.43,115.19 124.84,115.77 121.59,115.77 120.47,114.66 PR3.2
  BOTTOM w0.254: v1(127.71,111.15) 128.09,110.77 v2(128.09,110.34)
+1P2V: length 157.6
  TOP w0.254: U4.12 41.67,146.13 UC68.1
  TOP w0.279: UC970.1 31.42,148.82 32.11,148.13 U4.33 ; v1(31.67,140.79) 32.01,141.13 U4.47 ; UC78.1 30.38,144.06 31.75,144.06 31.82,144.13 U4.41 ; v1(34.59,139.14) 34.52,139.22 U4.52 ; U4.1 41.29,140.63 41.48,140.44 41.48,139.57 ; UC83.1 37.92,138.21 37.92,139.04 37.52,139.45 U4.58 ; UC77.1 31.13,147.83 31.64,147.83 31.86,147.62 31.86,147.34 32.07,147.13 U4.35
  TOP w0.381: v1(31.24,147.19) 31.13,147.31 UC77.1 UC970.1
  TOP w0.457: v1(30.68,143.46) 30.28,143.46 UC78.1 ; UC68.1 42.29,147.98 v3(41.16,149.11) ; v1(38.48,138.63) 38.48,138.61 38.49,138.6 38.49,138.42 38.18,138.1 UC83.1 ; 41.48,139.57 41.64,139.41 UC69.1 41.64,138.21 42.11,137.74 v3(42.11,137.62) ; UC90.1 31.25,140.47 31.25,140.5 31.55,140.79 v1(31.67,140.79)
  TOP w0.508: v1(34.39,137.54) 34.39,138.99 34.54,139.14 v1(34.59,139.14) ; UC92.1 37.77,155.23 v1(37.57,155.44)
  TOP w0.635: v3(42.11,137.62) 42.16,137.57 42.29,137.57 42.88,136.98 42.88,136.04 42.3,135.47 39.15,135.47 38.79,135.84 v1(38.68,135.84)
  TOP w0.762: v3(32.69,166.78) v3(39.14,166.78)
  BOTTOM w0.381: v1(30.68,143.46) 31.03,143.8 31.03,146.98 v1(31.24,147.19)
  BOTTOM w0.508: v1(30.68,143.46) 30.68,142.44 31.67,141.45 v1(31.67,140.79) ; v1(38.48,138.63) 38.02,138.63 37.52,139.14 v1(34.59,139.14)
  BOTTOM w0.635: v1(38.68,135.84) 37.11,135.84 35.41,137.54 v1(34.39,137.54) 33.42,137.54 31.67,139.29 v1(31.67,140.79)
  BOTTOM w0.762: v3(42.11,137.62) 41.96,137.77 41.96,142.82 40.77,144.02 40.77,146.92 41.16,147.31 v3(41.16,149.11) 38.52,151.75 38.52,153.31 37.57,154.26 v1(37.57,155.44) 37.57,157.49 36.22,158.84 36.22,160.33 32.69,163.87 v3(32.69,166.78) ; v3(39.14,166.78) 38.89,167.03 38.89,173.41 40.16,174.68 40.16,182.43 41.07,183.35 41.07,194.92 41.68,195.53 41.68,206.43 42.63,207.39 42.63,207.43 42.77,207.57 42.77,217.54 41.72,218.59 40.91,218.59 39.97,219.53 39.97,224.02 v2(38.25,225.73) 37.6,226.38 v3(36.21,226.38)
+1P2V_DUAL: length 792.6
  TOP w0.102: CON_XMM1.132 184,113.6 183.4,113.6 183.19,113.39 182.1,113.39 181.85,113.15 180.93,113.15 180.63,113.45 180.21,113.45 180.06,113.6 179.38,113.6 179.24,113.46 178.72,113.46 CON_XMM3.132 ; CON_XMM2.29 197.11,206.45 196.4,205.74 195.35,205.74 194.64,206.45 CON_XMM4.29 ; CON_XMM3.121 176.75,122.79 177.04,122.79 177.2,122.95 177.94,122.95 178.02,122.87 178.94,122.87 179.31,122.5 180.16,122.5 180.43,122.76 180.89,122.76 181.08,122.95 181.66,122.95 181.9,122.7 182.3,122.7 CON_XMM1.121 184.62,122.75 184.85,122.75 185.05,122.95 185.62,122.95 185.79,122.77 186.97,122.77 187.25,122.5 187.84,122.5 188.45,123.1 ; CON_XMM3.51 178.14,187.75 178.94,186.94 180.26,186.94 181.06,187.75 CON_XMM1.51 ; CON_XMM3.18 178.72,215.45 179.24,215.45 179.39,215.59 180.05,215.59 180.21,215.44 180.78,215.44 181.07,215.14 181.72,215.14 181.95,215.38 183.23,215.38 183.45,215.59 184.05,215.59 CON_XMM1.18 ; CON_XMM1.59 184.4,180.95 184.57,181.12 185.74,181.12 186.08,181.46 186.93,181.46 187.11,181.64 187.99,181.64 188.29,181.33 188.6,181.33 189.15,180.78 ; CON_XMM3.29 176.75,206.08 177.03,206.08 177.19,206.24 177.9,206.24 177.99,206.16 179.13,206.16 179.49,205.79 180.09,205.79 180.3,205.99 180.82,205.99 181.08,206.25 181.66,206.25 181.91,205.99 182.3,205.99 182.42,206.03 CON_XMM1.29 184.62,206.04 184.88,206.04 185.08,206.25 185.87,206.25 186.06,206.06 187.01,206.06 187.28,205.79 187.84,205.79 188.46,206.41 ; CON_XMM3.110 178.72,132.16 179.24,132.16 179.38,132.3 180.06,132.3 180.21,132.15 180.8,132.15 181.1,131.85 181.71,131.85 181.96,132.09 183.21,132.09 183.41,132.3 184.01,132.3 CON_XMM1.110 ; 185.35,197.09 184.08,196.9 183.43,196.9 183.21,196.68 181.89,196.68 181.65,196.44 181.11,196.44 180.81,196.74 180.21,196.74 180.05,196.89 179.39,196.89 179.24,196.75 178.72,196.75 CON_XMM3.40 ; 188.5,141.85 187.85,141.19 187.18,141.19 186.9,141.47 185.79,141.47 185.62,141.65 185.03,141.65 184.84,141.45 184.62,141.45 CON_XMM1.99 182.3,141.4 181.97,141.4 181.72,141.65 181.1,141.65 180.91,141.46 180.38,141.46 180.11,141.19 179.48,141.19 179.11,141.57 177.96,141.57 177.88,141.65 177.25,141.65 177.09,141.48 176.83,141.48 CON_XMM3.99 ; CON_XMM2.7 199.11,225.15 198.96,224.99 197.2,224.99 196.58,224.37 195.41,224.37 194.64,225.15 CON_XMM4.7 ; 188.47,225.11 187.85,224.49 187.2,224.49 186.92,224.76 185.83,224.76 185.65,224.94 185.06,224.94 184.86,224.74 184.62,224.74 CON_XMM1.7 182.3,224.69 181.93,224.69 181.68,224.94 181,224.94 180.81,224.75 180.34,224.75 180.09,224.49 179.46,224.49 179.1,224.85 177.99,224.85 177.9,224.94 177.27,224.94 177.1,224.77 176.75,224.77 CON_XMM3.7
  TOP w0.203: 190.18,214.95 188.71,214.95 187.87,215.8 CON_XMM1.18 ; 185.35,197.09 185.35,197.09 ; 185.35,197.09 CON_XMM1.40 ; 185.35,197.09 187.88,197.09 188.71,196.26 190.16,196.26 ; CON_XMM4.132 191.27,113.8 191.26,113.79 ; 191.22,123.15 CON_XMM4.121 192.47,123.06 194.82,123.06 195.58,122.3 196.72,122.3 197.49,123.06 198.63,123.06 198.71,123.15 CON_XMM2.121 ; 190.78,187.58 190.17,187.58 190,187.74 188.84,187.74 187.99,186.89 186.92,186.89 186.07,187.75 CON_XMM1.51 ; CON_XMM2.40 202.83,197.1 202.95,196.98 204.47,196.98 205.18,196.27 v1(207.44,196.27) ; 206.81,113.48 206.81,113.08 206.63,112.9 205.23,112.9 204.47,113.67 203.2,113.67 203.07,113.8 CON_XMM2.132 ; 190.16,225.11 188.47,225.11 ; CON_XMM2.51 197.4,187.75 196.6,186.94 195.62,186.94 194.82,187.75 CON_XMM4.51 192.06,187.75 191.29,188.52 ; 190.16,123.1 188.45,123.1 ; 190.14,206.41 188.46,206.41 ; CON_XMM4.40 191.45,197.1 ; 190.11,141.85 188.5,141.85 ; CON_XMM1.132 187.89,113.8 188.74,112.94 190.21,112.94 ; 190.18,131.72 188.65,131.72 187.88,132.5 CON_XMM1.110 ; CON_XMM4.18 191.34,215.8 ; 191.48,206.45 CON_XMM4.29
  TOP w0.254: v1(236.22,36.07) 236.03,36.25 231.57,36.25 O2R22.1 ; v1(141.46,157.06) 142.2,157.06 142.65,156.62 XU1.AW14 ; v1(136.53,90.07) 134.06,87.6 134.06,79.67 123.48,69.09 116.92,69.09 109.24,61.4 109.24,53.58 113.87,48.95 119.4,48.95 120.95,47.39 120.95,45.77 122.12,44.6 123.22,44.6 129.21,38.61 129.21,32.58 SR659.1 ; 207.52,131.7 204.98,131.7 204.29,132.38 203.06,132.38 202.95,132.5 CON_XMM2.110 ; 191.26,140.97 192.79,140.97 193.68,141.86 194.94,141.86 195.83,140.97 196.47,140.97 197.23,141.73 198.37,141.73 198.49,141.85 CON_XMM2.99 ; v1(208.84,75.51) 208.84,79.67 209.36,80.19 209.36,87.58 208.68,88.26 208.68,90.26 208.65,90.29 208.65,91.64 208.81,91.79 208.81,94.38 210.84,96.42 211.33,96.42 212.55,97.64 v1(212.55,98.88) ; 174.62,232.35 173.56,232.35 171.2,229.98 D4R33.1 ; CON_XMM4.110 191.23,132.5 ; CON_XMM4.99 191.4,141.85
  TOP w0.305: v1(141.44,150.3) 141.68,150.54 141.9,150.76 XU1.AW10 ; D4CB73.1 190.32,141.73 ; D4CB73.1 191.19,141.73 ; D4CB73.1 190.75,141.3 ; D4CB76.1 190.32,224.76 ; D4CB76.1 190.75,225.2 ; D4CB76.1 191.19,224.76 ; v1(140.56,165.35) 140.56,165.18 140.89,164.84 XU1.AU23 ; 191.16,150.95 D4CB77.1 ; D4CB77.1 190.73,151.38 ; D4CB77.1 190.3,150.95 ; XU1.AV17 141.89,159.36 v1(141.45,158.92) ; D4CB60.1 190.32,147.07 ; D4CB60.1 191.19,147.07 ; D4CB60.1 190.75,147.5 ; D4CB74.1 190.75,177.01 ; D4CB74.1 190.32,176.58 ; D4CB74.1 191.19,176.58 ; v1(142.37,167.13) 142.83,166.68 XU1.AW25 ; D4CB64.1 169.77,181.48 v1(169.72,181.43) ; XU1.AT21 140.5,163.44 v1(140.54,163.44) ; CON_XMM3.73 175.15,169.05 175.03,169.16 D4CB78.1 ; D4CB70.1 190.32,148.59 ; D4CB70.1 190.75,148.16 ; D4CB70.1 191.19,148.59 ; v1(142.61,162.95) 142.54,163.02 XU1.AV21 ; D4CB72.1 190.35,131.83 ; D4CB72.1 190.78,132.26 ; D4CB72.1 191.21,131.83 ; v1(144.51,154.64) 144.37,154.79 XU1.AY12 ; XU1.AY16 144.34,158.44 v1(144.4,158.51) ; 191.41,180.8 D4CB62.1 190.53,180.8 189.82,180.1 CON_XMM1.204 ; XU1.AY18 144.26,160.27 v1(144.37,160.16) ; XU1.AU15 141.46,157.07 v1(141.46,157.06) ; XU1.AV11 141.91,153.25 141.93,153.24 v1(141.94,153.24) ; 190.78,188.32 190.78,187.58 ; v1(140.56,161.63) XU1.AU19 ; XU1.AY23 144.29,164.84 v1(144.37,164.77) ; v1(140.54,159.8) 140.54,159.82 XU1.AT18 ; XU1.AU13 v1(141.46,156.16)
  TOP w0.381: 190.75,156.1 D4CB21.1 ; D4CB21.1 189.98,155.54 ; D4CB21.1 191.53,155.54 ; 190.22,197.52 D4CB50.1 ; D4CB50.1 190.75,198.03 ; D4CB50.1 191.29,197.52 ; D4CB52.1 190.75,215.89 ; D4CB52.1 190.22,215.38 ; D4CB52.1 191.29,215.38 ; 191.36,178.98 D4CB55.1 190.36,178.98 ; 190.22,162.34 D4R15.1 191.29,162.34 ; D4CB54.1 190.75,171.36 ; D4CB54.1 191.29,170.85 ; D4CB54.1 190.22,170.85 ; 190.63,153.23 D4CB20.1 ; D4CB20.1 190.09,153.73 ; D4CB20.1 191.16,153.73 ; 190.75,160.95 D4R10.1 ; D4R10.1 190.22,160.44 ; D4R10.1 191.29,160.44 ; 191.29,206.92 D4CB53.1 ; D4CB53.1 190.75,207.43 ; D4CB53.1 190.22,206.92 ; 190.22,157.87 D4R1.1 ; v1(173.61,185.55) 172.93,184.87 D4CB19.1
  TOP w0.432: 211.57,155.49 PR125.1
  TOP w0.457: 165.12,179.56 v1(165.69,180.13) ; D4CB34.1 159.59,173.96 v1(159.95,173.96) ; 190.88,225.88 190.88,226.9 191.54,227.56 v1(191.54,231.52) ; 206.13,160.77 D4R24.1 206.88,161.28 ; 167.89,182.1 167.88,182.1 v1(167.26,181.48) ; CON_XMM3.83 174.51,155.45 D4CB67.1 ; PC150.1 133.99,102.83 ; PC150.1 134.71,102.27 ; PC150.1 133.26,102.27 ; CON_XMM3.59 175.54,180.95 175.01,181.48 D4CB66.1 ; RFC108.1 190.53,137.97 ; CON_XMM3.67 175.95,174.12 D4CB27.1
  TOP w0.508: D4CB40.1 164.47,178.63 v1(164.47,178.94) ; v1(167,160.78) 167.39,160.78 167.73,161.12 D4CB28.1 D4CB31.1 170.3,161.12 D4CB51.1 ; D4R21.1 206.88,231.52 v1(206.91,231.5) ; v1(191.54,231.52) 191.26,231.8 181.2,231.8 180.66,232.35 174.62,232.35 ; v1(172.34,183.13) 171.7,183.13 PC6523.1 ; D4CB26.1 166.59,180.81 v1(167.26,181.48) ; v1(162.73,176.72) D4CB63.1 ; 191.58,174.84 D4CB29.1 190.8,174.28 ; PR9.1 v1(209.93,210.72) ; 191.49,225.15 CON_XMM4.7 ; v1(161.33,175.32) D4CB71.1
  TOP w0.635: CON_XMM2.217 203.96,169.73 ; CON_XMM2.217 203.27,169.05 ; CON_XMM2.217 204.64,169.05 ; CON_XMM2.217 203.96,168.36 ; CON_XMM4.92 193.98,148.48 ; CON_XMM4.92 193.98,147.03 ; CON_XMM4.92 194.67,147.8 ; CON_XMM4.92 193.22,147.8 ; CON_XMM2.85 200.16,152.98 ; CON_XMM2.85 200.16,154.43 ; CON_XMM2.85 199.47,153.75 ; CON_XMM2.85 200.84,153.75 ; CON_XMM2.204 205.56,179.41 ; CON_XMM2.204 206.24,180.1 ; CON_XMM2.204 205.56,180.78 ; CON_XMM2.204 204.87,180.1 ; CON_XMM4.80 193.98,158.68 ; CON_XMM4.80 193.22,158 ; CON_XMM4.80 194.67,158 ; CON_XMM4.80 193.98,157.23 ; CON_XMM4.223 195.42,158.84 ; CON_XMM4.223 196.18,158.08 ; CON_XMM4.223 196.87,158.84 ; CON_XMM4.223 196.18,159.53 ; 205.56,177.71 CON_XMM2.206 ; CON_XMM2.206 205.56,179.08 ; CON_XMM2.206 204.87,178.4 ; 191.7,180.95 CON_XMM4.59 ; CON_XMM4.59 193.07,180.95 ; CON_XMM4.59 192.38,180.26 ; CON_XMM2.231 204.64,152.05 ; CON_XMM2.231 203.19,152.05 ; CON_XMM2.231 203.96,151.28 ; CON_XMM2.231 203.96,152.73 ; 192.38,173.46 CON_XMM4.67 ; CON_XMM4.67 191.7,174.15 ; CON_XMM4.67 192.38,174.83 ; CON_XMM4.67 193.07,174.15 ; CON_XMM4.83 193.07,155.45 ; CON_XMM4.83 192.38,156.13 ; CON_XMM4.83 192.38,154.68 ; 201.07,176.7 CON_XMM2.64 ; CON_XMM2.64 202.44,176.7 ; CON_XMM2.64 201.76,176.01 ; CON_XMM2.64 201.76,177.38 ; 202.44,171.6 CON_XMM2.70 ; CON_XMM2.70 201.76,170.91 ; CON_XMM2.70 201.76,172.28 ; CON_XMM2.70 201.07,171.6 ; 218.91,178.18 217.75,177.02 PL652.2 ; CON_XMM4.70 194.67,171.6 ; CON_XMM4.70 193.98,172.28 ; CON_XMM4.70 193.3,171.6 ; CON_XMM4.70 193.98,170.91 ; 203.96,158.16 CON_XMM2.223 ; CON_XMM2.223 204.64,158.84 ; CON_XMM2.223 203.19,158.84 ; 196.18,152.81 CON_XMM4.231 ; CON_XMM4.231 196.18,151.28 ; CON_XMM4.231 195.5,152.05 ; CON_XMM4.231 196.87,152.05 ; CON_XMM2.236 204.87,147.8 ; CON_XMM2.236 205.56,147.03 ; CON_XMM2.236 205.56,148.56 ; CON_XMM4.88 193.3,151.2 ; CON_XMM4.88 194.67,151.2 ; CON_XMM4.88 193.98,150.43 ; CON_XMM4.88 193.98,151.96 ; 195.5,169.05 CON_XMM4.217 ; CON_XMM4.217 196.87,169.05 ; CON_XMM4.217 196.18,169.73 ; CON_XMM4.217 196.18,168.36 ; 193.3,176.7 CON_XMM4.64 ; CON_XMM4.64 194.67,176.7 ; CON_XMM4.64 193.98,177.38 ; CON_XMM4.64 193.98,176.01 ; CON_XMM4.85 192.38,154.43 ; CON_XMM4.85 192.38,152.98 ; CON_XMM4.85 193.07,153.75 ; CON_XMM4.85 191.62,153.75 ; PCE653.1 216.87,170.23 ; PCE653.1 214.99,168.35 ; PCE653.1 216.87,168.35 ; CON_XMM4.229 195.5,153.75 ; CON_XMM4.229 196.18,152.98 ; CON_XMM4.229 196.87,153.75 ; CON_XMM4.229 196.18,154.51 ; 203.27,175.85 CON_XMM2.209 ; CON_XMM2.209 203.96,175.16 ; CON_XMM2.209 203.96,176.53 ; CON_XMM2.209 204.64,175.85 ; CON_XMM4.226 197.02,156.3 ; CON_XMM4.226 198.47,156.3 ; CON_XMM4.226 197.78,156.98 ; CON_XMM4.226 197.78,155.53 ; CON_XMM2.83 200.84,155.45 ; CON_XMM2.83 200.16,156.13 ; CON_XMM2.83 200.16,154.68 ; CON_XMM2.83 199.47,155.45 ; 192.38,178.56 CON_XMM4.61 ; CON_XMM4.61 193.07,179.25 ; CON_XMM4.61 192.38,179.93 ; CON_XMM2.229 203.96,154.43 ; CON_XMM2.229 204.64,153.75 ; CON_XMM2.229 203.96,152.98 ; CON_XMM2.229 203.19,153.75 ; 193.98,148.73 CON_XMM4.90 ; CON_XMM4.90 194.67,149.5 ; CON_XMM4.90 193.98,150.18 ; CON_XMM4.90 193.22,149.5 ; CON_XMM2.226 205.56,155.53 ; CON_XMM2.226 204.87,156.3 ; CON_XMM2.226 205.56,157.06 ; 204.87,173.3 CON_XMM2.212 ; CON_XMM2.212 206.24,173.3 ; CON_XMM2.212 205.56,173.98 ; CON_XMM2.212 205.56,172.61 ; 200.16,168.36 CON_XMM2.73 ; CON_XMM2.73 200.84,169.05 ; CON_XMM2.73 200.16,169.73 ; CON_XMM2.73 199.47,169.05 ; 189.15,180.78 CON_XMM1.204 ; CON_XMM2.233 203.96,149.66 ; CON_XMM2.233 203.96,151.11 ; CON_XMM2.233 203.19,150.35 ; CON_XMM2.233 204.64,150.35 ; CON_XMM2.92 202.44,147.8 ; CON_XMM2.92 201.76,148.48 ; CON_XMM2.92 200.99,147.8 ; CON_XMM2.92 201.76,147.03 ; CON_XMM4.73 192.38,169.73 ; CON_XMM4.73 192.38,168.36 ; CON_XMM4.73 191.7,169.05 ; CON_XMM4.73 193.07,169.05 ; 197.78,177.71 CON_XMM4.206 ; CON_XMM4.206 197.78,179.08 ; CON_XMM4.206 197.1,178.4 ; CON_XMM4.206 198.47,178.4 ; 195.5,170.75 CON_XMM4.215 ; CON_XMM4.215 196.18,170.06 ; CON_XMM4.215 196.18,171.43 ; CON_XMM4.215 196.87,170.75 ; 203.27,170.75 CON_XMM2.215 ; CON_XMM2.215 203.96,170.06 ; CON_XMM2.215 203.96,171.43 ; CON_XMM2.215 204.64,170.75 ; 200.84,179.25 CON_XMM2.61 ; CON_XMM2.61 200.16,179.93 ; CON_XMM2.61 199.47,179.25 ; CON_XMM2.61 200.16,178.56 ; PL652.2 217.76,177.01 219.23,175.55 ; PL652.2 216.51,175.77 ; PL652.2 216.15,178.62 ; 197.78,172.61 CON_XMM4.212 ; CON_XMM4.212 197.78,173.98 ; CON_XMM4.212 197.1,173.3 ; CON_XMM4.212 198.47,173.3 ; CON_XMM2.220 206.24,166.5 ; CON_XMM2.220 204.87,166.5 ; CON_XMM2.220 205.56,165.81 ; CON_XMM2.220 205.56,167.18 ; CON_XMM2.67 200.16,174.83 ; CON_XMM2.67 200.16,173.46 ; CON_XMM2.67 199.47,174.15 ; CON_XMM2.67 200.84,174.15 ; 201.76,157.23 CON_XMM2.80 ; CON_XMM2.80 201.76,158.68 ; CON_XMM2.80 202.44,158 ; CON_XMM2.80 200.99,158 ; CON_XMM4.209 196.18,175.16 ; CON_XMM4.209 196.87,175.85 ; CON_XMM4.209 195.5,175.85 ; CON_XMM4.209 196.18,176.53 ; CON_XMM2.90 201.76,150.18 ; CON_XMM2.90 201.76,148.73 ; CON_XMM2.90 200.99,149.5 ; CON_XMM2.90 202.44,149.5 ; 200.16,180.26 CON_XMM2.59 200.84,180.95 ; CON_XMM4.236 197.78,148.48 ; CON_XMM4.236 198.47,147.8 ; CON_XMM4.236 197.02,147.8 ; CON_XMM4.236 197.78,147.03 ; 196.18,151.03 CON_XMM4.233 ; CON_XMM4.233 196.18,149.58 ; CON_XMM4.233 195.42,150.35 ; CON_XMM4.233 196.87,150.35 ; CON_XMM2.88 202.44,151.2 ; CON_XMM2.88 201.07,151.2 ; CON_XMM2.88 201.76,150.43 ; CON_XMM2.88 201.76,151.96 ; CON_XMM4.204 198.47,180.1 ; CON_XMM4.204 197.78,179.41 ; CON_XMM4.204 197.1,180.1
  TOP w0.762: 215.52,161.34 215.52,158.25 214.71,157.43 212.8,157.43 212.18,156.81 PC483.1
  TOP w0.889: PCE652.1 218.01,162.68 ; PCE652.1 218.01,160.8 ; PCE652.1 217.07,161.74
  TOP w2.032: 207.52,118.11 207.52,141.48
  IN1 w0.102: CON_XMM4.18 195.53,215.8 195.73,216 196.45,216 197.3,216.85 198.46,216.85 198.68,217.07 199.39,217.07 199.67,217.35 200.66,217.35 200.89,217.12 200.89,216.66 CON_XMM2.18
  BOTTOM w0.254: 207.86,102.15 208.61,101.4 210.45,101.4 212.55,99.3 v1(212.55,98.88) ; v1(139.47,97.23) 138.8,96.56 138.8,93.8 136.53,91.53 v1(136.53,90.07) ; v1(236.22,36.07) 235.98,36.31 235.98,37.19 234.24,38.93 234.24,60.14 232.18,62.19 232.18,62.84 227.71,67.31 226.64,67.31 223.32,70.64 217.04,70.64 214.58,73.1 211.6,73.1 209.19,75.51 v1(208.84,75.51)
  BOTTOM w0.508: v1(191.54,231.52) 191.57,231.5 v1(206.91,231.5) 206.91,231.34 209.25,229.01 209.25,227.86 211.24,225.87 211.24,219.37 209.8,217.93 209.8,215.39 210.31,214.88 210.31,211.1 v1(209.93,210.72) 209.93,209.93 207.44,207.44 v1(207.44,196.27) 207.44,184.71 206.98,184.25 206.98,181.52 CON_XMM2.204 ; 207.86,102.15 207.86,113.22 v1(207.9,113.26)
  BOTTOM w0.635: PCE653.1 214.9,170.31 ; PCE653.1 214.9,168.26 ; PCE653.1 216.95,170.31 ; PCE653.1 216.95,168.26 ; PL652.2 217.71,177.01 216.26,178.46 ; PL652.2 217.97,174.44 ; PL652.2 220.32,176.76 ; 216.98,160.71 PCE652.1 ; PCE652.1 219.04,160.71 ; PCE652.1 219.04,162.77 ; PCE652.1 216.98,162.77
  vias: v1(139.83,152.4) v1(140.44,152.17) v1(140.97,151.82) v1(207.52,143.64) v1(207.52,142.88) v1(207.9,115.54) v1(207.9,114.78) v1(207.9,114.02) v1(208.33,170.54) v1(208.33,142.16) v1(208.31,141.35) v1(209.09,170.03) v1(209.57,170.62) v1(210.29,163.27) v1(210.34,161.9) v1(210.82,169.98) v1(211.07,163.27) v1(211.18,161.93) v1(211.3,170.56) v1(212.09,170.59) v1(212.06,169.75) v1(212.45,162.15) v1(212.55,163.3) v1(213.26,162.13) v1(213.51,163.3) v1(216.53,166.17) v1(216.59,165.25) v1(216.64,164.44) v1(216.61,163.6) v2(213.79,160.88) v3(142.77,103.48) v3(143.48,100.3) v3(143.69,103.5) v3(164.97,101.85) v3(165.86,101.85) v3(166.75,101.85)
+1P2V_DUAL__FB: length 6
  TOP w0.254: PU651.6 215.33,222.33 v1(215.98,222.98) 216.88,223.88 PC640664.1 PR70222.2 217.04,224.98 PR70223.1
  BOTTOM w0.102: v1(215.98,222.98) 215.98,222.36 v2(215.8,222.17)
+1P2V_DUAL__LG_D: length 0.8
  BOTTOM w0.102: v2(215.6,215.72) v1(214.81,215.72)
+1P2V_DUAL__LX_D: length 37.7
  TOP w0.635: PL652.1 212.89,184.85 ; PL652.1 210.02,181.98 ; PL652.1 210.02,184.85 ; PL652.1 212.89,181.98
  BOTTOM w0.635: PQ652.12 212.72,199.03 212.72,207.87 212.14,208.46 212.14,214.6 212.72,215.19 v2(212.72,216.36) 212.72,217.45 v1(212.85,217.58) ; 209.93,181.89 PL652.1 ; PL652.1 212.98,184.94 ; PL652.1 212.98,181.89 ; PL652.1 209.93,184.94
  vias: v3(214.27,186.06) v3(214.3,181.71) v3(214.91,192.35) v3(216.18,184.05) v3(217.47,181.99) v3(217.63,192.41) v3(218.85,185.06)
+1P2V_DUAL__REFOUT: length 4.5
  TOP w0.254: PU651.10 212.36,222.9 212.51,223.05 PC640653.1 212.51,224.28 v1(211.96,224.83) 211.67,225.12 PR70211.1
  BOTTOM w0.102: v1(211.96,224.83) 212.14,225.02 v2(212.14,225.6)
+1P2V_DUAL__UG_D: length 21.3
  TOP w0.635: PR70210.1 220.65,201.5 v1(220.19,201.96)
  BOTTOM w0.635: v1(220.19,201.96) 220.19,208.43 v2(218.61,210.02) 213.87,214.76 213.87,218.44 213.48,218.83 v1(212.8,218.83)
+1P2V_DUAL__VCC_C: length 0.8
  BOTTOM w0.102: v2(216.23,219.18) v1(215.42,219.18)
+1P2V_DUAL_BOOT_D: length 0.9
  BOTTOM w0.102: v2(211.96,219.02) 211.68,218.74 v1(211.68,218.26)
+1P2V_DUAL_BOOTR_D: length 0.8
  BOTTOM w0.102: v2(210.54,216.51) v1(210.54,215.75)
+1P2V_DUAL_DAC_A: length 5.2
  TOP w0.102: PR70213.2 211.31,227.69 211.16,227.55 PR70225.1 ; PR70213.2 211.73,226.62 PR70224.1 211.39,226.62 211.25,226.48 PR70217.1 ; PR70213.2 211.73,229.01 v1(211.67,229.07)
  BOTTOM w0.102: v2(212.26,229.65) v1(211.67,229.07)
+1P2V_DUAL_DISCHARGE: length 7.3
  TOP w0.102: v1(209.55,213.36) 209.55,213 208.99,212.45 PR9.2 208.36,212.45 207.82,212.98 207.82,215.06 208.65,215.88 MQ24.6
  BOTTOM w0.102: v2(209.55,212.55) v1(209.55,213.36)
+1P2V_DUAL_EN_A: length 7.8
  TOP w0.102: PU651.7 213.86,222.62 214.38,223.14 v1(214.92,223.14) PC640671.1 216.25,223.87 216.41,224.03 216.41,226.36 216.03,226.75 PR11.2
  BOTTOM w0.102: v1(214.92,223.14) 214.56,222.78 v2(214.12,222.78)
+1P2V_DUAL_FB_C_B: length 64.3
  TOP w0.254: PJP652.2 v1(214.8,171.44) ; PR70260.2 218.35,226.61 218.4,226.66 PC6527.1 220.09,225.64 v1(220.09,223.75)
  BOTTOM w0.254: v1(214.8,171.44) 214.8,178.82 215.71,179.73 220.24,179.73 220.9,180.39 220.9,187.09 220.9,189.81 221.79,190.7 221.79,191.66 221.79,209.06 219.76,211.09 v2(219.76,222.07) 219.76,223.42 v1(220.09,223.75)
+1P2V_DUAL_FB_R_B: length 3.6
  TOP w0.254: PR70260.1 217.96,225.06 PR70222.1 PC640664.2 v1(217.72,223.14)
  BOTTOM w0.102: v2(217.72,222.26) v1(217.72,223.14)
+1P2V_DUAL_LG_R_D: length 32.4
  TOP w0.635: PR70220.2 213.78,214.81 213.73,214.76 v1(211.18,214.76)
  BOTTOM w0.635: v1(211.18,214.76) 211.18,208.15 211.96,207.37 211.96,193.07 v3(212.17,192.86) 212.24,192.79 v2(212.24,190.35) 212.24,186.85 v3(212.57,186.53)
+1P2V_DUAL_REFIN: length 6.6
  TOP w0.254: PR70224.2 213.06,225.74 212.9,225.58 PR70211.2 212.51,225.09 v1(212.76,224.85) 213.05,224.56 213.05,224.53 PC640661.1 213.16,223.56 213.16,223.09 212.86,222.79 PU651.9
  BOTTOM w0.102: v1(212.76,224.85) 212.94,224.66 v2(213.79,224.66)
+1P2V_DUAL_UG_R_D: length 0.8
  BOTTOM w0.102: v2(219.56,199.36) v1(219.56,200.18)
+1P2V_FB: length 6.4
  TOP w0.254: v1(46.84,226.24) 46.71,226.24 46.02,226.92 PR6807.2 46.04,227.61 PR6809.1 PC6809.2 44.75,228.33 PU681.7
  BOTTOM w0.508: v1(46.84,226.24) 46.84,225.45 v2(46.79,225.4)
+1P2V_FB_R: length 3.8
  TOP w0.254: v1(45,225.34) 44.51,225.83 PR6806.2 44.51,226.06 PR6807.1 44.51,227.39 44.36,227.55 PC6809.1
  BOTTOM w0.508: v1(45,225.34) 45,225.94 v2(44.75,226.19)
+1P2V_SUS: length 133.8
  TOP w0.254: U4.21 38.52,149.74 38.25,150 38.25,150.57 38.35,150.67 UC72.1 38.35,151.26 ; PR6806.1 45.57,225.79 45.57,225.13 45.23,224.79 44.78,224.79 43.92,225.65 43.92,227.02 43.64,227.3 ; v1(36.77,155.45) v1(34.98,155.45)
  TOP w0.279: v1(34.67,147.85) 33.32,147.85 33.1,147.63 U4.34
  TOP w0.305: 38.35,151.26 38.35,152.04 37.72,152.68 v1(37.72,152.83)
  TOP w0.508: v1(31.72,166.85) 30.89,166.85 26.72,162.69 v1(21.74,162.69) ; v1(27.51,223.88) v1(27.51,226.03)
  BOTTOM w0.254: v1(34.67,147.85) 34.67,149.62 35.01,149.96 35.01,155.41 v1(34.98,155.45)
  BOTTOM w0.508: v1(27.51,226.03) 27.51,226.87 28.8,228.17 v2(29.92,228.17) 33.81,228.17 34.39,227.58 v1(38.73,227.58) ; v1(27.51,223.88) 27.51,223.7 27.66,223.55 27.66,221.59 27.58,221.51 27.58,219.15 28.5,218.24 29.26,218.24 29.77,217.73 29.77,216.76 30.63,215.9 30.63,213.01 31.71,211.93 32.06,211.93 32.89,211.1 32.89,207.31 33.53,206.68 33.53,201.04 28.85,196.37 28.85,191.59 25.37,188.11 25.37,180.64 24.87,180.14 24.87,177.47 23.93,176.53 23.93,168.68 21.79,166.54 21.79,162.73 v1(21.74,162.69) ; v1(37.72,152.83) 36.77,153.78 v1(36.77,155.45) 36.77,157.23 34.57,159.43 34.57,160.93 31.72,163.77 v1(31.72,166.85)
+1P2V_SUS_CRT_MAIN_R: length 5.5
  TOP w0.102: PQ9784.1 38.29,228.91 38.78,229.4 v1(38.78,229.5) 38.35,229.92 PR136.1 38.77,230.26 38.98,230.47 PC640675.1 PR70254.2
  BOTTOM w0.102: v1(38.78,229.5) v2(38.78,230.26)
+1P2V_VDD: length 4.6
  TOP w0.508: PU681.4 42.21,236.07 42.13,236.16 PC6810.1 42.13,237.49 PR6810.2 41.54,238.07 v1(41.2,238.07)
  BOTTOM w0.508: v1(41.2,238.07) v2(42.21,238.07)
+1P05_SA_BOOT_D: length 0.9
  BOTTOM w0.254: v1(70.46,119.08) v2(69.57,119.08)
+1P05_SA_BOOTR_D: length 0.8
  BOTTOM w0.102: v2(75.01,122.25) 75.01,122.05 v1(74.61,121.65)
+1P05_SA_DAC_A: length 4.4
  TOP w0.254: PR70188.1 PR70201.2 ; PR70188.1 62.4,119.09 v1(62.48,119) 62.48,118.33 PR70196.2 ; PR70188.1 62.43,119.72 PR70207.1
  BOTTOM w0.102: v2(62.03,119.61) 62.03,119.46 v1(62.48,119)
+1P05_SA_EN_A: length 6.8
  TOP w0.254: PR70189.1 63.75,123.42 64.06,123.72 66.01,123.72 66.23,123.51 PC640672.2 66.8,123.04 v1(66.99,122.85) 67.01,122.83 67.01,122.66 67.5,122.17 PU10.7
  BOTTOM w0.102: v2(67.32,122.11) 66.99,122.44 v1(66.99,122.85)
+1P05_SA_FB: length 5.6
  TOP w0.254: PU10.6 67.82,122.67 67.56,122.92 67.56,124.21 v1(67.69,124.33) PR70206.1 PC640648.1 PR70205.2
  BOTTOM w0.102: v1(67.69,124.33) 68.3,123.72 v2(68.4,123.72)
+1P05_SA_FB_C_B: length 36.6
  TOP w0.254: PR70261.2 PR317.1 63.12,125.06 PC640674.1 63.19,124.23 v1(63.7,124.23)
  BOTTOM w0.254: PJP17.2 83.97,130.19 73.09,119.3 71.56,119.3 70.76,120.1 67.88,120.1 66.4,121.59 66.4,123.34 v2(64.9,124.84) 64.31,124.84 v1(63.7,124.23)
+1P05_SA_FB_R_B: length 3.7
  TOP w0.254: v1(64.41,126.7) 64.74,126.36 PR70261.1 PR70205.1 PC640648.2
  BOTTOM w0.102: v1(64.41,126.7) v2(65.2,126.7)
+1P05_SA_LG_D: length 4.2
  TOP w0.254: PU10.4 71.42,122.17
  TOP w0.635: 71.42,122.17 v1(71.78,122.17) 72.13,122.52 PR70190.1 73.27,122.52 PR70203.1
  BOTTOM w0.102: v1(71.78,122.17) 72.32,122.7 v2(72.32,122.7)
+1P05_SA_LG_R_D: length 26.2
  TOP w0.635: PR70203.2 75.41,123.98 v3(74.93,124.46)
  BOTTOM w0.635: v3(74.93,124.46) 74.93,125.22 74.23,125.92 72.66,125.92 68.07,130.51 68.07,135.13 69.6,136.65 71.91,136.65 v3(72.24,136.98) 72.69,136.53 v2(76.15,136.53) 77.06,136.53 v3(77.17,136.63)
+1P05_SA_LX_D: length 15.7
  BOTTOM w0.635: v3(72.71,120.46) 72.71,121.23 74.63,123.14 75.59,123.14 76.07,123.62 76.07,125.73 74.8,127 73.1,127 70.18,129.92 70.18,130.76
  vias: v2(71.91,131.06) v3(70.1,132.03) v3(70.36,134.24) v3(73.3,134.14) v3(73.71,128.19) v3(74.24,132.56) v3(76.33,134.16) v3(76.43,131.17) v3(76.45,128.12)
+1P05_SA_REFIN: length 5.6
  TOP w0.254: PR70207.2 PR70194.2 v1(65.24,120.56) 66.24,120.56 PC640644.1 66.85,121.17 PU10.9
  BOTTOM w0.102: v2(65.99,120.85) 65.7,120.56 v1(65.24,120.56)
+1P05_SA_REFOUT: length 4.7
  TOP w0.254: PU10.10 67.45,120.67 66.71,119.93 PC640637.1 65.48,119.93 v1(65.28,119.72) PR70194.1
  BOTTOM w0.102: v1(65.28,119.72) v2(65.28,118.85)
+1P05_SA_SN: length 1
  BOTTOM w0.102: v1(69.14,133.93) 69.14,133.1 v2(69.01,132.97)
+1P05_SA_UG_D: length 8.5
  TOP w0.635: v3(69.55,127.03) 69.95,126.62 PR70193.1
  BOTTOM w0.635: v3(71.45,120.85) 70.61,121.69 70.61,125.15 v2(70.15,125.6) 69.55,126.21 v3(69.55,127.03)
+1P05_SA_UG_R_D: length 0.9
  BOTTOM w0.102: v1(69.49,127.94) v2(68.61,127.94)
+1P05_SA_VCC_C: length 4.7
  TOP w0.254: PU10.5 70.88,122.67 70.97,122.76
  TOP w0.508: 70.97,122.76 71.17,122.96 PC640649.1 71.86,124.56 v1(71.98,124.43) PR70202.2
  BOTTOM w0.102: v2(72.75,124.43) v1(71.98,124.43)
+1P05V_SA: length 9.4
  TOP w0.889: 93.01,143.78 PCE13.1 ; PCE13.1 92.08,142.84 ; PCE13.1 91.14,143.78 ; PCE12.1 82.96,136.62 ; PCE12.1 84.84,136.62 ; PCE12.1 83.9,135.68
  IN1 w0.102: 112.65,157.84 112.65,157.33
  IN1 w0.127: 114.48,157.86 114.48,157.35 ; 109.91,156.04 109.91,155.56 ; 111.69,152.34 111.74,151.81 ; 112.67,159.72 112.67,159.13 ; 111.69,154.12 111.69,153.69 ; 112.66,155.93 112.66,155.57 ; 111.74,155.94 111.74,155.59
  vias: v1(117.7,148.45) v1(118.57,148.46) v1(119.51,148.47) v1(120.43,148.47) v1(121.36,148.47) v1(122.25,148.47) v1(123.17,148.47) v1(123.17,147.56) v1(126.03,156.36) v1(126.03,155.7) v1(126.06,155.02) v1(126.06,154.38) v1(126.06,153.64) v1(126.06,153.01) v1(126.09,152.32) v1(126.09,151.69) v1(126.78,153.56) v1(126.8,152.92) v1(126.77,152.27) v1(126.92,156.39) v1(126.92,155.7) v1(126.92,155.07) v1(126.92,154.43) v3(80.26,133.6) v3(81.97,129.41) v3(82.12,135.48) v3(82.09,132.36) v3(84.99,135.08) v3(85.06,132.11) v3(91.9,137.24) v3(91.9,136.35) v3(91.9,135.46) v3(91.9,134.57) v3(92.94,138.1) v3(92.94,137.11)
+2P5_VPP_FB: length 6.5
  TOP w0.254: v1(214.45,129.74) 213.99,130.19 213.99,130.37 ; PU7.6 212.84,127.19 212.43,127.6 212.43,128.16 PC122.1 PR6608.2 212.81,129.54 212.98,129.71 PR6609.1 213.99,130.37 ; 213.99,130.37 PR6611.1
  BOTTOM w0.102: v1(214.45,129.74) v2(214.99,129.2)
+2P5_VPP_FB_C: length 19.9
  TOP w0.254: PR6608.1 PC122.2 213.65,127.72 213.92,127.46 215.23,127.46 216.03,126.66 v1(216.03,125.07) 216.03,123.83 215.87,123.67 215.87,113.01 PJP25.1
  BOTTOM w0.102: v1(216.03,125.07) 216.48,125.53 v2(216.48,125.78)
+2P5_VPP_SW: length 1
  BOTTOM w0.102: v2(211.1,123.37) 210.77,123.04 v1(210.26,123.04)
+2P5V_VPP: length 94.6
  TOP w0.635: 186.11,105.3 CON_XMM1.142 185.35,104.53 ; 180.84,104.13 CON_XMM3.288 ; CON_XMM3.288 180.84,103.06 ; CON_XMM3.288 181.91,103.06 ; CON_XMM3.288 181.91,104.13 ; CON_XMM2.287 204.49,104.98 ; CON_XMM2.287 203.42,103.91 ; CON_XMM2.287 203.42,104.98 ; CON_XMM2.287 204.49,103.91 ; 201.22,104.76 CON_XMM2.142 202.29,104.76 ; 192.92,103.91 CON_XMM4.143 191.85,103.91 ; 179.24,104.98 CON_XMM3.287 ; CON_XMM3.287 180.31,104.98 ; CON_XMM3.287 179.24,103.91 ; CON_XMM3.287 180.31,103.91 ; CON_XMM2.143 200.69,103.91 ; CON_XMM4.286 197.02,105.3 ; CON_XMM4.286 198.55,105.3 ; CON_XMM4.286 197.78,104.53 ; 187.01,104.98 CON_XMM1.287 ; CON_XMM1.287 188.09,103.91 ; CON_XMM1.287 187.01,103.91 ; 193.45,104.76 CON_XMM4.142 194.52,104.76 ; 206.22,104.65 205.57,105.3 CON_XMM2.286 205.55,105.3 204.95,104.7 ; 206.09,103.06 CON_XMM2.288 ; CON_XMM2.288 205.02,104.13 ; CON_XMM2.288 205.02,103.06 ; CON_XMM2.288 206.09,104.13 ; 182.14,105.3 CON_XMM3.286 ; CON_XMM3.286 181.38,104.53 ; CON_XMM3.286 180.62,105.3 ; CON_XMM1.143 182.99,104.45 ; CON_XMM1.143 184.51,104.45 ; CON_XMM1.143 183.75,103.68 ; 177.58,104.53 CON_XMM3.142 178.34,105.3 ; 175.98,103.68 CON_XMM3.143 176.74,104.45 ; CON_XMM4.288 197.25,104.13 ; CON_XMM4.288 198.32,104.13 ; CON_XMM4.288 198.32,103.06 ; CON_XMM4.288 197.25,103.06 ; 195.65,104.98 CON_XMM4.287 ; CON_XMM4.287 195.65,103.91 ; CON_XMM4.287 196.72,104.98 ; CON_XMM4.287 196.72,103.91
  BOTTOM w0.635: CON_XMM3.286 181.38,104.53 ; CON_XMM3.286 182.14,105.3 ; CON_XMM3.286 180.62,105.3 ; 204.72,104.45 CON_XMM2.287 ; CON_XMM2.287 203.96,105.21 ; CON_XMM2.287 203.96,103.68 ; CON_XMM2.287 203.19,104.45 ; CON_XMM4.142 193.98,106.06 ; CON_XMM4.142 194.75,105.3 ; CON_XMM4.142 193.98,104.53 ; CON_XMM4.142 193.22,105.3 ; CON_XMM2.288 204.79,103.6 ; CON_XMM2.288 205.56,102.83 ; CON_XMM2.288 205.56,104.36 ; CON_XMM3.287 179.78,103.68 ; CON_XMM3.287 179.78,105.21 ; CON_XMM3.287 179.02,104.45 ; CON_XMM3.287 180.54,104.45 ; CON_XMM3.143 175.22,104.45 ; CON_XMM3.143 176.74,104.45 ; CON_XMM3.143 175.98,105.21 ; CON_XMM3.143 175.98,103.68 ; CON_XMM1.286 188.39,105.3 ; CON_XMM1.286 189.15,104.53 ; CON_XMM1.286 189.15,106.06 ; 198.55,103.6 CON_XMM4.288 ; CON_XMM4.288 197.78,104.36 ; CON_XMM4.288 197.02,103.6 ; CON_XMM4.288 197.78,102.83 ; CON_XMM1.142 185.35,104.53 ; CON_XMM1.142 186.11,105.3 ; CON_XMM1.142 184.59,105.3 ; CON_XMM2.142 200.99,105.3 ; CON_XMM2.142 201.76,104.53 ; CON_XMM2.142 202.52,105.3 ; CON_XMM2.142 201.76,106.06 ; CON_XMM3.142 177.58,104.53 ; CON_XMM3.142 178.34,105.3 ; CON_XMM3.142 176.82,105.3 ; CON_XMM4.287 196.18,105.21 ; CON_XMM4.287 195.42,104.45 ; CON_XMM4.287 196.18,103.68 ; CON_XMM4.287 196.95,104.45 ; CON_XMM1.287 187.55,105.21 ; CON_XMM1.287 188.31,104.45 ; CON_XMM1.287 187.55,103.68 ; CON_XMM1.287 186.79,104.45 ; CON_XMM3.288 180.62,103.6 ; CON_XMM3.288 181.38,102.83 ; CON_XMM3.288 182.14,103.6 ; CON_XMM3.288 181.38,104.36 ; 204.79,105.3 CON_XMM2.286 205.56,104.53 ; CON_XMM1.143 183.75,103.68 ; CON_XMM1.143 184.51,104.45 ; CON_XMM1.143 182.99,104.45 ; CON_XMM1.143 183.75,105.21 ; CON_XMM4.143 192.38,103.68 ; CON_XMM4.143 192.38,105.21 ; CON_XMM4.143 191.62,104.45 ; CON_XMM4.143 193.15,104.45 ; CON_XMM2.143 200.16,103.68 ; CON_XMM2.143 200.92,104.45 ; CON_XMM2.143 200.16,105.21 ; CON_XMM2.143 199.39,104.45 ; CON_XMM1.288 189.15,104.36 ; CON_XMM1.288 189.91,103.6 ; CON_XMM1.288 189.15,102.83 ; CON_XMM1.288 188.39,103.6 ; CON_XMM4.286 197.78,104.53 ; CON_XMM4.286 197.02,105.3 ; CON_XMM4.286 198.55,105.3 ; CON_XMM4.286 197.78,106.06
  vias: v1(188.09,103) v1(192.94,103) v1(204.09,103.25) v3(209.68,104.14) v3(210.57,105.03) v3(211.2,109.98) v3(211.58,111.25)
+3P3V: length 976.9
  TOP w0.178: 208.87,23.26 209.43,23.83 210,23.83 210.14,23.96 U104.4
  TOP w0.254: SR166.1 94.42,96.93 94.42,95.38 92.76,93.72 87.76,93.72 v1(85.24,96.24) 84.84,96.65 84.84,100.94 81.47,104.31 80.25,104.31 79.21,105.34 v1(77.81,105.34) ; SR738.1 158.41,22.27 v1(159.08,21.6) ; v1(124.71,93.85) 124.5,93.85 ECR90.1 PR124.1 ; SR7628.1 SR7627.1 184.26,32.35 v1(184.43,32.51) ; SR7629.1 171.74,29.39 v1(171.01,29.39) 171.01,29.77 SR680.1 ; v1(166.65,49.45) 166.2,49.45 PCH.AE13 ; 129.41,94.48 128.77,94.48 128.53,94.71 126.58,94.71 v1(126.11,94.23) ; v1(165.91,30.28) 165.81,30.28 165.24,29.71 SR746.1 164.31,29.71 163.87,29.27 163.87,28.77 SR87.1 163.83,27.88 163.83,27.75 SR7638.1 ; PR70228.1 63.65,122.5 v1(63.88,122.28) 63.33,121.73 PR70176.1 ; v1(178.08,29.42) 178.08,27.83 SR366.1 ; SR714.1 SR713.1 56.14,115.99 v1(57.24,115.99) ; SR164.1 83.37,110.12 81.7,110.12 v1(81.46,110.36) ; SR343.1 167.39,31.14 v1(167.54,31.29) ; M2R1.1 207.33,7.84 v1(207.09,7.59)
  TOP w0.279: UC82.1 39.52,139.6 U4.62 ; UC81.1 31.7,146 32.07,145.63 U4.38 ; U4.32 33.02,149.15 32.88,149.28 32.72,149.28 32.46,149.02 v1(32.18,149.02) ; UC74.1 41.54,142.13 U4.4 ; U4.44 v1(31.65,142.63) ; U4.55 UC79.1
  TOP w0.305: SR650.1 176.15,29.84 176.51,29.48 v1(176.73,29.48) ; XCB6.1 54.31,34.92 ; XCB6.1 54.74,34.49 ; XCB6.1 54.74,35.36 ; XCB5.1 50.55,55.07 ; XCB5.1 50.11,54.64 ; XCB5.1 50.11,55.5 ; v1(192.53,10.36) 192.7,10.19 P118.1 ; RFC121.1 43.27,141.78 42.65,141.78 UC74.1 ; 38.99,189.04 38.99,188.14 38.7,187.85 37.93,187.85 37.72,188.06 F3U2.8 37.72,190.02 37.85,190.14 UC94.1 37.85,191.35 RFC120.1 37.68,191.94 39.28,193.54 UR69703.1 UR69704.1 ; SLOT4.B8 52.45,16.21 52.76,15.91 XC94.1 52.27,14.33 51.99,14.05 v1(51.99,12.95) ; v1(208.48,22.39) 208.41,22.47 O2CB8.1 207.8,22.76 208.23,23.19 208.79,23.19 208.87,23.26 ; P118.3 v1(193.7,10.34) ; RFC30.1 D4C7.1 191.59,106.93 191.65,107 CON_XMM4.140 ; RFC29.1 173.82,106.3 174.62,106.3 174.62,105.51 v1(174.7,105.44)
  TOP w0.356: v1(193.05,48.82) 192.79,49.09 SR94.1
  TOP w0.381: 51.77,85.62 52.24,86.09 XR8.1 ; v1(78.51,6.69) 78.54,6.72 UCR43.1
  TOP w0.406: v1(133.48,235.56) 133.28,235.56 132.78,235.06 SR7714.1
  TOP w0.432: FR33.1 143.26,233.9 FR35.1
  TOP w0.457: SR7.1 231.6,19.44 v1(231.6,19.05) ; O2R21.1 v1(205.36,46.27) ; UC81.1 31.33,145.63 v1(31.6,145.36) ; UC91.1 44.58,139.23 UR69695.1 ; RFC30.1 189.15,107.07 CON_XMM1.284 ; M2C18.1 227.53,18.69 ; 51.33,26.33 XR16.1 ; XR16.1 50.27,26.33 ; XR16.1 50.8,26.84 ; UC82.1 40.75,138.65 41.07,138.33 41.07,137.59 42.06,136.6 42.06,136.4 v3(42.04,136.37) ; M2C17.1 226.61,18.85 v1(226.56,18.8) ; XR12.1 52.2,26.84 ; XR12.1 51.66,26.33 ; XR12.1 52.73,26.33 ; XR18.1 50.19,47.35 50.39,47.55 ; v1(42.96,141.14) 43.37,141.14 43.62,141.39 RFC121.1 ; v1(201.19,53.94) 200.41,54.72 SR673.1 SR7784.1 SR667.1 SR671.1 ; SR8.1 229.76,17.84 v1(229.59,18.01) ; 51.1,47.13 XR17.1 51.59,46.67 ; UC79.1 v1(36.7,138.44) ; 53.91,85.85 XR9.1 54.89,86.39 ; AR53.1 v1(24.8,21.75)
  TOP w0.508: UR69692.2 UR195.1 35.05,186.27 UD8869.2 v1(34.54,188.04) 35.2,188.7 35.2,189.04 RFC120.1 ; v1(83.52,11.91) 84.07,11.36 v1(84.07,9.25) ; PR641.2 24.08,169.28 MQ4.2 22.78,167.16 v1(21.06,167.16) ; v1(138.18,235.71) 138.18,235.33 136.87,234.02 FR1.1 FR8.1 ; FR30.1 233.12,229.92 233.07,229.87 232.29,229.87 FD8.3 231,229.73 230.43,229.16 FR31.1 v1(231.76,228.77) ; 206.88,107.99 206.55,107.99 CON_XMM2.284 ; v1(69.24,221.62) 69.25,221.63 PR5860.1 68.25,224.55 v1(68.25,225.25) ; v1(216.81,46.74) OR37.2 216.38,45.97 216.33,46.02 R18.1 ; v1(25.35,149.96) 26.13,149.18 29.14,149.18 30.2,150.24 31.52,150.24 32.18,149.58 v1(32.18,149.02) ; R25.1 103.88,5.02 104.58,5.73 106.44,5.73 107.7,6.99 v1(107.7,9.18) 109.89,9.18 114.63,13.92 v1(122.89,13.92) ; FD1.3 127.17,234.94 v1(127.13,234.99) ; v1(131.11,94.41) 131.05,94.48 129.41,94.48 ; R19.1 213.07,46.46 v1(212.75,46.46) ; 56.26,86.11 57.1,86.94 58.24,86.94 60.58,89.28 68.83,89.28 73.2,93.65 v1(78.08,93.65) 82.84,88.89 93.61,88.89 95.03,87.46 128.85,87.46 129.72,88.33 v1(130.71,88.33) ; UC91.1 44.58,141.12 44.31,141.39 RFC121.1 ; PD2.1 53.3,239.49 55.32,241.5 62.08,241.5 v1(65.71,237.87) 66.38,237.2 v1(67.65,237.2) 72.71,237.2 75.56,240.06 78.71,240.06 80.54,238.23 103.23,238.23 v1(104.01,239.01) ; v3(42.04,136.37) 39.24,136.37 v1(38.94,136.68) ; v1(32.69,204.29) v1(35.33,204.29) 35.97,204.29 36.5,204.83 36.5,205.23 37.01,205.74 38.46,205.74 43.81,211.1 43.81,217.86 44.5,218.54 v1(44.5,219.97) ; SCB32.1 175.06,33.68 174.78,33.96 v1(174.78,33.99) ; v1(28.98,18.61) 28.5,18.12 AL2.1 ; v1(143.85,235.56) FR33.1 ; PR5816.1 69.9,219.2 69.72,219.38 v1(69.24,219.38) ; v1(152.61,235.05) FD10.3
  TOP w0.635: 52.86,22.46 SLOT4.A9 52.86,21.28 ; XCE17.1 56.74,51.1 ; XCE17.1 55.8,50.16 ; XCE17.1 56.74,49.23 ; 59.54,30.61 XCE15.1 ; XCE15.1 58.65,29.72 ; XCE15.1 58.65,31.5 ; XCE15.1 57.76,30.61 ; 55.04,85.42 SLOT1.A10 53.86,84.24 ; 59.92,71.12 XCE2.1 ; XCE2.1 58.15,71.12 ; XCE2.1 59.03,70.23 ; XCE2.1 59.03,72.01 ; 54.02,41.62 SLOT3.A9 ; SLOT3.A9 52.88,41.62 ; SLOT3.A9 52.88,42.76 ; 55.02,44.76 SLOT3.A10 55.02,43.62 ; 52.45,77.49 SLOT1.B8 ; SLOT1.B8 52.45,79.17 ; SLOT1.B8 51.61,78.33 ; 53.02,37.12 SLOT3.B8 53.02,38.26 ; 53.45,81.99 SLOT1.A9 ; SLOT1.A9 53.45,83.67 ; SLOT1.A9 52.61,82.83 ; 52.45,18.29 SLOT4.B8 ; SLOT4.A10 53.86,23.28
  TOP w0.889: CON4.13 238.56,153.39 ; CON4.13 237.21,152.03 ; CON4.13 238.56,150.67 ; 233.06,157.59 CON4.2 ; CON4.2 231.71,156.23 ; CON4.2 233.06,154.87 ; CON4.2 234.42,156.23 ; 233.06,150.67 CON4.1 ; CON4.1 234.42,152.03 ; CON4.1 231.71,152.03 ; CON4.1 233.06,153.39
  TOP w1.016: v3(61.48,113.16) 64.19,115.86 v3(64.19,118.85) ; v3(44.33,131.83) 47.35,128.81 47.35,126.89 48.81,125.43 50.55,125.43 51.36,124.61 v3(52.3,124.61)
  BOTTOM w0.152: v1(174.78,33.99) 173.49,35.27 173.49,36.62 173.39,36.72 173.39,37.86 172.52,38.73 172.52,38.91 171.5,39.93 171.5,41.88 171.63,42.01 171.63,43.38 170.99,44.02 170.87,44.02 170.05,44.84 170.05,46.61 167.77,48.9 167.21,48.9 v1(166.65,49.45)
  BOTTOM w0.254: v1(124.71,93.85) 125.73,93.85 v1(126.11,94.23) ; PT25.1 PT24.1 185.19,33.27 v1(184.43,32.51) 184.26,32.35 PT22.1 182.15,31.49 179.61,31.49 178.08,29.96 v1(178.08,29.42) ; v1(167.54,31.29) 167.54,30.61 167.08,30.15 166.04,30.15 v1(165.91,30.28) ; v1(81.46,110.36) 77.81,106.71 v1(77.81,105.34)
  BOTTOM w0.305: CON_XMM2.284 CON_XMM2.140 ; CON_XMM4.140 CON_XMM4.284 ; CON_XMM1.284 187.03,107 186.18,106.15 184.96,106.15 184.35,106.76 184.35,107.24 CON_XMM1.139 182.9,107 CON_XMM3.284 179.26,107 178.42,106.16 177.18,106.16 176.35,106.98 175.63,106.98 174.7,106.05 v1(174.7,105.44)
  BOTTOM w0.381: v1(51.99,12.95) 51.99,12.93 53.47,11.45 57.07,11.45 57.86,10.67 73.79,10.67 74.41,11.29 74.93,11.29 75.46,11.82 75.93,11.82 83.44,11.82 v1(83.52,11.91)
  BOTTOM w0.457: CON_XMM4.284 199.31,107 CON_XMM2.139 201.01,107 CON_XMM2.140
  BOTTOM w0.508: v1(67.65,237.2) 66.55,236.09 66.55,233.17 68.25,231.47 v1(68.25,225.25) ; v1(32.18,149.02) 32.25,148.96 32.25,146.01 v1(31.6,145.36) 31.98,144.98 31.98,142.95 v1(31.65,142.63) 32.63,141.65 32.63,140.74 33.07,140.29 33.07,139.74 34.37,138.44 v1(36.7,138.44) 37.02,138.44 38.09,137.38 38.09,137.36 38.45,136.99 38.47,136.99 38.79,136.68 v1(38.94,136.68) ; v1(34.54,188.04) 33.66,188.93 33.66,197.61 35.69,199.64 35.69,203.94 v1(35.33,204.29) ; v1(122.89,13.92) 123.52,13.28 129.38,13.28 129.97,13.88 132.27,13.88 PT23.1 133.41,14.02 137.17,17.79 147.51,17.79 148.12,18.41 154.41,18.41 155.2,19.19 156.68,19.19 PT21.1 v1(159.08,21.6) ; v1(85.24,96.24) 84.19,95.19 79.62,95.19 v1(78.08,93.65) ; v1(131.11,94.41) 131.47,94.06 131.47,92.53 130.71,91.77 v1(130.71,88.33) ; v1(104.01,239.01) 104.01,237.85 107.95,233.91 117.92,233.91 119,234.99 v1(127.13,234.99) 132.91,234.99 v1(133.48,235.56) 134.84,235.56 135.36,235.04 136.77,235.04 137.44,235.71 v1(138.18,235.71) 138.51,236.04 143.37,236.04 v1(143.85,235.56) 146.44,235.56 146.96,235.04 147.93,235.04 149.16,236.27 152.01,236.27 152.61,235.67 v1(152.61,235.05) ; v1(63.88,122.28) 63.55,121.95 63.55,120.27 64.19,119.63 v3(64.19,118.85) ; v1(65.71,237.87) 64.92,237.08 50.59,237.08 44.06,230.55 44.06,225.34 44.44,224.95 44.44,221.85 43.81,221.22 43.81,220.66 v1(44.5,219.97) ; v1(69.24,221.62) v1(69.24,219.38) ; v1(231.76,228.77) 231.76,227.05 235.84,222.97 235.84,215.84 236.05,215.62 236.05,213.42 234.39,211.75 234.39,208.81 233.83,208.25 233.83,199 CON4.12 234.77,196.53 234.77,157.94 CON4.2 ; v1(25.35,149.96) 25.35,155.22 21.06,159.52 v1(21.06,167.16) 21.52,167.16 23.3,168.94 23.3,176.85 24.21,177.75 24.21,180.37 24.75,180.91 24.75,188.37 28.23,191.85 28.23,196.63 32.69,201.08 v1(32.69,204.29) ; v1(41.58,7.75) 41.58,9.32 35.46,15.44 32.15,15.44 v1(28.98,18.61) 28.98,20.32 27.56,21.75 v1(24.8,21.75) ; v1(84.07,9.25) 87.96,9.25 89.18,8.03 95.12,8.03 95.34,8.26 103.93,8.26 103.99,8.32 105.84,8.32 106.16,8.63 106.7,9.18 v1(107.7,9.18)
  BOTTOM w0.635: v3(42.04,136.37) 43.43,137.77 43.43,140.67 v1(42.96,141.14)
  BOTTOM w0.762: v3(42.04,136.37) 44.33,134.08 v3(44.33,131.83)
  BOTTOM w1.016: v3(71.25,98.42) 71.25,106.07 64.16,113.16 v3(61.48,113.16) 60.08,113.16 v1(57.24,115.99) 56.16,117.07 56.16,120.06 52.3,123.92 v3(52.3,124.61)
  vias: v1(205.41,15.9) v1(208.77,108.74) v1(208.78,107.97) v1(223.04,18.82) v1(223.77,18.8) v1(227.41,18.82) v3(204.88,15.24) v3(230.25,149.12) v3(231.11,148.39)
+3P3V_DISCHARGE: length 0.9
  BOTTOM w0.102: v2(227.81,156.74) v1(227.81,155.85)
+3P3V_DP: length 25.1
  TOP w0.254: v1(31.32,174.55) 31.32,174.59 31.83,175.1 31.83,175.86 31.57,176.11 M1R8.1
  TOP w0.457: M1R13.1 21.72,173.46 v1(21.59,173.33)
  TOP w0.508: v1(30.94,173.13) 30.78,172.97 28.32,172.97 27.31,171.96 v1(21.97,171.96) ; 16.89,174.62 19.3,174.62 19.41,174.73 v1(21.59,174.73) 21.72,174.6 M1R12.1
  TOP w0.635: 8.14,171.66 J125.20 7.4,170.92
  BOTTOM w0.254: v1(30.94,173.13) 31.32,173.51 v2(31.32,173.79) v1(31.32,174.55)
  BOTTOM w0.508: v1(21.97,171.96) 21.59,172.34 v1(21.59,173.33) v1(21.59,174.73)
+3P3V_DVDD: length 17.4
  TOP w0.254: AU1.1 21.72,12.82 22.23,12.32 ; AU1.9 21.67,16.82 21.83,16.98 22.54,16.98 22.71,17.14 AC14.1
  TOP w0.305: RFC114.1 23.23,16.98 AC14.1 ; RFC113.1 22.97,12.32 22.23,12.32
  TOP w0.457: RFC113.1 23.83,12.48 24.22,12.88 25.73,12.88 25.97,13.12 AC20.1
  TOP w0.508: AC20.1 25.97,14.54 v1(26.54,15.11) 26.54,16.75 26.52,16.78 AL2.2 AC15.1 24.18,16.78 RFC114.1
  BOTTOM w0.102: v2(25.63,15.11) v1(26.54,15.11)
