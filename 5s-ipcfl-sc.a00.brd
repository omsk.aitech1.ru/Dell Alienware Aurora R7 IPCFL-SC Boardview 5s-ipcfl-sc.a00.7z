# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Text on the board (continued)
User.45: 0@@list("AC1" "MX_C0201" list(895.000000 762.000000) nil) | 0@@list("AC129" "MX_C0402_SMALL_T01" list(1580.000000 330.000000) nil) | 0@@list("AC130" "MX_C0402_SMALL_T01" list(735.000000 3255.000000) nil) | 0@@list("AC136" "MX_C0402_SMALL_T01" list(549.000000 6907.000000) nil) | 0@@list("AC14" "MX_C0201" list(908.000000 685.000000) nil) | 0@@list("AC15" "MX_C0603_SMALL_T01" list(987.080000 687.000000) nil) | 0@@list("AC16" "MX_C0603_SMALL_T01" list(300.000000 695.080000) nil) | 0@@list("AC161" "C1206_H75" list(595.000000 950.000000) nil) | 0@@list("AC162" "C1206_H75" list(695.000000 950.000000) nil) | 0@@list("AC163" "C1206_H75" list(490.000000 950.000000) nil) | 0@@list("AC164" "C1206_H75" list(390.000000 950.000000) nil) | 0@@list("AC17" "MX_C0201" list(540.000000 330.000000) nil) | 0@@list("AC173" "MX_C0402_SMALL_T01" list(298.000000 2700.000000) nil) | 0@@list("AC174" "MX_C0402_SMALL_T01" list(207.000000 2700.000000) nil) | 0@@list("AC175" "MX_C0402_SMALL_T01" list(389.000000 2700.000000) nil) | 0@@list("AC176" "MX_C0402_SMALL_T01" list(480.000000 2700.000000) nil) | 0@@list("AC177" "MX_C0402_SMALL_T01" list(662.000000 2700.000000) nil) | 0@@list("AC178" "MX_C0402_SMALL_T01" list(571.000000 2700.000000) nil) | 0@@list("AC179" "MX_C0402_SMALL_T01" list(682.000000 3504.000000) nil) | 0@@list("AC18" "MX_C0603_SMALL_T01" list(465.000000 335.080000) nil) | 0@@list("AC180" "MX_C0402_SMALL_T01" list(770.000000 3502.000000) nil) | 0@@list("AC181" "MX_C0402_SMALL_T01" list(470.000000 3470.000000) nil) | 0@@list("AC182" "MX_C0402_SMALL_T01" list(398.000000 3530.000000) nil) | 0@@list("AC183" "MX_C0402_SMALL_T01" list(261.500000 3475.000000) nil) | 0@@list("AC184" "MX_C0402_SMALL_T01" list(215.000000 2830.000000) nil) | 0@@list("AC185" "MX_C0402_SMALL_T01" list(575.000000 8755.000000) nil) | 0@@list("AC186" "MX_C0402_SMALL_T01" list(630.000000 8920.000000) nil) | 0@@list("AC187" "MX_C0201" list(555.000000 8920.000000) nil) | 0@@list("AC188" "MX_C0603_SMALL_T01" list(940.000000 539.920000) nil) | 0@@list("AC19" "MX_C0201" list(355.000000 745.000000) nil) | 0@@list("AC193" "MX_C0402_SMALL_T01" list(2340.500000 345.500000) nil) | 0@@list("AC194" "MX_C0402_SMALL_T01" list(2850.000000 365.000000) nil) | 0@@list("AC195" "MX_C0402_SMALL_T01" list(2958.000000 365.000000) nil) | 0@@list("AC196" "MX_C0402_SMALL_T01" list(3069.000000 365.000000) nil) | 0@@list("AC197" "MX_C0402_SMALL_T01" list(2357.000000 453.000000) nil) | 0@@list("AC198" "MX_C0402_SMALL_T01" list(1130.000000 1178.000000) nil) | 0@@list("AC2" "MX_C0201" list(895.000000 798.000000) nil) | 0@@list("AC20" "MX_C0603_SMALL_T01" list(1049.000000 541.000000) nil) | 0@@list("AC21" "MX_C0201" list(875.000000 475.000000) nil) | 0@@list("AC22" "MX_C0402_SMALL_T01" list(930.000000 585.000000) nil) | 0@@list("AC23" "MX_C0603_SMALL_T01" list(300.000000 640.080000) nil) | 0@@list("AC24" "MX_C0402_SMALL_T01" list(1170.000000 445.000000) nil) | 0@@list("AC25" "MX_C0402_SMALL_T01" list(1235.000000 445.000000) nil) | 0@@list("AC26" "MX_C0402_SMALL_T01" list(715.000000 2795.000000) nil) | 0@@list("AC27" "MX_C0402_SMALL_T01" list(765.000000 1370.000000) nil) | 0@@list("AC3" "MX_C0603_SMALL_T01" list(271.000000 585.080000) nil) | 0@@list("AC39" "MX_C0201" list(8507.000000 868.000000) nil) | 0@@list("AC4" "MX_C0201" list(375.000000 580.000000) nil) | 0@@list("AC47" "MX_C0402_SMALL_T01" list(8040.000000 1390.000000) nil) | 0@@list("AC52" "MX_C0402_SMALL_T01" list(715.000000 2955.000000) nil) | 0@@list("AC55" "MX_C0402_SMALL_T01" list(715.000000 2285.000000) nil) | 0@@list("AC71" "MX_C0603_SMALL_T02" list(1190.000000 1063.000000) nil) | 0@@list("AC72" "MX_C0402_SMALL_T01" list(1621.000000 215.000000) nil) | 0@@list("AC73" "MX_C0402_SMALL_T01" list(810.000000 440.000000) nil) | 0@@list("AC74" "MX_C0402_SMALL_T01" list(1072.000000 305.000000) nil) | 0@@list("AC75" "MX_C0402_SMALL_T01" list(1215.000000 305.000000) nil) | 0@@list("AC76" "MX_C0402_SMALL_T01" list(1360.000000 305.000000) nil) | 0@@list("AC77" "MX_C0402_SMALL_T01" list(1495.000000 305.000000) nil) | 0@@list("AD10" "MX_VARISTOR_0402" list(1130.000000 445.000000) nil) | 0@@list("AD11" "MX_VARISTOR_0402" list(1295.000000 445.000000) nil) | 0@@list("AD12" "MX_VARISTOR_0402" list(1455.000000 430.000000) nil) | 0@@list("AD13" "MX_VARISTOR_0402" list(292.000000 2740.000000) nil) | 0@@list("AD14" "MX_VARISTOR_0402" list(207.000000 2740.000000) nil) | 0@@list("AD15" "MX_VARISTOR_0402" list(389.000000 2740.000000) nil) | 0@@list("AD16" "MX_VARISTOR_0402" list(495.000000 2740.000000) nil) | 0@@list("AD17" "MX_VARISTOR_0402" list(662.000000 2740.000000) nil) | 0@@list("AD18" "MX_VARISTOR_0402" list(571.000000 2740.000000) nil) | 0@@list("AD19" "MX_VARISTOR_0402" list(688.000000 3542.000000) nil) | 0@@list("AD2" "MX_S0402_AMAZ_COLAY" list(800.000000 1270.000000) nil) | 0@@list("AD20" "MX_VARISTOR_0402" list(2410.770000 411.600000) nil) | 0@@list("AD21" "MX_VARISTOR_0402" list(2812.000000 366.000000) nil) | 0@@list("AD22" "MX_VARISTOR_0402" list(2996.000000 366.000000) nil) | 0@@list("AD23" "MX_VARISTOR_0402" list(2664.000000 355.000000) nil) | 0@@list("AD3" "MX_VARISTOR_0402" list(765.000000 3541.000000) nil) | 0@@list("AD4" "MX_VARISTOR_0402" list(480.000000 3525.000000) nil) | 0@@list("AD5" "MX_VARISTOR_0402" list(437.000000 3525.000000) nil) | 0@@list("AD6" "MX_VARISTOR_0402" list(265.000000 3535.000000) nil) | 0@@list("AD7" "MX_VARISTOR_0402" list(175.000000 2830.000000) nil) | 0@@list("AD8" "MX_VARISTOR_0402" list(1615.000000 175.000000) nil) | 0@@list("AD9" "MX_VARISTOR_0402" list(1014.000000 430.000000) nil) | 0@@list("AL1" "MX_L0603_SMALL_T02" list(765.000000 1200.000000) nil) | 0@@list("AL10" "MX_L0603_SMALL_T02" list(372.000000 3472.000000) nil) | 0@@list("AL11" "MX_L0603_SMALL_T02" list(207.000000 2655.000000) nil) | 0@@list("AL12" "MX_L0603_SMALL_T02" list(200.000000 3484.000000) nil) | 0@@list("AL13" "MX_L0603_SMALL_T02" list(298.000000 2655.000000) nil) | 0@@list("AL14" "MX_L0603_SMALL_T02" list(260.000000 2825.000000) nil) | 0@@list("AL15" "MX_L0603_SMALL_T02" list(1505.000000 370.000000) nil) | 0@@list("AL16" "MX_L0603_SMALL_T02" list(1350.000000 350.000000) nil) | 0@@list("AL17" "MX_L0603_SMALL_T02" list(1177.000000 360.000000) nil) | 0@@list("AL18" "MX_L0603_SMALL_T02" list(995.000000 318.000000) nil) | 0@@list("AL2" "MX_L0603_SMALL_T02" list(1040.000000 687.020000) nil) | 0@@list("AL3" "MX_L0603_SMALL_T02" list(571.000000 2655.000000) nil) | 0@@list("AL4" "MX_L0603_SMALL_T02" list(685.000000 3460.000000) nil) | 0@@list("AL5" "MX_L0603_SMALL_T02" list(662.000000 2655.000000) nil) | 0@@list("AL6" "MX_L0603_SMALL_T02" list(770.000000 3440.000000) nil) | 0@@list("AL7" "MX_L0603_SMALL_T02" list(480.000000 2655.000000) nil) | 0@@list("AL8" "MX_L0603_SMALL_T02" list(550.000000 3484.000000) nil) | 0@@list("AL9" "MX_L0603_SMALL_T02" list(389.000000 2655.000000) nil) | 0@@list("APR112" "MX_R0402_SMALL_T01" list(997.000000 5653.000000) nil) | 0@@list("APR13" "MX_R0402_SMALL_T01" list(8397.000000 325.000000) nil) | 0@@list("AR1" "MX_R0402_SMALL_T01" list(1080.000000 885.000000) nil) | 0@@list("AR10" "MX_R0402_SMALL_T01" list(917.000000 373.000000) nil) | 0@@list("AR11" "MX_R0402_SMALL_T01" list(339.000000 505.000000) nil) | 0@@list("AR12" "MX_R0402_SMALL_T01" list(1255.000000 375.000000) nil) | 0@@list("AR13" "MX_R0402_SMALL_T01" list(1430.000000 339.000000) nil) | 0@@list("AR14" "MX_R0402_SMALL_T01" list(732.000000 1082.000000) nil) | 0@@list("AR15" "MX_R0402_SMALL_T01" list(732.000000 1117.000000) nil) | 0@@list("AR16" "MX_R0402_SMALL_T01" list(732.000000 1048.000000) nil) | 0@@list("AR17" "MX_R0402_SMALL_T01" list(770.000000 995.000000) nil) | 0@@list("AR18" "MX_R0402_SMALL_T01" list(267.000000 505.000000) nil) | 0@@list("AR19" "MX_R0402_SMALL_T01" list(375.000000 505.000000) nil) | 0@@list("AR199" "MX_R0402_SMALL_T01" list(223.000000 2390.000000) nil) | 0@@list("AR2" "MX_R0402_SMALL_T01" list(930.010000 630.000000) nil) | 0@@list("AR20" "MX_R0402_SMALL_T01" list(578.500000 8974.000000) nil) | 0@@list("AR200" "MX_R0402_SMALL_T01" list(186.620000 2390.260000) nil) | 0@@list("AR201" "MX_R0402_SMALL_T01" list(295.000000 2390.000000) nil) | 0@@list("AR202" "MX_R0402_SMALL_T01" list(259.000000 2390.000000) nil) | 0@@list("AR203" "MX_R0402_SMALL_T01" list(535.000000 2390.000000) nil) | 0@@list("AR204" "MX_R0402_SMALL_T01" list(499.000000 2390.000000) nil) | 0@@list("AR205" "MX_R0402_SMALL_T01" list(563.000000 2610.000000) nil) | 0@@list("AR206" "MX_R0402_SMALL_T01" list(649.500000 2610.000000) nil) | 0@@list("AR207" "MX_R0402_SMALL_T01" list(563.000000 2570.000000) nil) | 0@@list("AR208" "MX_R0402_SMALL_T01" list(649.500000 2570.000000) nil) | 0@@list("AR209" "MX_R0402_SMALL_T01" list(685.000000 3415.000000) nil) | 0@@list("AR210" "MX_R0402_SMALL_T01" list(705.000000 3365.000000) nil) | 0@@list("AR211" "MX_R0402_SMALL_T01" list(478.010000 2570.000000) nil) | 0@@list("AR212" "MX_R0402_SMALL_T01" list(610.000000 3424.000000) nil) | 0@@list("AR213" "MX_R0402_SMALL_T01" list(389.010000 2570.000000) nil) | 0@@list("AR214" "MX_R0402_SMALL_T01" list(308.500000 3479.990000) nil) | 0@@list("AR215" "MX_R0402_SMALL_T01" list(207.010000 2570.000000) nil) | 0@@list("AR216" "MX_R0402_SMALL_T01" list(190.000000 3404.000000) nil) | 0@@list("AR217" "MX_R0402_SMALL_T01" list(298.010000 2570.000000) nil) | 0@@list("AR218" "MX_R0402_SMALL_T01" list(329.500000 2793.000000) nil) | 0@@list("AR219" "MX_R0402_SMALL_T01" list(190.000000 3440.000000) nil) | 0@@list("AR220" "MX_R0402_SMALL_T01" list(298.000000 2610.000000) nil) | 0@@list("AR221" "MX_R0402_SMALL_T01" list(207.000000 2610.000000) nil) | 0@@list("AR222" "MX_R0402_SMALL_T01" list(389.000000 2610.000000) nil) | 0@@list("AR223" "MX_R0402_SMALL_T01" list(329.500000 2829.000000) nil) | 0@@list("AR224" "MX_R0402_SMALL_T01" list(476.000000 2610.000000) nil) | 0@@list("AR225" "MX_R0402_SMALL_T01" list(350.000000 3530.000000) nil) | 0@@list("AR226" "MX_R0402_SMALL_T01" list(560.000000 3439.000000) nil) | 0@@list("AR227" "MX_R0402_SMALL_T01" list(575.010000 8798.130000) nil) | 0@@list("AR228" "MX_R0402_SMALL_T01" list(575.010000 8838.130000) nil) | 0@@list("AR229" "MX_R0402_SMALL_T01" list(1660.000000 251.000000) nil) | 0@@list("AR23" "MX_R0402_SMALL_T01" list(810.000000 1095.000000) nil) | 0@@list("AR231" "MX_R0402_SMALL_T01" list(1335.000000 445.000000) nil) | 0@@list("AR232" "MX_R0402_SMALL_T01" list(715.000000 3015.000000) nil) | 0@@list("AR237" "MX_R0402_SMALL_T01" list(905.000000 5770.000000) nil) | 0@@list("AR238" "MX_R0402_SMALL_T01" list(896.000000 5912.000000) nil) | 0@@list("AR241" "MX_R0402_SMALL_T01" list(605.000000 6010.000000) nil) | 0@@list("AR242" "MX_R0402_SMALL_T01" list(997.000000 5689.000000) nil) | 0@@list("AR243" "MX_R0402_SMALL_T01" list(770.000000 5686.000000) nil) | 0@@list("AR244" "MX_R0402_SMALL_T01" list(1300.000000 6345.000000) nil) | 0@@list("AR247" "MX_R0402_SMALL_T01" list(916.000000 5990.000000) nil) | 0@@list("AR25" "MX_R0402_SMALL_T01" list(303.000000 505.000000) nil) | 0@@list("AR26" "MX_R0402_SMALL_T01" list(580.000000 330.000000) nil) | 0@@list("AR263" "MX_R0402_SMALL_T01" list(968.000000 430.000000) nil) | 0@@list("AR3" "MX_R0402_SMALL_T01" list(980.010000 805.000000) nil) | 0@@list("AR4" "MX_R0402_SMALL_T01" list(895.000000 835.000000) nil) | 0@@list("AR5" "MX_R0402_SMALL_T01" list(1430.000000 375.000000) nil) | 0@@list("AR50" "MX_R0402_SMALL_T01" list(840.000000 873.000000) nil) | 0@@list("AR53" "MX_R0402_SMALL_T01" list(960.000000 885.000000) nil) | 0@@list("AR55" "MX_R0402_SMALL_T01" list(1125.000000 1052.000000) nil) | 0@@list("AR56" "MX_R0402_SMALL_T01" list(1125.000000 1088.000000) nil) | 0@@list("AR57" "MX_R0603_SMALL_T01" list(1140.000000 1133.000000) nil) | 0@@list("AR6" "MX_R0402_SMALL_T01" list(1265.000000 325.000000) nil) | 0@@list("AR61" "MX_R0402_SMALL_T01" list(630.000000 2390.000000) nil) | 0@@list("AR62" "MX_R0402_SMALL_T01" list(594.000000 2390.000000) nil) | 0@@list("AR63" "MX_R0402_SMALL_T01" list(409.000000 2390.000000) nil) | 0@@list("AR64" "MX_R0402_SMALL_T01" list(445.000000 2390.000000) nil) | 0@@list("AR7" "MX_R0402_SMALL_T01" list(917.000000 337.000000) nil) | 0@@list("AR8" "MX_R0402_SMALL_T01" list(1079.000000 365.000000) nil) | 0@@list("AR9" "MX_R0402_SMALL_T01" list(1115.000000 365.000000) nil) | 0@@list("ASR7" "MX_R0402_SMALL_T01" list(1437.000000 5912.000000) nil) | 0@@list("AU1" "MX_QFP_48P_20_354X354_H63" list(630.000000 613.000000) nil) | 0@@list("C1" "MX_C0402_SMALL_T01" list(8486.000000 1775.000000) nil) | 0@@list("C2" "MX_C0402_SMALL_T01" list(8422.000000 1775.000000) nil) | 0@@list("C414" "MX_C0402_SMALL_T01" list(6654.000000 982.000000) nil) | 0@@list("C415" "MX_C0402_SMALL_T01" list(6698.000000 982.000000) nil) | 0@@list("C416" "MX_C0402_SMALL_T01" list(6632.000000 1175.000000) nil) | 0@@list("C417" "MX_C0402_SMALL_T01" list(6391.000000 1239.000000) nil) | 0@@list("C5" "MX_C0402_SMALL_T01" list(4187.000000 412.000000) nil) | 0@@list("C81" "MX_C0402_SMALL_T01" list(8040.000000 1130.000000) nil) | 0@@list("C82" "MX_C0402_SMALL_T01" list(8720.500000 1704.500000) nil) | 0@@list("C83" "MX_C0402_SMALL_T01" list(8894.000000 1031.500000) nil) | 0@@list("C85" "MX_C0603_SMALL_T01" list(8069.000000 906.000000) nil) | 0@@list("C93" "MX_C0201" list(5425.920000 596.400000) nil) | 0@@list("C9357" "MX_C0201" list(8796.000000 4041.000000) nil) | 0@@list("C941399" "MX_C0201" list(8723.000000 4600.000000) nil) | 0@@list("C941400" "MX_C0201" list(9042.000000 4097.000000) nil) | 0@@list("C941401" "MX_C0201" list(9067.000000 4558.000000) nil) | 0@@list("C941402" "MX_C0402_SMALL_T01" list(8787.000000 3908.000000) nil) | 0@@list("CB2" "MX_C0402_SMALL_T01" list(1096.000000 1694.000000) nil) | 0@@list("CB4107" "MX_C0201" list(618.000000 5494.000000) nil) | 0@@list("CB4112" "MX_C0201" list(638.000000 5630.000000) nil) | 0@@list("CB4113" "MX_C0201" list(729.000000 5614.000000) nil) | 0@@list("CB4114" "MX_C0201" list(618.000000 5458.000000) nil) | 0@@list("CB4115" "MX_C0201" list(904.000000 8935.000000) nil) | 0@@list("CB4116" "MX_C0201" list(726.000000 8968.000000) nil) | 0@@list("CB4117" "MX_C0201" list(585.000000 8520.000000) nil) | 0@@list("CB4119" "MX_C0402_SMALL_T01" list(1670.000000 8130.000000) nil) | 0@@list("CB4122" "MX_C0402_SMALL_T01" list(8982.000000 5405.000000) nil) | 0@@list("CB4123" "MX_C0201" list(8868.000000 5406.000000) nil) | 0@@list("CB4124" "MX_C0201" list(9207.000000 4567.000000) nil) | 0@@list("CB4125" "MX_C0201" list(1706.000000 8130.000000) nil) | 0@@list("CB4126" "MX_C0201" list(1515.000000 6415.000000) nil) | 0@@list("CB4127" "MX_C0201" list(944.000000 5643.000000) nil) | 0@@list("CB4128" "MX_C0402_SMALL_T01" list(902.000000 5654.000000) nil) | 0@@list("CB4129" "MX_C0402_SMALL_T01" list(829.000000 5995.000000) nil) | 0@@list("CR17" "MX_R0402_SMALL_T01" list(1410.000000 7900.000000) nil) | 0@@list("CR19" "MX_R0402_SMALL_T01" list(1518.000000 7935.000000) nil) | 0@@list("D4C1" "MX_C0402_SMALL_T01" list(8160.500000 7221.290000) nil) | 0@@list("D4C12" "MX_C0201" list(8145.000000 4235.000000) nil) | 0@@list("D4C13" "MX_C0201" list(8145.000000 9055.000000) nil) | 0@@list("D4C17" "MX_C0201" list(8181.000000 4235.000000) nil) | 0@@list("D4C18" "MX_C0201" list(8195.000000 9040.000000) nil) | 0@@list("D4C2" "MX_C0201" list(6875.000000 4195.000000) nil) | 0@@list("D4C21" "MX_C0603_SMALL_T01" list(7505.000000 8999.000000) nil) | 0@@list("D4C22" "MX_C0603_SMALL_T01" list(6785.000000 9030.000000) nil) | 0@@list("D4C23" "MX_C0603_SMALL_T01" list(8155.000000 8975.000000) nil) | 0@@list("D4C24" "MX_C0603_SMALL_T01" list(8205.000000 8975.000000) nil) | 0@@list("D4C3" "MX_C0201" list(6830.000000 9050.000000) nil) | 0@@list("D4C4" "MX_C0402_SMALL_T01" list(6805.000000 4065.000000) nil) | 0@@list("D4C5" "MX_C0402_SMALL_T01" list(6805.000000 4130.000000) nil) | 0@@list("D4C7" "MX_C0201" list(7505.000000 4200.000000) nil) | 0@@list("D4C8" "MX_C0201" list(7505.000000 9080.000000) nil) | 0@@list("D4CB1" "MX_C0603_SMALL_T01" list(6830.000000 6480.000000) nil) | 0@@list("D4CB10" "MX_C0201" list(7513.000000 6535.000000) nil) | 0@@list("D4CB11" "MX_C0201" list(8181.000000 4165.000000) nil) | 0@@list("D4CB12" "MX_C0201" list(8145.000000 4165.000000) nil) | 0@@list("D4CB13" "MX_C0603_SMALL_T01" list(8172.000000 6134.000000) nil) | 0@@list("D4CB14" "MX_C0201" list(8146.000000 6480.000000) nil) | 0@@list("D4CB15" "MX_C0201" list(8265.000000 4325.000000) nil) | 0@@list("D4CB16" "MX_C0201" list(8367.000000 4394.000000) nil) | 0@@list("D4CB17" "MX_C0402_SMALL_T01" list(8325.000000 6330.000000) nil) | 0@@list("D4CB18" "MX_C0402_SMALL_T01" list(8170.000000 7095.000000) nil) | 0@@list("D4CB19" "MX_C0402_SMALL_T01" list(6785.000000 7290.000000) nil) | 0@@list("D4CB2" "MX_C0201" list(6872.000000 6490.000000) nil) | 0@@list("D4CB20" "MX_C0402_SMALL_T01" list(7505.000000 6069.000000) nil) | 0@@list("D4CB21" "MX_C0603_SMALL_T02" list(7510.000000 6150.000000) nil) | 0@@list("D4CB22" "MX_C0603_SMALL_T02" list(7510.000000 6630.000000) nil) | 0@@list("D4CB23" "MX_C0603_SMALL_T02" list(8252.000000 6599.500000) nil) | 0@@list("D4CB24" "MX_C0603_SMALL_T02" list(8199.000000 6614.000000) nil) | 0@@list("D4CB25" "MX_C0201" list(8217.000000 6330.000000) nil) | 0@@list("D4CB26" "MX_C0603_SMALL_T02" list(6540.000000 7137.000000) nil) | 0@@list("D4CB27" "MX_C0402_SMALL_T01" list(6850.000000 6855.000000) nil) | 0@@list("D4CB28" "MX_C0603_SMALL_T02" list(6611.000000 6317.000000) nil) | 0@@list("D4CB29" "MX_C0603_SMALL_T02" list(7512.000000 6857.000000) nil) | 0@@list("D4CB3" "MX_C0201" list(6789.000000 3987.000000) nil) | 0@@list("D4CB30" "MX_C0603_SMALL_T02" list(8302.000000 6483.000000) nil) | 0@@list("D4CB31" "MX_C0603_SMALL_T02" list(6665.000000 6317.000000) nil) | 0@@list("D4CB32" "MX_C0603_SMALL_T02" list(8237.500000 6779.000000) nil) | 0@@list("D4CB33" "MX_C0402_SMALL_T01" list(8193.500000 6780.000000) nil) | 0@@list("D4CB34" "MX_C0402_SMALL_T01" list(6253.000000 6842.000000) nil) | 0@@list("D4CB35" "MX_C0402_SMALL_T01" list(8254.000000 6481.000000) nil) | 0@@list("D4CB36" "MX_C0402_SMALL_T01" list(8283.000000 6779.000000) nil) | 0@@list("D4CB37" "MX_C0402_SMALL_T01" list(6489.000000 7081.000000) nil) | 0@@list("D4CB38" "MX_C0603_SMALL_T02" list(8170.000000 6940.000000) nil) | 0@@list("D4CB39" "MX_C0603_SMALL_T02" list(8170.000000 6885.000000) nil) | 0@@list("D4CB4" "MX_C0201" list(6833.000000 3987.000000) nil) | 0@@list("D4CB40" "MX_C0603_SMALL_T02" list(6430.000000 7025.000000) nil) | 0@@list("D4CB41" "MX_C0603_SMALL_T02" list(8170.000000 6995.000000) nil) | 0@@list("D4CB48" "MX_C0402_SMALL_T01" list(5159.000000 6005.000000) nil) | 0@@list("D4CB49" "MX_C0402_SMALL_T01" list(8157.500000 6780.000000) nil) | 0@@list("D4CB5" "MX_C0603_SMALL_T01" list(8262.000000 6175.000000) nil) | 0@@list("D4CB50" "MX_C0402_SMALL_T01" list(7510.000000 7760.000000) nil) | 0@@list("D4CB51" "MX_C0402_SMALL_T01" list(6710.000000 6332.000000) nil) | 0@@list("D4CB52" "MX_C0402_SMALL_T01" list(7510.000000 8463.000000) nil) | 0@@list("D4CB53" "MX_C0402_SMALL_T01" list(7510.000000 8130.000000) nil) | 0@@list("D4CB54" "MX_C0402_SMALL_T01" list(7510.000000 6710.000000) nil) | 0@@list("D4CB55" "MX_C0402_SMALL_T01" list(7513.000000 7030.000000) nil) | 0@@list("D4CB57" "MX_C0201" list(8181.000000 6330.000000) nil) | 0@@list("D4CB58" "MX_C0201" list(7511.000000 7375.000000) nil) | 0@@list("D4CB59" "MX_C0201" list(8289.000000 6330.000000) nil) | 0@@list("D4CB6" "MX_C0201" list(8176.000000 6180.000000) nil) | 0@@list("D4CB60" "MX_C0201" list(7510.000000 5780.000000) nil) | 0@@list("D4CB61" "MX_C0201" list(8220.000000 6480.000000) nil) | 0@@list("D4CB62" "MX_C0201" list(7513.000000 7108.000000) nil) | 0@@list("D4CB63" "MX_C0603_SMALL_T02" list(6359.000000 6947.000000) nil) | 0@@list("D4CB64" "MX_C0201" list(6717.000000 7145.000000) nil) | 0@@list("D4CB65" "MX_C0201" list(8253.000000 6330.000000) nil) | 0@@list("D4CB66" "MX_C0402_SMALL_T01" list(6850.000000 7145.000000) nil) | 0@@list("D4CB67" "MX_C0402_SMALL_T01" list(6818.000000 6084.000000) nil) | 0@@list("D4CB68" "MX_C0402_SMALL_T01" list(6598.000000 7181.000000) nil) | 0@@list("D4CB69" "MX_C0201" list(8156.000000 6628.000000) nil) | 0@@list("D4CB7" "MX_C0201" list(7511.000000 4070.000000) nil) | 0@@list("D4CB70" "MX_C0201" list(7510.000000 5860.000000) nil) | 0@@list("D4CB71" "MX_C0603_SMALL_T02" list(6305.000000 6893.000000) nil) | 0@@list("D4CB72" "MX_C0201" list(7511.000000 5180.000000) nil) | 0@@list("D4CB73" "MX_C0201" list(7510.000000 5590.000000) nil) | 0@@list("D4CB74" "MX_C0201" list(7510.000000 6942.000000) nil) | 0@@list("D4CB75" "MX_C0201" list(8170.000000 6841.000000) nil) | 0@@list("D4CB76" "MX_C0201" list(7510.000000 8839.000000) nil) | 0@@list("D4CB77" "MX_C0201" list(7509.000000 5933.000000) nil) | 0@@list("D4CB78" "MX_C0201" list(6850.000000 6660.000000) nil) | 0@@list("D4CB8" "MX_C0201" list(7510.000000 3985.000000) nil) | 0@@list("D4CB86" "MX_C0402_SMALL_T01" list(8210.000000 9220.000000) nil) | 0@@list("D4CB87" "MX_C0402_SMALL_T01" list(6520.000000 8920.000000) nil) | 0@@list("D4CB88" "MX_C0603_SMALL_T02" list(5146.000000 6144.000000) nil) | 0@@list("D4CB89" "MX_C0603_SMALL_T02" list(5146.000000 6090.000000) nil) | 0@@list("D4CB9" "MX_C0603_SMALL_T01" list(8172.000000 6085.000000) nil) | 0@@list("D4R1" "MX_R0402_SMALL_T01" list(7510.000000 6232.000000) nil) | 0@@list("D4R10" "MX_R0402_SMALL_T01" list(7510.000000 6300.000000) nil) | 0@@list("D4R15" "MX_R0402_SMALL_T01" list(7510.000000 6375.000000) nil) | 0@@list("D4R20" "MX_R0402_SMALL_T01" list(8195.000000 9076.000000) nil) | 0@@list("D4R21" "MX_R0402_SMALL_T01" list(8145.000000 9160.000000) nil) | 0@@list("D4R24" "MX_R0402_SMALL_T01" list(8145.000000 6313.000000) nil) | 0@@list("D4R3" "MX_R0402_SMALL_T01" list(8160.500000 7185.280000) nil) | 0@@list("D4R30" "MX_R0402_SMALL_T01" list(8195.000000 9112.000000) nil) | 0@@list("D4R31" "MX_R0402_SMALL_T01" list(8160.000000 9235.000000) nil) | 0@@list("D4R32" "MX_R0402_SMALL_T01" list(6600.000000 8920.000000) nil) | 0@@list("D4R33" "MX_R0402_SMALL_T01" list(6740.000000 9022.000000) nil) | 0@@list("D4R34" "MX_R0402_SMALL_T01" list(6560.000000 8920.000000) nil) | 0@@list("D4R35" "MX_R0402_SMALL_T01" list(6480.000000 8920.000000) nil) | 0@@list("EC22" "MX_C0201" list(9065.000000 6755.000000) nil) | 0@@list("ECC55" "MX_C0402_SMALL_T01" list(5225.000000 3780.000000) nil) | 0@@list("ECC56" "MX_C0402_SMALL_T01" list(5093.000000 3641.000000) nil) | 0@@list("ECR101" "MX_R0402_SMALL_T01" list(8594.000000 768.000000) nil) | 0@@list("ECR104" "MX_R0402_SMALL_T01" list(8894.000000 995.500000) nil) | 0@@list("ECR105" "MX_R0402_SMALL_T01" list(5129.000000 3641.000000) nil) | 0@@list("ECR67" "MX_R0402_SMALL_T01" list(8068.000000 948.000000) nil) | 0@@list("ECR90" "MX_R0402_SMALL_T01" list(4880.000000 3700.000000) nil) | 0@@list("ECR92" "MX_R0402_SMALL_T01" list(5189.000000 3780.000000) nil) | 0@@list("ECR96" "MX_R0402_SMALL_T01" list(8758.500000 1705.000000) nil) | 0@@list("ECR97" "MX_R0402_SMALL_T01" list(8038.000000 986.000000) nil) | 0@@list("ECR98" "MX_R0402_SMALL_T01" list(8879.500000 1386.000000) nil) | 0@@list("F3CB1" "MX_C0402_SMALL_T01" list(7322.000000 348.240000) nil) | 0@@list("F3CB3" "MX_C0402_SMALL_T01" list(7019.500000 432.000000) nil) | 0@@list("F3CB4" "MX_C0201" list(6985.000000 435.000000) nil) | 0@@list("F3R10" "MX_R0402_SMALL_T01" list(7144.000000 365.000000) nil) | 0@@list("F3R12" "MX_R0402_SMALL_T01" list(6880.000000 191.000000) nil) | 0@@list("F3R13" "MX_R0402_SMALL_T01" list(7216.500000 365.000000) nil) | 0@@list("F3R14" "MX_R0402_SMALL_T01" list(7355.000000 915.000000) nil) | 0@@list("F3R20" "MX_R0402_SMALL_T01" list(7317.000000 915.000000) nil) | 0@@list("F3R21" "MX_R0402_SMALL_T01" list(7191.000000 870.000000) nil) | 0@@list("F3R3" "MX_R0402_SMALL_T01" list(6965.000000 341.000000) nil) | 0@@list("F3R4" "MX_R0402_SMALL_T01" list(7374.000000 365.000000) nil) | 0@@list("F3R6" "MX_R0402_SMALL_T01" list(6940.000000 510.000000) nil) | 0@@list("F3R7" "MX_R0402_SMALL_T01" list(7238.000000 870.000000) nil) | 0@@list("F3R8" "MX_R0402_SMALL_T01" list(7393.000000 832.510000) nil) | 0@@list("FC13" "MX_C0805_SMALL_T02" list(733.000000 6047.000000) nil) | 0@@list("FC14" "MX_C0402_SMALL_T01" list(9235.000000 8587.000000) nil) | 0@@list("FC15" "MX_C0402_SMALL_T01" list(5481.000000 9393.000000) nil) | 0@@list("FC16" "MX_C0402_SMALL_T01" list(4519.000000 9365.000000) nil) | 0@@list("FC2" "MX_C0402_SMALL_T01" list(5131.000000 9193.000000) nil) | 0@@list("FC3" "MX_C0402_SMALL_T01" list(5340.000000 9230.000000) nil) | 0@@list("FC5" "MX_C0402_SMALL_T01" list(9217.000000 8887.000000) nil) | 0@@list("FC6" "MX_C0402_SMALL_T01" list(9156.000000 8924.000000) nil) | 0@@list("FC8" "MX_C0402_SMALL_T01" list(7559.800000 1969.500000) nil) | 0@@list("FCE1" "MX_C1206_H75" list(4442.000000 9336.000000) nil) | 0@@list("FCE4" "MX_C1206_H75" list(5651.000000 9359.000000) nil) | 0@@list("FCE5" "MX_C1206_H75" list(9155.000000 8703.000000) nil) | 0@@list("FR1" "MX_R0402_SMALL_T01" list(5380.000000 9230.000000) nil) | 0@@list("FR17" "MX_R0402_SMALL_T01" list(5340.000000 9165.000000) nil) | 0@@list("FR2" "MX_R0805_SMALL_T02" list(5280.000000 9206.000000) nil) | 0@@list("FR28" "MX_R0805_SMALL_T02" list(9223.000000 8977.000000) nil) | 0@@list("FR29" "MX_R0402_SMALL_T01" list(9092.000000 8924.000000) nil) | 0@@list("FR30" "MX_R0402_SMALL_T01" list(9225.000000 9052.000000) nil) | 0@@list("FR31" "MX_R0402_SMALL_T01" list(9072.000000 8990.000000) nil) | 0@@list("FR32" "MX_R0805_SMALL_T02" list(5845.000000 9225.000000) nil) | 0@@list("FR33" "MX_R0402_SMALL_T01" list(5680.000000 9232.000000) nil) | 0@@list("FR35" "MX_R0402_SMALL_T01" list(5640.000000 9182.000000) nil) | 0@@list("FR36" "MX_R0402_SMALL_T01" list(5146.000000 9246.000000) nil) | 0@@list("FR37" "MX_R0402_SMALL_T01" list(3615.500000 499.500000) nil) | 0@@list("FR8" "MX_R0402_SMALL_T01" list(5380.000000 9165.000000) nil) | 0@@list("H13" "MX_SMT_NUT_CT276B195D165" list(1443.720000 3542.560000) nil) | 0@@list("H14" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 2888.890000) nil) | 0@@list("H15" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 3676.290000) nil) | 0@@list("H16" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 2180.230000) nil) | 0@@list("H20" "MX_NUT_CT256BD146_H71" list(3763.810000 8731.590000) nil) | 0@@list("H21" "MX_NUT_CT256BD146_H71" list(2359.030000 8301.710000) nil) | 0@@list("H22" "MX_NUT_CT256BD146_H71" list(5858.300000 8731.590000) nil) | 0@@list("H23" "MX_NUT_CT256BD146_H71" list(2359.030000 5199.350000) nil) | 0@@list("H4" "MX_HOLE_160_T_HP" list(6500.000000 3150.000000) nil) | 0@@list("H5" "MX_HOLE_160_T_HP" list(6500.000000 550.000000) nil) | 0@@list("HC11" "MX_C0402_SMALL_T01" list(6986.000000 1121.000000) nil) | 0@@list("HC23" "MX_C0402_SMALL_T01" list(4013.000000 4646.000000) nil) | 0@@list("HC24" "MX_C0402_SMALL_T01" list(3672.000000 8126.500000) nil) | 0@@list("HC25" "MX_C0402_SMALL_T01" list(5220.000000 4446.000000) nil) | 0@@list("HC27" "MX_C0402_SMALL_T01" list(5109.000000 5986.000000) nil) | 0@@list("HC29" "MX_C0402_SMALL_T01" list(8116.000000 2116.000000) nil) | 0@@list("HC3" "MX_C0603_SMALL_T02" list(5164.000000 4589.000000) nil) | 0@@list("HC30" "MX_C0402_SMALL_T01" list(523.000000 2842.000000) nil) | 0@@list("HC31" "MX_C0402_SMALL_T01" list(241.000000 1645.000000) nil) | 0@@list("HC4" "MX_C0402_SMALL_T01" list(5068.000000 4612.120000) nil) | 0@@list("HC5" "MX_C0402_SMALL_T01" list(4005.000000 4795.000000) nil) | 0@@list("HR11" "MX_R0402_SMALL_T01" list(3875.000000 5580.000000) nil) | 0@@list("HR14" "MX_R0402_SMALL_T01" list(3875.500000 5708.000000) nil) | 0@@list("HR15" "MX_R0402_SMALL_T01" list(3875.500000 5672.000000) nil) | 0@@list("HR17" "MX_R0402_SMALL_T01" list(3524.000000 8207.000000) nil) | 0@@list("HR18" "MX_R0402_SMALL_T01" list(3600.000000 8127.000000) nil) | 0@@list("HR20" "MX_R0402_SMALL_T01" list(3564.000000 8127.000000) nil) | 0@@list("HR22" "MX_R0402_T01" list(3999.800000 4891.300000) nil) | 0@@list("HR23" "MX_R0402_SMALL_T01" list(3955.000000 4800.000000) nil) | 0@@list("HR24" "MX_R0402_SMALL_T01" list(3640.000000 8207.000000) nil) | 0@@list("HR25" "MX_R0402_SMALL_T01" list(3958.000000 4714.000000) nil) | 0@@list("HR26" "MX_R0402_SMALL_T01" list(3636.000000 8127.000000) nil) | 0@@list("HR27" "MX_R0402_SMALL_T01" list(4045.000000 4795.000000) nil) | 0@@list("HR28" "MX_R0402_SMALL_T01" list(6027.000000 1713.000000) nil) | 0@@list("HR29" "MX_R0402_SMALL_T01" list(4060.000000 4645.000000) nil) | 0@@list("HR31" "MX_R0402_SMALL_T01" list(4719.000000 6044.000000) nil) | 0@@list("HR32" "MX_R0402_SMALL_T01" list(3604.000000 8207.000000) nil) | 0@@list("HR33" "MX_R0402_SMALL_T01" list(3564.000000 8207.000000) nil) | 0@@list("HR36" "MX_R0402_SMALL_T01" list(3738.500000 4674.000000) nil) | 0@@list("HR4" "MX_R0402_SMALL_T01" list(4719.000000 6007.000000) nil) | 0@@list("HR6" "MX_R0402_SMALL_T01" list(4719.000000 5971.000000) nil) | 0@@list("HR615" "MX_R0402_SMALL_T01" list(3765.000000 4700.000000) nil) | 0@@list("HR616" "MX_R0402_SMALL_T01" list(3792.500000 4748.000000) nil) | 0@@list("HR617" "MX_R0402_SMALL_T01" list(3828.500000 4748.000000) nil) | 0@@list("HR618" "MX_R0402_SMALL_T01" list(3870.000000 4690.000000) nil) | 0@@list("HR619" "MX_R0402_SMALL_T01" list(4058.800000 4557.700000) nil) | 0@@list("HR620" "MX_R0402_SMALL_T01" list(3978.000000 4584.000000) nil) | 0@@list("HR621" "MX_R0402_SMALL_T01" list(3942.000000 4631.000000) nil) | 0@@list("HR622" "MX_R0402_SMALL_T01" list(3906.000000 4653.000000) nil) | 0@@list("HR626" "MX_R0402_SMALL_T01" list(3925.000000 4280.000000) nil) | 0@@list("HR627" "MX_R0402_SMALL_T01" list(7430.000000 1735.000000) nil) | 0@@list("HR629" "MX_R0402_SMALL_T01" list(7404.060000 1836.930000) nil) | 0@@list("HR630" "MX_R0402_SMALL_T01" list(4758.000000 4722.000000) nil) | 0@@list("HR631" "MX_R0402_SMALL_T01" list(5391.000000 8289.000000) nil) | 0@@list("HR78" "MX_R0402_SMALL_T01" list(4082.000000 4795.000000) nil) | 0@@list("HR86" "MX_R0402_SMALL_T01" list(4014.000000 4557.000000) nil) | 0@@list("HR9" "MX_R0402_SMALL_T01" list(3898.000000 5471.000000) nil) | 0@@list("L1" "MX_L0603_SMALL_T02" list(1595.000000 8285.000000) nil) | 0@@list("L2" "MX_L0603_SMALL_T02" list(1355.000000 8825.000000) nil) | 0@@list("LC10" "MX_C0402_SMALL_T01" list(1421.000000 8293.000000) nil) | 0@@list("LC12" "MX_C0402_SMALL_T01" list(1106.000000 8149.000000) nil) | 0@@list("LC18" "MX_C0402_SMALL_T01" list(1505.000000 8680.000000) nil) | 0@@list("LC4" "MX_C0402_SMALL_T01" list(1253.000000 8765.000000) nil) | 0@@list("LC44" "MX_C0402_SMALL_T01" list(980.000000 8665.000000) nil) | 0@@list("LC47" "MX_C0402_SMALL_T01" list(1585.000000 8470.000000) nil) | 0@@list("LC48" "MX_C0402_SMALL_T01" list(1585.000000 8506.000000) nil) | 0@@list("LC5" "MX_C0402_SMALL_T01" list(1179.000000 8765.000000) nil) | 0@@list("LC6" "MX_C0402_SMALL_T01" list(1223.000000 8140.000000) nil) | 0@@list("LC7" "MX_C0402_SMALL_T01" list(1650.000000 8652.000000) nil) | 0@@list("LC8" "MX_C0402_SMALL_T01" list(1020.000000 8665.000000) nil) | 0@@list("LC9" "MX_C0402_SMALL_T01" list(1457.000000 8293.000000) nil) | 0@@list("LCB10" "MX_C0201" list(1602.000000 8432.000000) nil) | 0@@list("LCB11" "MX_C0402_SMALL_T01" list(1185.000000 8685.000000) nil) | 0@@list("LCB12" "MX_C0201" list(1315.000000 8275.000000) nil) | 0@@list("LCB13" "MX_C0603_SMALL_T01" list(1595.000000 8353.000000) nil) | 0@@list("LCB14" "MX_C0201" list(1210.000000 8395.000000) nil) | 0@@list("LCB15" "MX_C0402_SMALL_T01" list(1187.000000 8543.000000) nil) | 0@@list("LCB16" "MX_C0603_SMALL_T01" list(1585.000000 8795.000000) nil) | 0@@list("LCB17" "MX_C0201" list(1574.000000 8676.000000) nil) | 0@@list("LCB18" "MX_C0402_SMALL_T01" list(1574.000000 8640.000000) nil) | 0@@list("LCB19" "MX_C0402_SMALL_T01" list(1602.000000 8395.000000) nil) | 0@@list("LCB2" "MX_C0402_SMALL_T01" list(1574.000000 8750.000000) nil) | 0@@list("LCB20" "MX_C0201" list(1315.000000 8315.000000) nil) | 0@@list("LCB21" "MX_C0201" list(1556.000000 8561.000000) nil) | 0@@list("LCB22" "MX_C0402_SMALL_T01" list(1612.000000 8565.000000) nil) | 0@@list("LCB3" "MX_C0603_SMALL_T01" list(1585.000000 8845.000000) nil) | 0@@list("LCB4" "MX_C0201" list(1223.000000 8485.000000) nil) | 0@@list("LCB5" "MX_C0402_SMALL_T01" list(1574.000000 8713.000000) nil) | 0@@list("LCB6" "MX_C0201" list(1515.000000 8336.000000) nil) | 0@@list("LCB7" "MX_C0201" list(1374.000000 8680.000000) nil) | 0@@list("LCB9" "MX_C0201" list(1515.000000 8300.000000) nil) | 0@@list("LR1" "MX_R0402_SMALL_T01" list(1505.000000 8794.000000) nil) | 0@@list("LR10" "MX_R0402_SMALL_T01" list(1375.000000 8290.000000) nil) | 0@@list("LR2" "MX_R0402_SMALL_T01" list(1407.000000 8794.500000) nil) | 0@@list("LR20" "MX_R0402_SMALL_T01" list(940.000000 8665.000000) nil) | 0@@list("LR22" "MX_R0402_SMALL_T01" list(1183.000000 8728.000000) nil) | 0@@list("LR23" "MX_R0402_SMALL_T01" list(1407.000000 8680.000000) nil) | 0@@list("LR24" "MX_R0402_SMALL_T01" list(1185.000000 8625.000000) nil) | 0@@list("LR3" "MX_R0402_SMALL_T01" list(1070.000000 8665.000000) nil) | 0@@list("LR4" "MX_R0603_SMALL_T01" list(1202.000000 8092.000000) nil) | 0@@list("LR5" "MX_R0603_SMALL_T01" list(1328.000000 8110.000000) nil) | 0@@list("LR6" "MX_R0402_SMALL_T01" list(1465.000000 8680.000000) nil) | 0@@list("LR9" "MX_R0402_SMALL_T01" list(1687.000000 8652.000000) nil) | 0@@list("M1C1" "MX_C0201" list(513.000000 6907.000000) nil) | 0@@list("M1C12" "MX_C0402_SMALL_T01" list(1400.000000 6896.000000) nil) | 0@@list("M1C13" "MX_C0402_SMALL_T01" list(1400.000000 6860.000000) nil) | 0@@list("M1C35" "MX_C0201" list(770.000000 6690.000000) nil) | 0@@list("M1D1" "MX_S0402_AMAZ_COLAY" list(660.000000 6710.000000) nil) | 0@@list("M1F1" "MX_POLYSWITCH_2P_0805_H30" list(693.500000 6923.000000) nil) | 0@@list("M1R11" "MX_R0402_SMALL_T01" list(1140.000000 6850.000000) nil) | 0@@list("M1R12" "MX_R0402_SMALL_T01" list(908.000000 6874.000000) nil) | 0@@list("M1R13" "MX_R0402_SMALL_T01" list(908.000000 6829.000000) nil) | 0@@list("M1R36" "MX_R0402_SMALL_T01" list(770.000000 6726.000000) nil) | 0@@list("M1R37" "MX_R0402_SMALL_T01" list(583.600000 6702.800000) nil) | 0@@list("M1R4" "MX_R0402_SMALL_T01" list(1534.000000 7035.000000) nil) | 0@@list("M1R40" "MX_R0402_SMALL_T01" list(5355.000000 3780.000000) nil) | 0@@list("M1R5" "MX_R0402_SMALL_T01" list(1440.000000 6975.000000) nil) | 0@@list("M1R8" "MX_R0402_SMALL_T01" list(1211.000000 6950.000000) nil) | 0@@list("M1U1" "MX_ESD_10P_20_98X39_NXP" list(621.000000 6459.000000) nil) | 0@@list("M1U2" "MX_ESD_10P_20_98X39_NXP" list(621.000000 6601.000000) nil) | 0@@list("M1U3" "MX_ESD_10P_20_98X39_NXP" list(1111.000000 7727.000000) nil) | 0@@list("M1U4" "MX_ESD_10P_20_98X39_NXP" list(986.180000 7147.240000) nil) | 0@@list("M1U5" "MX_ESD_10P_20_98X39_NXP" list(986.440000 7276.500000) nil) | 0@@list("M1U6" "MX_ESD_10P_20_98X39_NXP" list(442.000000 4688.000000) nil) | 0@@list("M1U7" "MX_ESD_10P_20_98X39_NXP" list(732.000000 4700.000000) nil) | 0@@list("M1U8" "MX_ESD_10P_20_98X39_NXP" list(1012.000000 8507.000000) nil) | 0@@list("M1U9" "MX_ESD_10P_20_98X39_NXP" list(1114.000000 8336.000000) nil) | 0@@list("M2C1" "MX_C0603_SMALL_T02" list(2002.500000 4556.000000) nil) | 0@@list("M2C13" "MX_C0603_SMALL_T02" list(8007.000000 628.000000) nil) | 0@@list("M2C14" "MX_C0201" list(8816.000000 784.210000) nil) | 0@@list("M2C15" "MX_C0402_SMALL_T01" list(8851.920000 784.210000) nil) | 0@@list("M2C16" "MX_C0603_SMALL_T02" list(8007.000000 575.000000) nil) | 0@@list("M2C17" "MX_C0201" list(8921.790000 783.960000) nil) | 0@@list("M2C18" "MX_C0402_SMALL_T01" list(8958.000000 784.000000) nil) | 0@@list("M2C19" "MX_C0603_SMALL_T02" list(8754.000000 778.000000) nil) | 0@@list("M2C2" "MX_C0201" list(982.000000 4598.000000) nil) | 0@@list("M2C20" "MX_C0201" list(8112.000000 695.000000) nil) | 0@@list("M2C21" "MX_C0402_SMALL_T01" list(8014.000000 676.000000) nil) | 0@@list("M2C22" "MX_C0402_SMALL_T01" list(8517.430000 339.530000) nil) | 0@@list("M2C23" "MX_C0402_SMALL_T01" list(8481.430000 339.530000) nil) | 0@@list("M2C24" "MX_C0402_SMALL_T01" list(8598.870000 340.530000) nil) | 0@@list("M2C25" "MX_C0402_SMALL_T01" list(8634.870000 340.530000) nil) | 0@@list("M2C26" "MX_C0402_SMALL_T01" list(8716.020000 340.530000) nil) | 0@@list("M2C27" "MX_C0402_SMALL_T01" list(8752.020000 340.530000) nil) | 0@@list("M2C28" "MX_C0402_SMALL_T01" list(8836.360000 340.530000) nil) | 0@@list("M2C29" "MX_C0402_SMALL_T01" list(8872.360000 340.530000) nil) | 0@@list("M2C3" "MX_C0402_SMALL_T01" list(910.000000 4597.000000) nil) | 0@@list("M2C4" "MX_C0603_SMALL_T02" list(866.000000 4171.000000) nil) | 0@@list("M2C40" "MX_C0402_SMALL_T01" list(1939.000000 4822.000000) nil) | 0@@list("M2C41" "MX_C0402_SMALL_T01" list(1939.000000 4861.000000) nil) | 0@@list("M2C44" "MX_C0402_SMALL_T01" list(8361.000000 325.000000) nil) | 0@@list("M2C46" "MX_C0402_SMALL_T01" list(2008.000000 4637.000000) nil) | 0@@list("M2C47" "MX_C0402_SMALL_T01" list(2008.000000 4683.000000) nil) | 0@@list("M2C48" "MX_C0402_SMALL_T01" list(2097.000000 4671.000000) nil) | 0@@list("M2C49" "MX_C0402_SMALL_T01" list(1958.000000 4598.000000) nil) | 0@@list("M2C5" "MX_C0201" list(1922.000000 4598.000000) nil) | 0@@list("M2C50" "MX_C0402_SMALL_T01" list(878.000000 4219.000000) nil) | 0@@list("M2C51" "MX_C0402_SMALL_T01" list(8070.000000 693.000000) nil) | 0@@list("M2C52" "MX_C0402_SMALL_T01" list(8119.000000 551.000000) nil) | 0@@list("M2C53" "MX_C0402_SMALL_T01" list(1939.000000 4765.000000) nil) | 0@@list("M2C54" "MX_C0402_SMALL_T01" list(8252.000000 325.000000) nil) | 0@@list("M2C55" "MX_C0402_SMALL_T01" list(8079.000000 552.000000) nil) | 0@@list("M2C6" "MX_C0402_SMALL_T01" list(946.000000 4598.000000) nil) | 0@@list("M2R1" "MX_R0402_SMALL_T01" list(8180.000000 325.000000) nil) | 0@@list("M2R33" "MX_R0402_SMALL_T01" list(8216.000000 325.000000) nil) | 0@@list("M2R34" "MX_R0402_SMALL_T01" list(8288.000000 325.000000) nil) | 0@@list("M2R36" "MX_R0402_SMALL_T01" list(8325.000000 325.000000) nil) | 0@@list("M2R39" "MX_R0402_SMALL_T01" list(1267.000000 4954.000000) nil) | 0@@list("M2R4" "MX_R0402_SMALL_T01" list(1730.000000 4960.000000) nil) | 0@@list("M2R40" "MX_R0402_SMALL_T01" list(2487.000000 2959.000000) nil) | 0@@list("M2R41" "MX_R0402_SMALL_T01" list(2510.000000 2160.000000) nil) | 0@@list("M2R43" "MX_R0402_SMALL_T01" list(2498.000000 1364.000000) nil) | 0@@list("M2R44" "MX_R0402_SMALL_T01" list(2451.000000 625.000000) nil) | 0@@list("M2R46" "MX_R0402_SMALL_T01" list(1939.000000 4685.000000) nil) | 0@@list("M2R47" "MX_R0402_SMALL_T01" list(1939.000000 4649.000000) nil) | 0@@list("M2R52" "MX_R0402_SMALL_T01" list(907.000000 6065.000000) nil) | 0@@list("M2R54" "MX_R0402_SMALL_T01" list(1695.000000 4960.000000) nil) | 0@@list("MR41" "MX_R0402_SMALL_T01" list(515.000000 6770.000000) nil) | 0@@list("O2C1" "MX_C0402_SMALL_T01" list(8915.000000 1159.000000) nil) | 0@@list("O2C2" "MX_C0402_SMALL_T01" list(2637.000000 2802.000000) nil) | 0@@list("O2C4" "MX_C0402_SMALL_T01" list(8966.000000 2946.000000) nil) | 0@@list("O2C5" "MX_C0402_SMALL_T01" list(8884.000000 1115.000000) nil) | 0@@list("O2CB1" "MX_C0201" list(8040.000000 1167.000000) nil) | 0@@list("O2CB10" "MX_C0201" list(8671.000000 865.000000) nil) | 0@@list("O2CB11" "MX_C0201" list(8635.000000 870.000000) nil) | 0@@list("O2CB12" "MX_C0402_SMALL_T01" list(8039.000000 1094.000000) nil) | 0@@list("O2CB15" "MX_C0402_SMALL_T01" list(8910.000000 959.500000) nil) | 0@@list("O2CB16" "MX_C0201" list(8834.000000 870.000000) nil) | 0@@list("O2CB17" "MX_C0201" list(8540.000000 1705.000000) nil) | 0@@list("O2CB19" "MX_C0201" list(8950.000000 1283.000000) nil) | 0@@list("O2CB2" "MX_C0201" list(8870.000000 870.000000) nil) | 0@@list("O2CB20" "MX_C0201" list(8889.000000 1235.000000) nil) | 0@@list("O2CB3" "MX_C0201" list(8764.000000 1655.000000) nil) | 0@@list("O2CB4" "MX_C0201" list(8853.000000 1235.000000) nil) | 0@@list("O2CB5" "MX_C0201" list(8877.140000 1458.730000) nil) | 0@@list("O2CB6" "MX_C0201" list(8877.140000 1494.730000) nil) | 0@@list("O2CB7" "MX_C0201" list(8580.000000 870.000000) nil) | 0@@list("O2CB8" "MX_C0201" list(8181.000000 868.000000) nil) | 0@@list("O2R1" "MX_R0402_SMALL_T01" list(8743.000000 865.000000) nil) | 0@@list("O2R10" "MX_R0402_SMALL_T01" list(8910.000000 923.000000) nil) | 0@@list("O2R11" "MX_R0402_SMALL_T01" list(8675.000000 1885.000000) nil) | 0@@list("O2R2" "MX_R0402_SMALL_T01" list(8986.000000 1283.000000) nil) | 0@@list("O2R20" "MX_R0402_SMALL_T01" list(8577.000000 1705.000000) nil) | 0@@list("O2R21" "MX_R0402_SMALL_T01" list(8120.000000 1805.000000) nil) | 0@@list("O2R22" "MX_R0402_SMALL_T01" list(9006.000000 1333.000000) nil) | 0@@list("O2R3" "MX_R0402_SMALL_T01" list(8536.000000 1892.000000) nil) | 0@@list("O2R5" "MX_R0402_SMALL_T01" list(8879.500000 1422.000000) nil) | 0@@list("O2R8" "MX_R0402_SMALL_T01" list(8600.000000 1892.000000) nil) | 0@@list("O3R5" "MX_R0402_SMALL_T01" list(2357.000000 418.810000) nil) | 0@@list("OR22" "MX_R0402_SMALL_T01" list(8040.000000 1218.000000) nil) | 0@@list("OR29" "MX_R0402_SMALL_T01" list(7973.000000 989.000000) nil) | 0@@list("OR3" "MX_R0402_SMALL_T01" list(8797.000000 865.000000) nil) | 0@@list("OR34" "MX_R0402_SMALL_T01" list(8040.000000 1058.000000) nil) | 0@@list("OR35" "MX_R0402_SMALL_T01" list(8039.500000 1354.000000) nil) | 0@@list("OR37" "MX_R0402_SMALL_T01" list(8536.000000 1793.500000) nil) | 0@@list("OR44" "MX_R0402_SMALL_T01" list(8038.000000 1022.000000) nil) | 0@@list("OR5" "MX_R0402_SMALL_T01" list(8475.000000 768.000000) nil) | 0@@list("OR51" "MX_R0402_SMALL_T01" list(8181.000000 2116.000000) nil) | 0@@list("OR52" "MX_R0402_SMALL_T01" list(8180.000000 1935.000000) nil) | 0@@list("OR53" "MX_R0402_SMALL_T01" list(8358.000000 1705.000000) nil) | 0@@list("OR56" "MX_R0402_SMALL_T01" list(8686.000000 1704.500000) nil) | 0@@list("OR57" "MX_R0402_SMALL_T01" list(8614.000000 1704.500000) nil) | 0@@list("OR59" "MX_R0402_SMALL_T01" list(8943.000000 1387.000000) nil) | 0@@list("OR6" "TX_R0402" list(8475.000000 804.000000) nil) | 0@@list("OR60" "MX_R0402_SMALL_T01" list(8395.000000 1705.000000) nil) | 0@@list("OR61" "MX_R0402_SMALL_T01" list(8467.000000 1705.000000) nil) | 0@@list("OR65" "MX_R0402_SMALL_T01" list(8180.000000 1870.000000) nil) | 0@@list("OR68" "MX_R0402_SMALL_T01" list(8392.000000 1946.000000) nil) | 0@@list("OR69" "MX_R0402_SMALL_T01" list(8339.000000 1929.000000) nil) | 0@@list("OR70" "MX_R0402_SMALL_T01" list(8059.000000 290.200000) nil) | 0@@list("P1C2" "MX_C0402_SMALL_T01" list(9255.000000 5835.000000) nil) | 0@@list("P1CB1" "MX_C0402_SMALL_T01" list(9050.000000 7645.000000) nil) | 0@@list("P1CB10" "MX_C0402_SMALL_T01" list(2470.000000 8620.000000) nil) | 0@@list("P1CB11" "MX_C0402_SMALL_T01" list(2470.000000 8660.000000) nil) | 0@@list("P1CB12" "MX_C0402_SMALL_T01" list(9063.000000 6545.000000) nil) | 0@@list("P1CB13" "MX_C1206_H75" list(1963.000000 7933.000000) nil) | 0@@list("P1CB14" "MX_C1206_H75" list(2015.000000 6436.000000) nil) | 0@@list("P1CB15" "MX_C1206_H75" list(2015.000000 6336.000000) nil) | 0@@list("P1CB16" "MX_C1206_H75" list(1966.000000 7192.000000) nil) | 0@@list("P1CB17" "MX_C0402_SMALL_T01" list(2470.000000 8582.000000) nil) | 0@@list("P1CB2" "MX_C0201" list(9029.000000 7335.000000) nil) | 0@@list("P1CB3" "MX_C0201" list(9050.000000 7915.000000) nil) | 0@@list("P1CB4" "MX_C0201" list(9042.000000 5954.000000) nil) | 0@@list("P1CB5" "MX_C0402_SMALL_T01" list(9063.000000 6421.000000) nil) | 0@@list("P1CB8" "MX_C0402_SMALL_T01" list(9042.000000 5918.000000) nil) | 0@@list("P1R1" "MX_R0402_SMALL_T01" list(9065.000000 6625.000000) nil) | 0@@list("P1R2" "MX_R0402_SMALL_T01" list(9255.000000 5755.000000) nil) | 0@@list("P1R3" "MX_R0402_SMALL_T01" list(9254.990000 5795.000000) nil) | 0@@list("P1R4" "MX_R0402_SMALL_T01" list(9065.000000 6690.000000) nil) | 0@@list("PC10" "MX_C0603_SMALL_T02" list(4835.760000 6573.000000) nil) | 0@@list("PC118" "MX_C0805_SMALL_T02" list(8295.000000 5055.000000) nil) | 0@@list("PC121" "MX_C0402_SMALL_T01" list(2058.000000 4870.000000) nil) | 0@@list("PC122" "MX_C0402_SMALL_T01" list(8395.000000 5061.000000) nil) | 0@@list("PC126" "MX_C0402_SMALL_T01" list(8443.000000 4915.000000) nil) | 0@@list("PC13" "MX_C0201" list(2178.000000 4790.000000) nil) | 0@@list("PC131" "MX_C0603_SMALL_T01" list(8426.620000 5241.240000) nil) | 0@@list("PC132" "MX_C0603_SMALL_T01" list(9405.620000 8325.960000) nil) | 0@@list("PC133" "MX_C0402_SMALL_T01" list(5349.000000 4312.000000) nil) | 0@@list("PC137" "MX_C1206_H75" list(2604.000000 5081.000000) nil) | 0@@list("PC138" "MX_C1206_H75" list(2598.000000 5280.000000) nil) | 0@@list("PC142" "MX_C0603_SMALL_T02" list(3112.000000 5339.000000) nil) | 0@@list("PC149" "MX_C0603_SMALL_T02" list(5047.000000 5980.000000) nil) | 0@@list("PC15" "MX_C0603_SMALL_T01" list(4855.000000 3830.000000) nil) | 0@@list("PC150" "MX_C0603_SMALL_T01" list(5275.000000 4000.000000) nil) | 0@@list("PC151" "MX_C0603_SMALL_T01" list(5060.000000 3895.000000) nil) | 0@@list("PC152" "MX_C0402_SMALL_T01" list(5319.000000 3780.000000) nil) | 0@@list("PC153" "MX_C0402_SMALL_T01" list(4925.000000 4060.000000) nil) | 0@@list("PC154" "MX_C0402_SMALL_T01" list(5115.000000 3765.000000) nil) | 0@@list("PC155" "MX_C0402_SMALL_T01" list(5170.000000 3895.000000) nil) | 0@@list("PC156" "MX_C0603_SMALL_T02" list(4835.000000 3970.000000) nil) | 0@@list("PC157" "MX_C0603_SMALL_T02" list(4780.000000 3970.000000) nil) | 0@@list("PC158" "MX_C0402_SMALL_T01" list(5190.000000 3845.000000) nil) | 0@@list("PC159" "MX_C0402_SMALL_T01" list(5185.000000 3950.000000) nil) | 0@@list("PC160" "MX_C0402_SMALL_T01" list(4926.000000 3910.000000) nil) | 0@@list("PC161" "MX_C0603_SMALL_T02" list(4965.000000 4268.000000) nil) | 0@@list("PC162" "MX_C0603_SMALL_T02" list(4965.000000 4320.000000) nil) | 0@@list("PC163" "MX_C0603_SMALL_T02" list(4780.000000 6000.000000) nil) | 0@@list("PC164" "MX_C0603_SMALL_T02" list(4835.000000 6000.000000) nil) | 0@@list("PC193" "MX_C0603_SMALL_T02" list(8269.000000 4423.000000) nil) | 0@@list("PC194" "MX_C0603_SMALL_T02" list(8432.000000 4405.000000) nil) | 0@@list("PC205" "MX_C1206" list(7950.000000 3732.000000) nil) | 0@@list("PC206" "MX_C1206" list(7950.000000 3636.000000) nil) | 0@@list("PC207" "MX_C0805_SMALL_T02" list(7905.000000 3550.000000) nil) | 0@@list("PC208" "MX_C0603_SMALL_T01" list(8681.000000 4392.000000) nil) | 0@@list("PC209" "MX_C0402_SMALL_T01" list(7458.000000 3601.000000) nil) | 0@@list("PC210" "MX_C0603_SMALL_T01" list(7713.000000 3623.000000) nil) | 0@@list("PC211" "MX_C0402_SMALL_T01" list(8127.870000 3516.920000) nil) | 0@@list("PC212" "MX_C0603_SMALL_T01" list(7705.000000 3550.000000) nil) | 0@@list("PC213" "MX_C0603_SMALL_T01" list(7972.000000 2571.000000) nil) | 0@@list("PC214" "MX_C0603" list(8155.000000 3410.000000) nil) | 0@@list("PC215" "MX_C0402_SMALL_T01" list(7970.000000 3250.000000) nil) | 0@@list("PC217" "MX_C0402_SMALL_T01" list(7448.000000 3529.000000) nil) | 0@@list("PC218" "MX_C0603_SMALL_T01" list(7379.000000 3575.000000) nil) | 0@@list("PC231" "MX_C0201" list(9062.000000 6320.000000) nil) | 0@@list("PC232" "MX_C0603_SMALL_T01" list(8975.000000 6520.000000) nil) | 0@@list("PC233" "MX_C0603_SMALL_T01" list(8990.000000 7490.000000) nil) | 0@@list("PC234" "MX_C0201" list(8905.000000 7700.000000) nil) | 0@@list("PC236" "MX_C0603_SMALL_T01" list(8900.000000 7490.000000) nil) | 0@@list("PC238" "MX_C0201" list(9065.000000 7335.000000) nil) | 0@@list("PC239" "MX_C0603_SMALL_T02" list(8855.000000 6520.000000) nil) | 0@@list("PC240" "MX_C0603_SMALL_T02" list(8855.000000 6465.000000) nil) | 0@@list("PC241" "MX_C0402_SMALL_T01" list(9045.000000 7265.000000) nil) | 0@@list("PC242" "MX_C0402_SMALL_T01" list(9220.000000 8010.880000) nil) | 0@@list("PC243" "MX_C0805_SMALL_T02" list(9327.000000 8099.000000) nil) | 0@@list("PC247" "MX_C0402_SMALL_T01" list(8980.000000 6440.000000) nil) | 0@@list("PC272" "MX_C0603_SMALL_T02" list(5112.000000 4589.000000) nil) | 0@@list("PC273" "MX_C0603_SMALL_T02" list(5176.000000 4480.380000) nil) | 0@@list("PC274" "MX_C0603_SMALL_T01" list(4869.000000 4604.000000) nil) | 0@@list("PC329" "MX_C0603_SMALL_T02" list(4908.000000 6035.000000) nil) | 0@@list("PC331" "MX_C0603_SMALL_T02" list(4908.000000 5980.000000) nil) | 0@@list("PC339" "MX_C0402_SMALL_T01" list(8569.500000 5722.000000) nil) | 0@@list("PC341" "MX_C0805_SMALL_T02" list(8570.000000 5359.000000) nil) | 0@@list("PC343" "MX_C0402_SMALL_T01" list(8075.000000 3350.000000) nil) | 0@@list("PC4" "MX_C0603_SMALL_T02" list(4730.000000 6570.000000) nil) | 0@@list("PC481" "MX_C0603_SMALL_T02" list(7512.000000 6457.000000) nil) | 0@@list("PC484" "MX_C0402_SMALL_T01" list(8182.000000 5716.000000) nil) | 0@@list("PC485" "MX_C0402_SMALL_T01" list(8234.000000 6105.000000) nil) | 0@@list("PC486" "MX_C0402_SMALL_T01" list(8594.000000 6204.000000) nil) | 0@@list("PC566" "MX_C0402_SMALL_T01" list(4725.000000 2210.000000) nil) | 0@@list("PC567" "MX_C0402_SMALL_T01" list(4536.800000 2089.900000) nil) | 0@@list("PC568" "MX_C0603_SMALL_T01" list(4578.000000 1955.000000) nil) | 0@@list("PC569" "MX_C0201" list(4579.000000 2210.000000) nil) | 0@@list("PC570" "MX_C0201" list(4616.000000 2210.000000) nil) | 0@@list("PC5801" "MX_C0201" list(2860.000000 8240.000000) nil) | 0@@list("PC5802" "MX_C0603_SMALL_T01" list(2885.000000 8335.000000) nil) | 0@@list("PC5803" "MX_C0603_SMALL_T01" list(2965.000000 8332.000000) nil) | 0@@list("PC5804" "MX_C0201" list(2995.000000 8215.000000) nil) | 0@@list("PC5805" "MX_C0603_SMALL_T01" list(2873.000000 8458.000000) nil) | 0@@list("PC5806" "MX_C0201" list(2788.000000 8405.000000) nil) | 0@@list("PC5807" "MX_C0603_SMALL_T01" list(3027.500000 8885.000000) nil) | 0@@list("PC5808" "MX_C0201" list(2988.000000 9005.000000) nil) | 0@@list("PC5809" "MX_C0603_SMALL_T01" list(3081.500000 8885.000000) nil) | 0@@list("PC5810" "MX_C0201" list(3096.000000 9005.000000) nil) | 0@@list("PC5811" "MX_C0603_SMALL_T01" list(3085.000000 8334.000000) nil) | 0@@list("PC5812" "MX_C0201" list(3036.000000 8217.000000) nil) | 0@@list("PC5813" "MX_C0402_SMALL_T01" list(2880.000000 8600.000000) nil) | 0@@list("PC5814" "MX_C0201" list(3559.000000 8755.000000) nil) | 0@@list("PC5815" "MX_C0402_SMALL_T01" list(3265.000000 8320.000000) nil) | 0@@list("PC5816" "MX_C0402_SMALL_T01" list(3170.000000 8400.000000) nil) | 0@@list("PC5817" "MX_C0402_SMALL_T01" list(3222.000000 8245.000000) nil) | 0@@list("PC5818" "MX_C0402_SMALL_T01" list(3150.000000 8245.000000) nil) | 0@@list("PC5819" "MX_C0402_SMALL_T01" list(3250.000000 8380.000000) nil) | 0@@list("PC5820" "MX_C0402_SMALL_T01" list(3272.500000 8900.000000) nil) | 0@@list("PC5821" "MX_C0402_SMALL_T01" list(3150.000000 8990.000000) nil) | 0@@list("PC5822" "MX_C0402_SMALL_T01" list(3225.000000 9007.000000) nil) | 0@@list("PC5823" "MX_C0402_SMALL_T01" list(3175.000000 8850.000000) nil) | 0@@list("PC5824" "MX_C0402_SMALL_T01" list(3240.000000 8850.000000) nil) | 0@@list("PC5825" "C0201" list(2793.000000 8550.000000) nil) | 0@@list("PC5826" "C0201" list(2865.000000 8940.000000) nil) | 0@@list("PC5827" "MX_C0603_SMALL_T01" list(3498.000000 8664.000000) nil) | 0@@list("PC5828" "MX_C0402_SMALL_T01" list(3400.000000 8881.000000) nil) | 0@@list("PC5829" "MX_C0603_SMALL_T01" list(3335.000000 8870.000000) nil) | 0@@list("PC5830" "MX_C0402_SMALL_T01" list(2865.000000 8730.000000) nil) | 0@@list("PC5901" "MX_C0603_SMALL_T01" list(2820.000000 7231.000000) nil) | 0@@list("PC5902" "MX_C0402_SMALL_T01" list(2514.000000 7203.000000) nil) | 0@@list("PC5903" "MX_C0603_SMALL_T01" list(2720.000000 7439.000000) nil) | 0@@list("PC5904" "MX_C0603_SMALL_T02" list(2910.000000 6838.000000) nil) | 0@@list("PC5905" "MX_C0402_SMALL_T01" list(2586.000000 7203.000000) nil) | 0@@list("PC5906" "MX_C0402_SMALL_T01" list(2580.000000 6770.000000) nil) | 0@@list("PC5907" "MX_C0402_SMALL_T01" list(2325.000000 6830.000000) nil) | 0@@list("PC5908" "MX_C0402_SMALL_T01" list(2550.000000 6831.990000) nil) | 0@@list("PC5909" "MX_C0402_SMALL_T01" list(2585.000000 7895.000000) nil) | 0@@list("PC5910" "MX_C0402_SMALL_T01" list(2581.000000 7458.000000) nil) | 0@@list("PC5911" "MX_C0402_SMALL_T01" list(2513.000000 7895.000000) nil) | 0@@list("PC5912" "MX_C0402_SMALL_T01" list(2340.000000 7525.000000) nil) | 0@@list("PC5913" "MX_C0402_SMALL_T01" list(2585.000000 7525.000000) nil) | 0@@list("PC5914" "MX_C0603_SMALL_T02" list(2940.000000 7526.000000) nil) | 0@@list("PC5915" "MX_C0603_SMALL_T01" list(2650.000000 7955.000000) nil) | 0@@list("PC5916" "MX_C0603_SMALL_T01" list(2540.000000 8115.000000) nil) | 0@@list("PC5917" "MX_C1206_H75" list(1966.000000 7349.000000) nil) | 0@@list("PC5918" "MX_C1206_H75" list(1966.000000 7445.000000) nil) | 0@@list("PC5919" "MX_C1206_H75" list(1962.000000 7675.000000) nil) | 0@@list("PC5920" "MX_C1206_H75" list(1962.000000 7771.000000) nil) | 0@@list("PC601" "MX_C0402_SMALL_T01" list(2588.530000 6515.000000) nil) | 0@@list("PC602" "MX_C0402_SMALL_T01" list(2583.000000 6074.000000) nil) | 0@@list("PC603" "MX_C0402_SMALL_T01" list(2516.530000 6515.000000) nil) | 0@@list("PC604" "MX_C0402_SMALL_T01" list(2553.000000 6140.530000) nil) | 0@@list("PC605" "MX_C0402_SMALL_T01" list(2325.000000 6140.000000) nil) | 0@@list("PC606" "MX_C0603_SMALL_T02" list(2908.000000 6145.000000) nil) | 0@@list("PC607" "MX_C0603_SMALL_T01" list(2805.000000 6545.000000) nil) | 0@@list("PC608" "MX_C0603_SMALL_T01" list(2690.000000 6691.000000) nil) | 0@@list("PC609" "MX_C0402_SMALL_T01" list(2587.000000 5814.000000) nil) | 0@@list("PC610" "MX_C0402_SMALL_T01" list(2594.000000 5391.000000) nil) | 0@@list("PC6101" "MX_C0402_SMALL_T01" list(4485.000000 8835.000000) nil) | 0@@list("PC6102" "MX_C0402_SMALL_T01" list(4530.000000 8835.000000) nil) | 0@@list("PC6103" "MX_C0402_SMALL_T01" list(4730.000000 8599.000000) nil) | 0@@list("PC6104" "MX_C0402_SMALL_T01" list(4265.000000 8955.000000) nil) | 0@@list("PC6105" "MX_C0402_SMALL_T01" list(4070.000000 8940.000000) nil) | 0@@list("PC6106" "MX_C0603_SMALL_T02" list(4280.000000 7935.000000) nil) | 0@@list("PC6107" "MX_C0603_SMALL_T01" list(3880.000000 9005.000000) nil) | 0@@list("PC6108" "MX_C0603_SMALL_T01" list(3648.000000 8921.000000) nil) | 0@@list("PC6109" "MX_C0402_SMALL_T01" list(5320.000000 8830.000000) nil) | 0@@list("PC611" "MX_C0402_SMALL_T01" list(2515.000000 5814.000000) nil) | 0@@list("PC6110" "MX_C0402_SMALL_T01" list(5362.000000 8830.000000) nil) | 0@@list("PC6111" "MX_C0402_SMALL_T01" list(5575.000000 8600.000000) nil) | 0@@list("PC6112" "MX_C0402_SMALL_T01" list(4880.000000 8940.000000) nil) | 0@@list("PC6113" "MX_C0402_SMALL_T01" list(5110.000000 8955.000000) nil) | 0@@list("PC6114" "MX_C0603_SMALL_T02" list(4860.000000 7935.000000) nil) | 0@@list("PC6115" "MX_C0603_SMALL_T01" list(5885.000000 8914.000000) nil) | 0@@list("PC6116" "MX_C0603_SMALL_T01" list(5694.000000 9003.000000) nil) | 0@@list("PC6117" "MX_C1206_H75" list(4509.000000 8963.000000) nil) | 0@@list("PC6118" "MX_C1206_H75" list(4691.000000 9210.000000) nil) | 0@@list("PC6119" "MX_C1206_H75" list(5527.000000 9138.000000) nil) | 0@@list("PC612" "MX_C0402_SMALL_T01" list(2325.000000 5444.000000) nil) | 0@@list("PC6120" "MX_C1206_H75" list(5351.000000 8974.000000) nil) | 0@@list("PC613" "MX_C0402_SMALL_T01" list(2546.000000 5444.530000) nil) | 0@@list("PC614" "MX_C0603_SMALL_T02" list(3100.000000 5525.000000) nil) | 0@@list("PC615" "MX_C0603_SMALL_T01" list(2842.000000 5887.000000) nil) | 0@@list("PC616" "MX_C0603_SMALL_T01" list(2710.000000 5996.000000) nil) | 0@@list("PC617" "MX_C1206_H75" list(2015.000000 6048.000000) nil) | 0@@list("PC618" "MX_C1206_H75" list(2015.000000 6144.000000) nil) | 0@@list("PC619" "MX_C1206_H75" list(1993.000000 6714.000000) nil) | 0@@list("PC620" "MX_C1206_H75" list(1993.000000 6617.000000) nil) | 0@@list("PC6201" "MX_C0603_SMALL_T02" list(4945.000000 6375.000000) nil) | 0@@list("PC6202" "MX_C0603_SMALL_T02" list(5000.000000 6375.000000) nil) | 0@@list("PC6203" "MX_C0603_SMALL_T02" list(4945.000000 6265.000000) nil) | 0@@list("PC6204" "MX_C0603_SMALL_T02" list(5000.000000 6265.000000) nil) | 0@@list("PC6205" "MX_C0603_SMALL_T02" list(4945.000000 6500.000000) nil) | 0@@list("PC6206" "MX_C0603_SMALL_T02" list(5110.000000 6500.000000) nil) | 0@@list("PC6207" "MX_C0603_SMALL_T02" list(4730.000000 6625.000000) nil) | 0@@list("PC6208" "MX_C0603_SMALL_T02" list(4780.000000 6265.000000) nil) | 0@@list("PC6209" "MX_C0603_SMALL_T02" list(4835.000000 6500.000000) nil) | 0@@list("PC6210" "MX_C0603_SMALL_T02" list(4890.000000 6265.000000) nil) | 0@@list("PC6211" "MX_C0603_SMALL_T02" list(4725.000000 6265.000000) nil) | 0@@list("PC6212" "MX_C0603_SMALL_T02" list(4725.000000 6375.000000) nil) | 0@@list("PC6213" "MX_C0603_SMALL_T02" list(5165.000000 6375.000000) nil) | 0@@list("PC6214" "MX_C0603_SMALL_T02" list(4835.000000 6170.000000) nil) | 0@@list("PC6215" "MX_C0603_SMALL_T02" list(4780.000000 6170.000000) nil) | 0@@list("PC6216" "MX_C0603_SMALL_T02" list(4890.000000 6375.000000) nil) | 0@@list("PC6217" "MX_C0603_SMALL_T02" list(4725.000000 6170.000000) nil) | 0@@list("PC6218" "MX_C0603_SMALL_T02" list(4890.000000 6500.000000) nil) | 0@@list("PC6219" "MX_C0603_SMALL_T02" list(5055.000000 6500.000000) nil) | 0@@list("PC6220" "MX_C0603_SMALL_T02" list(5000.000000 6500.000000) nil) | 0@@list("PC6221" "MX_C0603_SMALL_T02" list(3915.000000 8435.000000) nil) | 0@@list("PC6222" "MX_C0603_SMALL_T02" list(5087.000000 8244.000000) nil) | 0@@list("PC6223" "MX_C0603_SMALL_T02" list(3975.000000 7935.000000) nil) | 0@@list("PC6224" "MX_C0603_SMALL_T02" list(4860.000000 7880.000000) nil) | 0@@list("PC6225" "MX_C0603_SMALL_T02" list(5044.620000 6735.000000) nil) | 0@@list("PC6226" "MX_C0603_SMALL_T02" list(4939.520000 6680.000000) nil) | 0@@list("PC6227" "MX_C0603_SMALL_T01" list(5044.620000 6680.000000) nil) | 0@@list("PC6228" "MX_C0603_SMALL_T02" list(4939.520000 6625.000000) nil) | 0@@list("PC6229" "MX_C0603_SMALL_T02" list(4939.520000 6735.000000) nil) | 0@@list("PC6230" "MX_C0603_SMALL_T02" list(4834.760000 6625.000000) nil) | 0@@list("PC6231" "MX_C0603_SMALL_T02" list(5044.620000 6625.000000) nil) | 0@@list("PC6232" "MX_C0603_SMALL_T02" list(4834.760000 6735.000000) nil) | 0@@list("PC6233" "MX_C0603_SMALL_T02" list(3975.000000 7880.000000) nil) | 0@@list("PC6234" "MX_C0603_SMALL_T02" list(4280.000000 7880.000000) nil) | 0@@list("PC6235" "MX_C0603_SMALL_T02" list(5149.380000 6680.000000) nil) | 0@@list("PC6236" "MX_C0603_SMALL_T02" list(5149.380000 6735.000000) nil) | 0@@list("PC6237" "MX_C0603_SMALL_T02" list(3810.000000 6290.000000) nil) | 0@@list("PC6238" "MX_C0603_SMALL_T02" list(3810.000000 6500.000000) nil) | 0@@list("PC6239" "MX_C0603_SMALL_T02" list(3810.000000 7055.000000) nil) | 0@@list("PC6240" "MX_C0603_SMALL_T02" list(3810.000000 6865.000000) nil) | 0@@list("PC6241" "MX_C0603_SMALL_T02" list(4575.000000 7935.000000) nil) | 0@@list("PC6242" "MX_C0603_SMALL_T02" list(4575.000000 7880.000000) nil) | 0@@list("PC6243" "MX_C0603_SMALL_T02" list(5149.380000 6624.000000) nil) | 0@@list("PC6244" "MX_C0603_SMALL_T02" list(4834.760000 6680.000000) nil) | 0@@list("PC640625" "MX_C0603_SMALL_T02" list(4730.000000 6680.000000) nil) | 0@@list("PC640626" "MX_C0603_SMALL_T02" list(5110.000000 6265.000000) nil) | 0@@list("PC640627" "MX_C0603_SMALL_T02" list(5110.000000 6375.000000) nil) | 0@@list("PC640628" "MX_C0603_SMALL_T02" list(5165.000000 6265.000000) nil) | 0@@list("PC640629" "MX_C0603_SMALL_T02" list(4780.000000 6375.000000) nil) | 0@@list("PC640630" "MX_C0603_SMALL_T02" list(3810.000000 6690.000000) nil) | 0@@list("PC640632" "MX_C0603_SMALL_T02" list(4908.000000 6145.000000) nil) | 0@@list("PC640633" "MX_C0603_SMALL_T02" list(4908.000000 6090.000000) nil) | 0@@list("PC640634" "MX_C0603_SMALL_T02" list(5050.000000 6145.000000) nil) | 0@@list("PC640635" "MX_C0603_SMALL_T02" list(5050.000000 6090.000000) nil) | 0@@list("PC640636" "MX_C0603_SMALL_T02" list(5047.000000 6035.000000) nil) | 0@@list("PC640637" "MX_C0402_SMALL_T01" list(2615.000000 4705.000000) nil) | 0@@list("PC640639" "MX_C0402_SMALL_T01" list(2995.000000 5406.000000) nil) | 0@@list("PC640641" "MX_C0402_SMALL_T01" list(2775.000000 5108.000000) nil) | 0@@list("PC640644" "MX_C0402_SMALL_T01" list(2615.000000 4770.000000) nil) | 0@@list("PC640645" "MX_C0402_SMALL_T01" list(2707.000000 5329.000000) nil) | 0@@list("PC640646" "MX_C0402_SMALL_T01" list(2885.000000 5350.000000) nil) | 0@@list("PC640647" "MX_C0603_SMALL_T01" list(2885.000000 4780.000000) nil) | 0@@list("PC640648" "MX_C0402_SMALL_T01" list(2625.000000 4940.000000) nil) | 0@@list("PC640649" "MX_C0805_SMALL_T02" list(2768.000000 4904.000000) nil) | 0@@list("PC640651" "MX_C0402_SMALL_T01" list(2995.000000 5442.000000) nil) | 0@@list("PC640653" "MX_C0402_SMALL_T01" list(8350.000000 8820.000000) nil) | 0@@list("PC640656" "MX_C0402_SMALL_T01" list(8295.000000 7621.000000) nil) | 0@@list("PC640658" "MX_C0402_SMALL_T01" list(8649.000000 7808.000000) nil) | 0@@list("PC640660" "MX_C0402_SMALL_T01" list(8237.200000 7799.600000) nil) | 0@@list("PC640661" "MX_C0402_SMALL_T01" list(8409.000000 8835.000000) nil) | 0@@list("PC640662" "MX_C0402_SMALL_T01" list(8638.000000 7384.000000) nil) | 0@@list("PC640663" "MX_C0603_SMALL_T01" list(8395.000000 8511.500000) nil) | 0@@list("PC640664" "MX_C0402_SMALL_T01" list(8555.000000 8815.000000) nil) | 0@@list("PC640665" "MX_C0603_SMALL_T01" list(8515.000000 8575.000000) nil) | 0@@list("PC640667" "MX_C0402_SMALL_T01" list(8294.900000 7397.500000) nil) | 0@@list("PC640671" "MX_C0603_SMALL_T01" list(8490.000000 8840.000000) nil) | 0@@list("PC640672" "MX_C0402_SMALL_T01" list(2591.000000 4844.000000) nil) | 0@@list("PC640674" "MX_C0603_SMALL_T01" list(2470.000000 4935.000000) nil) | 0@@list("PC640675" "MX_C0402_SMALL_T01" list(1555.000000 9090.000000) nil) | 0@@list("PC640676" "MX_C0805_SMALL_T02" list(1415.000000 8985.000000) nil) | 0@@list("PC640679" "MX_C0603_SMALL_T01" list(2116.020000 4948.000000) nil) | 0@@list("PC640681" "MX_C0201" list(2020.000000 5158.000000) nil) | 0@@list("PC640682" "MX_C0603_SMALL_T01" list(755.000000 5985.000000) nil) | 0@@list("PC640683" "MX_C0402_SMALL_T01" list(2199.000000 7952.000000) nil) | 0@@list("PC640684" "MX_C0402_SMALL_T01" list(2797.000000 7445.000000) nil) | 0@@list("PC640685" "MX_C0402_SMALL_T01" list(2600.000000 8177.000000) nil) | 0@@list("PC640686" "MX_C0402_SMALL_T01" list(2201.000000 6076.000000) nil) | 0@@list("PC640687" "MX_C0402_SMALL_T01" list(2755.000000 6745.000000) nil) | 0@@list("PC640688" "MX_C0402_SMALL_T01" list(2710.000000 6059.000000) nil) | 0@@list("PC640689" "MX_C0402_SMALL_T01" list(2932.000000 7479.000000) nil) | 0@@list("PC640690" "MX_C0402_SMALL_T01" list(2920.000000 6784.000000) nil) | 0@@list("PC640691" "MX_C0402_SMALL_T01" list(3153.000000 5528.000000) nil) | 0@@list("PC640692" "MX_C0402_SMALL_T01" list(2916.000000 6100.000000) nil) | 0@@list("PC642" "MX_C0402_SMALL_T01" list(1817.000000 9333.000000) nil) | 0@@list("PC6501" "MX_C1206_H75" list(8302.000000 8100.000000) nil) | 0@@list("PC6502" "MX_C1206_H75" list(8302.000000 7999.000000) nil) | 0@@list("PC6521" "MX_C0603_SMALL_T02" list(8369.000000 6328.000000) nil) | 0@@list("PC6522" "MX_C0603_SMALL_T02" list(8382.000000 6089.000000) nil) | 0@@list("PC6523" "MX_C0603_SMALL_T02" list(6735.000000 7235.000000) nil) | 0@@list("PC6524" "MX_C0603_SMALL_T02" list(8328.500000 6778.000000) nil) | 0@@list("PC6525" "MX_C0603_SMALL_T02" list(8170.000000 7050.000000) nil) | 0@@list("PC6526" "MX_C0603_SMALL_T01" list(8994.000000 8132.000000) nil) | 0@@list("PC6527" "MX_C0603_SMALL_T01" list(8625.000000 8950.000000) nil) | 0@@list("PC661" "MX_C0402_SMALL_T01" list(8400.000000 5199.000000) nil) | 0@@list("PC6805" "MX_C0603_SMALL_T01" list(1703.000000 9364.000000) nil) | 0@@list("PC6807" "MX_C0603_SMALL_T01" list(1650.000000 8945.000000) nil) | 0@@list("PC6808" "MX_C0603_SMALL_T01" list(1700.000000 8945.000000) nil) | 0@@list("PC6809" "MX_C0402_SMALL_T01" list(1763.000000 8972.000000) nil) | 0@@list("PC6810" "MX_C0402_SMALL_T01" list(1642.000000 9317.000000) nil) | 0@@list("PC832" "MX_C0603_SMALL_T02" list(8269.000000 4370.000000) nil) | 0@@list("PC834" "MX_C0603_SMALL_T02" list(5165.000000 6500.000000) nil) | 0@@list("PR11" "MX_R0402_SMALL_T01" list(8505.000000 8965.000000) nil) | 0@@list("PR115" "MX_R0402_SMALL_T01" list(5400.000000 3630.000000) nil) | 0@@list("PR12" "MX_R0402_SMALL_T01" list(8560.000000 8980.000000) nil) | 0@@list("PR121" "MX_R0402_SMALL_T01" list(9432.000000 8498.000000) nil) | 0@@list("PR122" "MX_R0402_SMALL_T01" list(9095.000000 8440.000000) nil) | 0@@list("PR123" "MX_R0603_SMALL_T01" list(8257.000000 5716.000000) nil) | 0@@list("PR124" "MX_R0402_SMALL_T01" list(4880.000000 3770.000000) nil) | 0@@list("PR125" "MX_R0402_SMALL_T01" list(8306.000000 6105.000000) nil) | 0@@list("PR126" "MX_R0402_SMALL_T01" list(8270.000000 6105.000000) nil) | 0@@list("PR127" "MX_R0805_SMALL_T02" list(5074.000000 3954.000000) nil) | 0@@list("PR128" "MX_R0402_SMALL_T01" list(5154.000000 3845.000000) nil) | 0@@list("PR129" "MX_R0402_SMALL_T01" list(5149.000000 3950.000000) nil) | 0@@list("PR130" "MX_R0402_SMALL_T01" list(4889.000000 3975.000000) nil) | 0@@list("PR131" "MX_R1206" list(4700.000000 3945.000000) nil) | 0@@list("PR132" "MX_R0402_SMALL_T01" list(4890.000000 3910.000000) nil) | 0@@list("PR133" "MX_R0402_SMALL_T01" list(4962.000000 3910.000000) nil) | 0@@list("PR134" "MX_R0402_SMALL_T01" list(8465.000000 5676.000000) nil) | 0@@list("PR135" "MX_R0402_SMALL_T01" list(8481.000000 5366.000000) nil) | 0@@list("PR136" "MX_R0402_SMALL_T01" list(1493.500000 9065.190000) nil) | 0@@list("PR137" "MX_R0402_SMALL_T01" list(8429.000000 5299.500000) nil) | 0@@list("PR138" "MX_R0402_SMALL_T01" list(9263.380000 8012.500000) nil) | 0@@list("PR139" "MX_R0402_SMALL_T01" list(8586.000000 5774.000000) nil) | 0@@list("PR14" "MX_R0402_SMALL_T01" list(8218.000000 4165.000000) nil) | 0@@list("PR161" "MX_R0805_SMALL_T02" list(7668.000000 3702.000000) nil) | 0@@list("PR162" "MX_R0402_SMALL_T01" list(7458.000000 3637.000000) nil) | 0@@list("PR163" "MX_R0805_SMALL_T02" list(8145.000000 3605.000000) nil) | 0@@list("PR164" "MX_R0402_SMALL_T01" list(8165.870000 3516.920000) nil) | 0@@list("PR165" "MX_R0805_SMALL_T02" list(7740.000000 3490.000000) nil) | 0@@list("PR166" "MX_R1206" list(7910.000000 3360.000000) nil) | 0@@list("PR167" "MX_R0402_SMALL_T01" list(7384.000000 3675.000000) nil) | 0@@list("PR168" "MX_R0402_SMALL_T01" list(7573.000000 3506.000000) nil) | 0@@list("PR170" "MX_R0402_SMALL_T01" list(7351.000000 3637.000000) nil) | 0@@list("PR171" "MX_R0402_SMALL_T01" list(8075.000000 3387.000000) nil) | 0@@list("PR172" "MX_R0402_SMALL_T01" list(7448.000000 3565.000000) nil) | 0@@list("PR173" "MX_R0402_SMALL_T01" list(7441.000000 3493.000000) nil) | 0@@list("PR174" "MX_R0402_SMALL_T01" list(7458.000000 3673.000000) nil) | 0@@list("PR175" "MX_R0402_SMALL_T01" list(7509.000000 3493.000000) nil) | 0@@list("PR187" "MX_R0402_SMALL_T01" list(8980.000000 6476.000000) nil) | 0@@list("PR188" "MX_R0402_SMALL_T01" list(9018.000000 7446.000000) nil) | 0@@list("PR189" "MX_R0402_SMALL_T01" list(9030.000000 7410.000000) nil) | 0@@list("PR191" "MX_R0402_SMALL_T01" list(8965.000000 7410.000000) nil) | 0@@list("PR192" "MX_R0402_SMALL_T01" list(8940.000000 7265.000000) nil) | 0@@list("PR193" "MX_R0402_SMALL_T01" list(8990.000000 7285.000000) nil) | 0@@list("PR195" "MX_R0402_SMALL_T01" list(9432.000000 8433.000000) nil) | 0@@list("PR198" "MX_R0402_SMALL_T01" list(9402.000000 8368.000000) nil) | 0@@list("PR199" "MX_R0402_SMALL_T01" list(9029.000000 8440.000000) nil) | 0@@list("PR2" "MX_R0805_SMALL_T02" list(2597.000000 8644.000000) nil) | 0@@list("PR234" "MX_R0402_SMALL_T01" list(2179.000000 4881.000000) nil) | 0@@list("PR235" "MX_R0402_SMALL_T01" list(2122.000000 4870.000000) nil) | 0@@list("PR236" "MX_R0402_SMALL_T01" list(2178.000000 4725.000000) nil) | 0@@list("PR244" "MX_R0402_SMALL_T01" list(5022.000000 4612.500000) nil) | 0@@list("PR245" "MX_R0402_SMALL_T01" list(4971.900000 4597.000000) nil) | 0@@list("PR248" "MX_R0402_SMALL_T01" list(5445.000000 4385.000000) nil) | 0@@list("PR249" "MX_R0402_SMALL_T01" list(5313.000000 4312.000000) nil) | 0@@list("PR3" "MX_R0805_SMALL_T02" list(4704.000000 4480.000000) nil) | 0@@list("PR302" "MX_R0402_SMALL_T01" list(8443.000000 5570.000000) nil) | 0@@list("PR305" "MX_R0402_SMALL_T01" list(8481.000000 5402.000000) nil) | 0@@list("PR312" "MX_R0402_SMALL_T01" list(4998.000000 3910.000000) nil) | 0@@list("PR313" "MX_R0402_SMALL_T01" list(4925.000000 3975.000000) nil) | 0@@list("PR317" "MX_R0402_SMALL_T01" list(2513.000000 4940.000000) nil) | 0@@list("PR340" "MX_R0805_SMALL_T02" list(5115.620000 4488.000000) nil) | 0@@list("PR341" "MX_R0805_SMALL_T02" list(1958.000000 5012.000000) nil) | 0@@list("PR381" "MX_R0402_SMALL_T01" list(8491.000000 6058.000000) nil) | 0@@list("PR4" "MX_R0805_SMALL_T02" list(5240.000000 4357.000000) nil) | 0@@list("PR432" "MX_R0402_SMALL_T01" list(8632.000000 6204.000000) nil) | 0@@list("PR5" "MX_R0402_SMALL_T01" list(9050.000000 7790.000000) nil) | 0@@list("PR511" "MX_R0402_SMALL_T01" list(8959.500000 5896.000000) nil) | 0@@list("PR512" "MX_R0402_SMALL_T01" list(8230.000000 8793.000000) nil) | 0@@list("PR5801" "MX_R0402_SMALL_T01" list(2905.000000 8240.000000) nil) | 0@@list("PR5802" "MX_R0402_SMALL_T01" list(2975.000000 8270.000000) nil) | 0@@list("PR5803" "MX_R0402_SMALL_T01" list(3007.000000 8325.000000) nil) | 0@@list("PR5804" "MX_R0402_SMALL_T01" list(2805.000000 8455.000000) nil) | 0@@list("PR5805" "MX_R0402_SMALL_T01" list(2876.000000 8416.000000) nil) | 0@@list("PR5806" "MX_R0402_SMALL_T01" list(3114.000000 8210.000000) nil) | 0@@list("PR5807" "MX_R0402_SMALL_T01" list(2980.500000 8870.000000) nil) | 0@@list("PR5808" "MX_R0402_SMALL_T01" list(3079.000000 8954.000000) nil) | 0@@list("PR5809" "MX_R0402_SMALL_T01" list(3111.000000 8071.000000) nil) | 0@@list("PR5810" "MX_R0402_SMALL_T01" list(2885.000000 8290.000000) nil) | 0@@list("PR5811" "MX_R0402_SMALL_T01" list(2885.000000 8380.000000) nil) | 0@@list("PR5812" "MX_R0402_SMALL_T01" list(2880.000000 8690.000000) nil) | 0@@list("PR5813" "MX_R0402_SMALL_T01" list(2989.000000 8954.000000) nil) | 0@@list("PR5814" "MX_R0402_SMALL_T01" list(3060.000000 8267.000000) nil) | 0@@list("PR5815" "MX_R0402_SMALL_T01" list(3043.000000 8325.000000) nil) | 0@@list("PR5816" "MX_R0402_SMALL_T01" list(2795.000000 8630.000000) nil) | 0@@list("PR5817" "MX_R0402_SMALL_T01" list(3485.000000 8863.000000) nil) | 0@@list("PR5818" "MX_R0402_SMALL_T01" list(3485.000000 8827.000000) nil) | 0@@list("PR5819" "MX_R0402_SMALL_T01" list(3400.040000 8803.910000) nil) | 0@@list("PR5820" "MX_R0402_SMALL_T01" list(3400.000000 8845.000000) nil) | 0@@list("PR5821" "MX_R0402_SMALL_T01" list(3485.000000 8791.000000) nil) | 0@@list("PR5822" "MX_R0402_SMALL_T01" list(3400.000000 8731.000000) nil) | 0@@list("PR5823" "MX_R0402_SMALL_T01" list(3485.000000 8755.000000) nil) | 0@@list("PR5824" "MX_R0402_SMALL_T01" list(3308.000000 8259.000000) nil) | 0@@list("PR5825" "MX_R0402_SMALL_T01" list(3424.000000 8352.000000) nil) | 0@@list("PR5826" "MX_R0402_SMALL_T01" list(3426.000000 8267.000000) nil) | 0@@list("PR5827" "MX_R0402_SMALL_T01" list(3388.000000 8352.000000) nil) | 0@@list("PR5828" "MX_R0402_SMALL_T01" list(3487.000000 8402.000000) nil) | 0@@list("PR5829" "MX_R0402_SMALL_T01" list(3400.000000 8402.000000) nil) | 0@@list("PR5830" "MX_R0402_SMALL_T01" list(3487.000000 8438.000000) nil) | 0@@list("PR5831" "MX_R0402_SMALL_T01" list(3400.000000 8438.000000) nil) | 0@@list("PR5832" "MX_R0402_SMALL_T01" list(3487.000000 8474.000000) nil) | 0@@list("PR5833" "MX_R0402_SMALL_T01" list(3400.000000 8474.000000) nil) | 0@@list("PR5834" "MX_R0402_SMALL_T01" list(3487.000000 8582.000000) nil) | 0@@list("PR5835" "MX_R0402_SMALL_T01" list(3400.000000 8582.000000) nil) | 0@@list("PR5836" "MX_R0402_SMALL_T01" list(3345.000000 8259.000000) nil) | 0@@list("PR5837" "MX_R0402_SMALL_T01" list(3390.000000 8267.000000) nil) | 0@@list("PR5838" "MX_R0402_SMALL_T01" list(3400.000000 8546.000000) nil) | 0@@list("PR5839" "MX_R0402_SMALL_T01" list(3487.000000 8546.000000) nil) | 0@@list("PR5840" "MX_R0402_SMALL_T01" list(3487.000000 8510.000000) nil) | 0@@list("PR5841" "MX_R0402_SMALL_T01" list(3400.000000 8510.000000) nil) | 0@@list("PR5842" "MX_R0402_SMALL_T01" list(3345.000000 8355.000000) nil) | 0@@list("PR5843" "MX_R0402_SMALL_T01" list(3303.000000 8355.000000) nil) | 0@@list("PR5844" "MX_R0402_SMALL_T01" list(3229.000000 8320.000000) nil) | 0@@list("PR5845" "MX_R0402_SMALL_T01" list(3186.000000 8245.000000) nil) | 0@@list("PR5846" "MX_R0402_SMALL_T01" list(3150.000000 8330.000000) nil) | 0@@list("PR5847" "MX_R0402_SMALL_T01" list(3188.000000 8331.000000) nil) | 0@@list("PR5848" "MX_R0402_SMALL_T01" list(3236.500000 8900.000000) nil) | 0@@list("PR5849" "MX_R0402_SMALL_T01" list(3160.000000 8910.000000) nil) | 0@@list("PR5850" "MX_R0402_SMALL_T01" list(3187.000000 8990.000000) nil) | 0@@list("PR5851" "MX_R0402_SMALL_T01" list(3196.000000 8910.000000) nil) | 0@@list("PR5852" "MX_R0402_SMALL_T01" list(2795.000000 8590.000000) nil) | 0@@list("PR5853" "MX_R0402_SMALL_T01" list(2880.000000 8556.000000) nil) | 0@@list("PR5854" "MX_R0402_SMALL_T01" list(2829.000000 8940.000000) nil) | 0@@list("PR5855" "MX_R0402_SMALL_T01" list(2902.000000 8871.000000) nil) | 0@@list("PR5856" "MX_R0402_SMALL_T01" list(3345.000000 8938.000000) nil) | 0@@list("PR5857" "MX_R0402_SMALL_T01" list(3400.000000 8655.000000) nil) | 0@@list("PR5858" "MX_R0402_SMALL_T01" list(3400.040000 8766.910000) nil) | 0@@list("PR5859" "MX_R0402_SMALL_T01" list(2768.000000 8762.000000) nil) | 0@@list("PR5860" "MX_R0402_SMALL_T01" list(2743.000000 8801.000000) nil) | 0@@list("PR5862" "MX_R0402_SMALL_T01" list(3566.000000 8563.000000) nil) | 0@@list("PR5863" "MX_R0402_SMALL_T01" list(3602.000000 8563.000000) nil) | 0@@list("PR5864" "MX_R0402_SMALL_T01" list(3562.000000 8685.000000) nil) | 0@@list("PR5865" "MX_R0402_SMALL_T01" list(3598.000000 8685.000000) nil) | 0@@list("PR5866" "MX_R0402_SMALL_T01" list(3400.000000 8695.000000) nil) | 0@@list("PR5867" "MX_R0402" list(3400.000000 8618.000000) nil) | 0@@list("PR5868" "MX_R0402_SMALL_T01" list(3490.000000 8620.000000) nil) | 0@@list("PR5869" "MX_R0402_SMALL_T01" list(3485.000000 8718.000000) nil) | 0@@list("PR5870" "MX_R0402_SMALL_T01" list(2865.000000 8766.000000) nil) | 0@@list("PR5871" "MX_R0402_SMALL_T01" list(2881.000000 8512.000000) nil) | 0@@list("PR5872" "MX_R0402_SMALL_T01" list(2931.000000 8957.000000) nil) | 0@@list("PR5873" "MX_R0402_SMALL_T01" list(2944.000000 8870.000000) nil) | 0@@list("PR5874" "MX_R0402_SMALL_T01" list(2793.000000 8513.000000) nil) | 0@@list("PR5875" "MX_R0402_SMALL_T01" list(2820.000000 8850.000000) nil) | 0@@list("PR5876" "MX_R0805_SMALL_T02" list(3166.000000 8072.000000) nil) | 0@@list("PR5877" "MX_R0402_SMALL_T01" list(3124.000000 8873.000000) nil) | 0@@list("PR5878" "MX_R0402_SMALL_T01" list(3075.000000 8396.000000) nil) | 0@@list("PR5879" "MX_R0402_SMALL_T01" list(2880.000000 8640.000000) nil) | 0@@list("PR5880" "MX_R0402_SMALL_T01" list(2950.000000 8215.000000) nil) | 0@@list("PR5881" "MX_R0402_SMALL_T01" list(2769.000000 8455.000000) nil) | 0@@list("PR5882" "MX_R0402_SMALL_T01" list(3078.000000 8210.000000) nil) | 0@@list("PR5883" "MX_R0402_SMALL_T01" list(3024.000000 9005.000000) nil) | 0@@list("PR5884" "MX_R0402_SMALL_T01" list(3060.000000 9005.000000) nil) | 0@@list("PR5901" "MX_R1206_H26" list(2895.000000 7365.000000) nil) | 0@@list("PR5902" "MX_R0603_SMALL_T01" list(2682.000000 7370.000000) nil) | 0@@list("PR5903" "MX_R0805_SMALL_T02" list(2535.990000 7293.000000) nil) | 0@@list("PR5904" "MX_R0402_SMALL_T01" list(2550.000000 7203.000000) nil) | 0@@list("PR5905" "MX_R1206" list(2700.000000 6817.000000) nil) | 0@@list("PR5906" "MX_R0402_SMALL_T01" list(2586.000000 6831.990000) nil) | 0@@list("PR5908" "MX_R0402_SMALL_T01" list(2549.000000 7895.000000) nil) | 0@@list("PR5909" "MX_R0603_SMALL_T01" list(2553.000000 8221.000000) nil) | 0@@list("PR5910" "MX_R0805_SMALL_T02" list(2532.000000 7984.000000) nil) | 0@@list("PR5911" "MX_R1206_H26" list(2740.000000 8035.000000) nil) | 0@@list("PR5912" "MX_R0402_SMALL_T01" list(2549.000000 7525.000000) nil) | 0@@list("PR5913" "MX_R1206" list(2700.000000 7510.000000) nil) | 0@@list("PR6" "MX_R0805_SMALL_T02" list(9075.000000 7989.000000) nil) | 0@@list("PR601" "MX_R0402_SMALL_T01" list(2552.530000 6515.000000) nil) | 0@@list("PR602" "MX_R0603_SMALL_T01" list(2617.000000 6713.000000) nil) | 0@@list("PR603" "MX_R0805_SMALL_T02" list(2595.000000 6596.470000) nil) | 0@@list("PR604" "MX_R1206_H26" list(2880.000000 6665.000000) nil) | 0@@list("PR605" "MX_R0402_SMALL_T01" list(2589.000000 6140.530000) nil) | 0@@list("PR606" "MX_R1206" list(2703.000000 6125.000000) nil) | 0@@list("PR608" "MX_R0402_SMALL_T01" list(2551.000000 5814.000000) nil) | 0@@list("PR609" "MX_R0603_SMALL_T01" list(2603.000000 6007.000000) nil) | 0@@list("PR610" "MX_R0805_SMALL_T02" list(2595.000000 5910.000000) nil) | 0@@list("PR6101" "MX_R0402_SMALL_T01" list(4730.000000 8563.000000) nil) | 0@@list("PR6102" "MX_R0603_SMALL_T01" list(3604.000000 9037.000000) nil) | 0@@list("PR6103" "MX_R0805_SMALL_T02" list(4720.000000 8460.000000) nil) | 0@@list("PR6104" "MX_R1206_H26" list(3760.000000 9065.000000) nil) | 0@@list("PR6105" "MX_R0402_SMALL_T01" list(4070.000000 8976.000000) nil) | 0@@list("PR6106" "MX_R1206" list(4510.000000 8679.000000) nil) | 0@@list("PR6108" "MX_R0402_SMALL_T01" list(5575.000000 8564.000000) nil) | 0@@list("PR6109" "MX_R0603_SMALL_T01" list(5694.000000 8954.000000) nil) | 0@@list("PR611" "MX_R1206_H26" list(2931.000000 5981.000000) nil) | 0@@list("PR6110" "MX_R0805_SMALL_T02" list(5544.000000 8458.000000) nil) | 0@@list("PR6111" "MX_R1206_H26" list(5984.000000 9029.000000) nil) | 0@@list("PR6112" "MX_R0402_SMALL_T01" list(4880.000000 8976.000000) nil) | 0@@list("PR6113" "MX_R1206" list(5354.000000 8679.000000) nil) | 0@@list("PR612" "MX_R0402_SMALL_T01" list(2582.000000 5444.530000) nil) | 0@@list("PR613" "MX_R1206" list(2700.000000 5473.000000) nil) | 0@@list("PR621" "MX_R0402_SMALL_T01" list(3227.000000 8169.000000) nil) | 0@@list("PR622" "MX_R0402_SMALL_T01" list(3294.000000 8170.000000) nil) | 0@@list("PR623" "MX_R0402_SMALL_T01" list(3261.000000 9002.000000) nil) | 0@@list("PR624" "MX_R0402_SMALL_T01" list(3345.000000 8975.000000) nil) | 0@@list("PR641" "MX_R0805_SMALL_T02" list(914.000000 6716.000000) nil) | 0@@list("PR6506" "MX_R0402_SMALL_T01" list(8445.000000 8835.000000) nil) | 0@@list("PR6601" "MX_R0603_SMALL_T01" list(4670.000000 1955.000000) nil) | 0@@list("PR6602" "MX_R0402_SMALL_T01" list(4689.000000 2210.000000) nil) | 0@@list("PR6603" "MX_R0402_SMALL_T01" list(4735.300000 2011.800000) nil) | 0@@list("PR6605" "MX_R0402_SMALL_T01" list(4734.600000 2078.700000) nil) | 0@@list("PR6607" "MX_R0402_SMALL_T01" list(8443.000000 4879.000000) nil) | 0@@list("PR6608" "MX_R0402_SMALL_T01" list(8395.000000 5098.000000) nil) | 0@@list("PR6609" "MX_R0402_SMALL_T01" list(8385.000000 5149.000000) nil) | 0@@list("PR6610" "MX_R0402_SMALL_T01" list(8429.000000 4968.000000) nil) | 0@@list("PR6611" "MX_R0402_SMALL_T01" list(8425.000000 5148.990000) nil) | 0@@list("PR6806" "MX_R0402_SMALL_T01" list(1769.000000 8898.000000) nil) | 0@@list("PR6807" "MX_R0402_SMALL_T01" list(1768.990000 8934.000000) nil) | 0@@list("PR6809" "MX_R0402_SMALL_T01" list(1829.000000 8972.000000) nil) | 0@@list("PR6810" "MX_R0603_SMALL_T01" list(1655.000000 9380.000000) nil) | 0@@list("PR7" "MX_R0805_SMALL_T02" list(9020.000000 6180.000000) nil) | 0@@list("PR70176" "MX_R0402_SMALL_T01" list(2510.000000 4785.000000) nil) | 0@@list("PR70188" "MX_R0402_SMALL_T01" list(2440.000000 4715.000000) nil) | 0@@list("PR70189" "MX_R0402_SMALL_T01" list(2468.000000 4859.000000) nil) | 0@@list("PR70190" "MX_R0402_SMALL_T01" list(2860.000000 4840.000000) nil) | 0@@list("PR70193" "MX_R0805_SMALL_T02" list(2792.000000 5019.000000) nil) | 0@@list("PR70194" "MX_R0402_SMALL_T01" list(2535.000000 4730.000000) nil) | 0@@list("PR70195" "MX_R0603_SMALL_T01" list(3445.000000 5705.000000) nil) | 0@@list("PR70196" "MX_R0402_SMALL_T01" list(2440.000000 4655.000000) nil) | 0@@list("PR70198" "MX_R0805_SMALL_T02" list(2860.000000 4690.000000) nil) | 0@@list("PR70199" "MX_R1206" list(2743.010000 5236.000000) nil) | 0@@list("PR70201" "MX_R0402_SMALL_T01" list(2440.000000 4755.000000) nil) | 0@@list("PR70202" "MX_R0603_SMALL_T01" list(2889.000000 4899.000000) nil) | 0@@list("PR70203" "MX_R0805_SMALL_T02" list(2935.000000 4840.000000) nil) | 0@@list("PR70204" "MX_R0402_SMALL_T01" list(2811.000000 5108.000000) nil) | 0@@list("PR70205" "MX_R0402_SMALL_T01" list(2585.000000 4940.000000) nil) | 0@@list("PR70206" "MX_R0402_SMALL_T01" list(2665.000000 4940.000000) nil) | 0@@list("PR70210" "MX_R0805_SMALL_T02" list(8687.000000 7886.000000) nil) | 0@@list("PR70211" "MX_R0402_SMALL_T01" list(8350.000000 8881.000000) nil) | 0@@list("PR70212" "MX_R0603_SMALL_T01" list(8305.000000 6599.000000) nil) | 0@@list("PR70213" "MX_R0402_SMALL_T01" list(8352.200000 8964.200000) nil) | 0@@list("PR70215" "MX_R0805_SMALL_T02" list(8335.000000 8525.000000) nil) | 0@@list("PR70216" "MX_R1206" list(8312.200000 7878.600000) nil) | 0@@list("PR70217" "MX_R0402_SMALL_T01" list(8300.000000 8900.000000) nil) | 0@@list("PR70219" "MX_R0603_SMALL_T01" list(8541.380000 8646.000000) nil) | 0@@list("PR70220" "MX_R0805_SMALL_T02" list(8455.000000 8491.000000) nil) | 0@@list("PR70221" "MX_R0402_SMALL_T01" list(8649.000000 7771.000000) nil) | 0@@list("PR70222" "MX_R0402_SMALL_T01" list(8555.000000 8851.000000) nil) | 0@@list("PR70223" "MX_R0402_SMALL_T01" list(8545.000000 8905.000000) nil) | 0@@list("PR70225" "MX_R0402_SMALL_T01" list(8300.000000 8975.000000) nil) | 0@@list("PR70227" "MX_R0402_SMALL_T01" list(8455.000000 8567.000000) nil) | 0@@list("PR70228" "MX_R0402_SMALL_T01" list(2468.000000 4823.000000) nil) | 0@@list("PR70231" "MX_R0402_SMALL_T01" list(3460.000000 8915.000000) nil) | 0@@list("PR70238" "MX_R0402_SMALL_T01" list(4880.000000 3635.000000) nil) | 0@@list("PR70244" "MX_R0805_SMALL_T02" list(8840.000000 6335.000000) nil) | 0@@list("PR70245" "MX_R0805_SMALL_T02" list(8840.000000 6265.000000) nil) | 0@@list("PR70246" "MX_R0805_SMALL_T02" list(7760.000000 2617.000000) nil) | 0@@list("PR70250" "MX_R0402_SMALL_T01" list(8520.000000 5680.000000) nil) | 0@@list("PR70254" "MX_R0402_SMALL_T01" list(1600.000000 9090.000000) nil) | 0@@list("PR70256" "MX_R0402_SMALL_T01" list(2129.000000 4906.000000) nil) | 0@@list("PR70260" "MX_R0402_SMALL_T01" list(8581.000000 8905.000000) nil) | 0@@list("PR70261" "MX_R0402_SMALL_T01" list(2549.000000 4940.000000) nil) | 0@@list("PR70291" "MX_R0805_SMALL_T02" list(8117.000000 3296.000000) nil) | 0@@list("PR70296" "MX_R0805_SMALL_T02" list(9000.000000 7720.000000) nil) | 0@@list("PR70298" "MX_R0402_SMALL_T01" list(1781.000000 9333.000000) nil) | 0@@list("PR8" "MX_R0805_SMALL_T02" list(8562.000000 8496.000000) nil) | 0@@list("PR9" "MX_R0805_SMALL_T02" list(8215.000000 8330.000000) nil) | 0@@list("PRT581" "MX_R0402_SMALL_T01" list(2960.000000 7225.000000) nil) | 0@@list("PRT582" "MX_R0402_SMALL_T01" list(3953.000000 8511.000000) nil) | 0@@list("PRT583" "MX_R0402_SMALL_T01" list(2513.000000 7431.000000) nil) | 0@@list("PRT584" "MX_R0402_SMALL_T01" list(3995.000000 8980.000000) nil) | 0@@list("PU10" "MX_DFN_10P_20_S118_PAD_R_4V" list(2725.000000 4790.000000) nil) | 0@@list("PU581" "MX_QFN_56P_16_S236_PAD_4V" list(3096.040000 8611.280000) nil) | 0@@list("PU591" "MX_DFN_8P_20_79X79_PAD_RIC" list(2782.420000 7344.710000) nil) | 0@@list("PU592" "MX_DFN_8P_20_79X79_PAD_RIC" list(2638.100000 8073.710000) nil) | 0@@list("PU601" "MX_DFN_8P_20_79X79_PAD_RIC" list(2777.180000 6661.710000) nil) | 0@@list("PU602" "MX_DFN_8P_20_79X79_PAD_RIC" list(2806.860000 5989.710000) nil) | 0@@list("PU611" "MX_DFN_8P_20_79X79_PAD_RIC" list(3758.000000 8955.000000) nil) | 0@@list("PU612" "MX_DFN_8P_20_79X79_PAD_RIC" list(5816.340000 8998.710000) nil) | 0@@list("PU651" "MX_DFN_10P_20_S118_PAD_R_4V" list(8400.000000 8700.000000) nil) | 0@@list("PU7" "MX_DFN_10P_20_S118_PAD_R_4V" list(8340.000000 4940.000000) nil) | 0@@list("PU9" "MX_DFN_10P_20_S118_PAD_R_4V" list(7583.000000 3596.000000) nil) | 0@@list("R18" "MX_R0402_SMALL_T01" list(8486.000000 1812.000000) nil) | 0@@list("R19" "MX_R0402_SMALL_T01" list(8422.000000 1812.000000) nil) | 0@@list("R25" "MX_R0603_SMALL_T01" list(4055.000000 224.000000) nil) | 0@@list("R27" "MX_R0603_SMALL_T01" list(3931.000000 224.000000) nil) | 0@@list("R30" "MX_R0603_SMALL_T01" list(3746.000000 224.000000) nil) | 0@@list("R31" "MX_R0603_SMALL_T01" list(3982.000000 224.000000) nil) | 0@@list("R36" "MX_R0805_SMALL_T02_H26" list(1239.000000 1653.000000) nil) | 0@@list("R37" "MX_R0402_SMALL_T01" list(1109.000000 1495.000000) nil) | 0@@list("R37456" "R0402" list(8760.000000 4136.000000) nil) | 0@@list("R60373" "MX_R0402_SMALL_T01" list(8886.000000 4124.000000) nil) | 0@@list("R60374" "MX_R0402_SMALL_T01" list(8808.000000 4605.000000) nil) | 0@@list("R60375" "R0402" list(8880.520000 3137.000000) nil) | 0@@list("R60381" "MX_R0402_SMALL_T01" list(8772.000000 4605.000000) nil) | 0@@list("R60385" "MX_R0402_SMALL_T01" list(8836.000000 4135.000000) nil) | 0@@list("R636" "MX_R0402_SMALL_T01" list(8880.000000 1350.000000) nil) | 0@@list("R69583" "MX_R0402_SMALL_T01" list(8882.000000 3175.000000) nil) | 0@@list("R69584" "MX_R0402_SMALL_T01" list(8798.000000 4135.000000) nil) | 0@@list("R69686" "MX_R0603_SMALL_T01" list(3871.000000 224.000000) nil) | 0@@list("R69687" "MX_R0603_SMALL_T01" list(3807.000000 224.000000) nil) | 0@@list("R69694" "MX_R0402_SMALL_T01" list(4653.000000 2210.000000) nil) | 0@@list("R69695" "MX_R0402_SMALL_T01" list(8720.500000 3908.000000) nil) | 0@@list("RFC100" "MX_C0402_SMALL_T01" list(8218.000000 5662.000000) nil) | 0@@list("RFC101" "MX_C0402_SMALL_T01" list(8221.980000 6259.950000) nil) | 0@@list("RFC102" "MX_C0402_SMALL_T01" list(8149.000000 4032.000000) nil) | 0@@list("RFC103" "MX_C0402_SMALL_T01" list(8182.000000 6480.000000) nil) | 0@@list("RFC104" "MX_C0402_SMALL_T01" list(6876.000000 3987.000000) nil) | 0@@list("RFC105" "MX_C0402_SMALL_T01" list(7510.000000 5697.000000) nil) | 0@@list("RFC106" "MX_C0402_SMALL_T01" list(8186.000000 6258.000000) nil) | 0@@list("RFC107" "MX_C0402_SMALL_T01" list(8185.000000 4060.000000) nil) | 0@@list("RFC108" "MX_C0402_SMALL_T01" list(7501.000000 5473.000000) nil) | 0@@list("RFC109" "MX_C0402_SMALL_T01" list(8257.980000 6259.950000) nil) | 0@@list("RFC110" "MX_C0402_SMALL_T01" list(8258.000000 4221.000000) nil) | 0@@list("RFC111" "MX_C0402_SMALL_T01" list(8218.000000 5626.000000) nil) | 0@@list("RFC112" "MX_C0402_SMALL_T01" list(2089.000000 2984.000000) nil) | 0@@list("RFC113" "MX_C0402_SMALL_T01" list(911.000000 475.000000) nil) | 0@@list("RFC114" "MX_C0402_SMALL_T01" list(944.000000 685.000000) nil) | 0@@list("RFC115" "MX_C0402_SMALL_T01" list(585.000000 6907.000000) nil) | 0@@list("RFC116" "MX_C0402_SMALL_T01" list(8905.000000 7736.000000) nil) | 0@@list("RFC117" "MX_C0402_SMALL_T01" list(8816.000000 6211.000000) nil) | 0@@list("RFC118" "MX_C0402_SMALL_T01" list(1940.500000 7603.420000) nil) | 0@@list("RFC119" "MX_C0402_SMALL_T01" list(1964.000000 6528.000000) nil) | 0@@list("RFC120" "MX_C0402_SMALL_T01" list(1500.000000 7540.000000) nil) | 0@@list("RFC121" "MX_C0402_SMALL_T01" list(1719.000000 5550.000000) nil) | 0@@list("RFC14" "MX_C0402_SMALL_T01" list(362.000000 5467.000000) nil) | 0@@list("RFC15" "MX_C0402_SMALL_T01" list(858.000000 5493.000000) nil) | 0@@list("RFC29" "MX_C0402_SMALL_T01" list(6837.000000 4195.000000) nil) | 0@@list("RFC30" "MX_C0402_SMALL_T01" list(7505.000000 4290.000000) nil) | 0@@list("RFC31" "MX_C0402_SMALL_T01" list(8181.000000 4300.000000) nil) | 0@@list("RFC32" "MX_C0402_SMALL_T01" list(8145.000000 4300.000000) nil) | 0@@list("RN23" "MX_4R8P0402" list(8040.000000 1286.000000) nil) | 0@@list("RN24" "MX_4R8P0402" list(8040.000000 1560.000000) nil) | 0@@list("RN25" "MX_4R8P0402" list(8040.000000 1460.000000) nil) | 0@@list("RN26" "MX_4R8P0402" list(8290.000000 1705.000000) nil) | 0@@list("SC100" "MX_C0201" list(5302.800000 2430.100000) nil) | 0@@list("SC101" "MX_C0603_SMALL_T01" list(5207.500000 2419.900000) nil) | 0@@list("SC102" "MX_C0603_SMALL_T01" list(6121.500000 1042.000000) nil) | 0@@list("SC103" "MX_C0603_SMALL_T01" list(6068.500000 1043.000000) nil) | 0@@list("SC105" "MX_C0402_SMALL_T01" list(5838.500000 1542.000000) nil) | 0@@list("SC121" "MX_C0402_SMALL_T01" list(5194.000000 1155.000000) nil) | 0@@list("SC141" "MX_C0402_SMALL_T01" list(6427.000000 1239.000000) nil) | 0@@list("SC146" "MX_C0402_SMALL_T01" list(5855.000000 1830.000000) nil) | 0@@list("SC147" "MX_C0402_SMALL_T01" list(6528.000000 948.000000) nil) | 0@@list("SC148" "MX_C0402_SMALL_T01" list(6202.000000 1135.000000) nil) | 0@@list("SC149" "MX_C0402_SMALL_T01" list(5180.000000 1103.000000) nil) | 0@@list("SC152" "MX_C0402_SMALL_T01" list(710.000000 6617.000000) nil) | 0@@list("SC153" "MX_C0402_SMALL_T01" list(710.000000 6653.000000) nil) | 0@@list("SC154" "MX_C0402_SMALL_T01" list(2925.000000 2618.000000) nil) | 0@@list("SC155" "MX_C0402_SMALL_T01" list(2790.000000 2617.000000) nil) | 0@@list("SC156" "MX_C0402_SMALL_T01" list(2961.000000 2618.000000) nil) | 0@@list("SC157" "MX_C0402_SMALL_T01" list(2826.000000 2617.000000) nil) | 0@@list("SC158" "MX_C0402_SMALL_T01" list(2646.000000 1820.000000) nil) | 0@@list("SC159" "MX_C0402_SMALL_T01" list(2925.000000 1815.000000) nil) | 0@@list("SC160" "MX_C0402_SMALL_T01" list(2488.000000 1848.000000) nil) | 0@@list("SC161" "MX_C0402_SMALL_T01" list(2765.000000 1815.000000) nil) | 0@@list("SC162" "MX_C0402_SMALL_T01" list(2524.000000 1848.000000) nil) | 0@@list("SC163" "MX_C0402_SMALL_T01" list(2961.000000 1815.000000) nil) | 0@@list("SC164" "MX_C0402_SMALL_T01" list(2610.000000 1820.000000) nil) | 0@@list("SC165" "MX_C0402_SMALL_T01" list(2801.000000 1815.000000) nil) | 0@@list("SC166" "MX_C0402_SMALL_T01" list(8947.000000 4413.500000) nil) | 0@@list("SC167" "MX_C0402_SMALL_T01" list(8958.000000 3261.000000) nil) | 0@@list("SC168" "MX_C0603_SMALL_T01" list(5366.300000 2484.100000) nil) | 0@@list("SC170" "MX_C0402_SMALL_T01" list(977.000000 9024.000000) nil) | 0@@list("SC171" "MX_C0402_SMALL_T01" list(767.000000 9022.000000) nil) | 0@@list("SC172" "MX_C0603_SMALL_T01" list(654.000000 9163.220000) nil) | 0@@list("SC173" "MX_C0402_SMALL_T01" list(917.000000 9153.000000) nil) | 0@@list("SC174" "MX_C0201" list(6285.000000 1235.000000) nil) | 0@@list("SC175" "MX_C0402_SMALL_T01" list(6588.000000 1280.000000) nil) | 0@@list("SC32" "MX_C0402_SMALL_T01" list(2478.000000 2618.000000) nil) | 0@@list("SC52" "MX_C0402_SMALL_T01" list(8707.000000 865.000000) nil) | 0@@list("SC6" "MX_C0402_SMALL_T01" list(6039.000000 1264.000000) nil) | 0@@list("SC61" "MX_C0402_SMALL_T01" list(2442.000000 2618.000000) nil) | 0@@list("SC62" "MX_C0402_SMALL_T01" list(2619.000000 2617.000000) nil) | 0@@list("SC63" "MX_C0402_SMALL_T01" list(2655.000000 2617.000000) nil) | 0@@list("SC64" "MX_C0402_SMALL_T01" list(710.000000 6401.000000) nil) | 0@@list("SC65" "MX_C0402_SMALL_T01" list(710.000000 6437.000000) nil) | 0@@list("SC66" "MX_C0402_SMALL_T01" list(710.000000 6473.000000) nil) | 0@@list("SC67" "MX_C0402_SMALL_T01" list(710.000000 6509.000000) nil) | 0@@list("SC68" "MX_C0402_SMALL_T01" list(710.000000 6545.000000) nil) | 0@@list("SC69" "MX_C0402_SMALL_T01" list(710.000000 6581.000000) nil) | 0@@list("SC7" "MX_C0402_SMALL_T01" list(5990.000000 1166.000000) nil) | 0@@list("SC70" "MX_C0402_SMALL_T01" list(6485.000000 1080.000000) nil) | 0@@list("SC72" "MX_C0402_SMALL_T01" list(7420.000000 1565.000000) nil) | 0@@list("SC8" "MX_C0402_SMALL_T01" list(5958.000000 2489.000000) nil) | 0@@list("SC80" "MX_C0402_SMALL_T01" list(5965.000000 1395.000000) nil) | 0@@list("SC81" "MX_C0402_SMALL_T01" list(5825.000000 1395.000000) nil) | 0@@list("SC82" "MX_C0402_SMALL_T01" list(5965.000000 1358.000000) nil) | 0@@list("SC83" "MX_C0402_SMALL_T01" list(5885.000000 1440.000000) nil) | 0@@list("SC85" "MX_C0402_SMALL_T01" list(7420.000000 1524.500000) nil) | 0@@list("SC86" "MX_C0402_SMALL_T01" list(7420.000000 1447.000000) nil) | 0@@list("SC9" "MX_C0402_SMALL_T01" list(5993.000000 2425.000000) nil) | 0@@list("SC90" "MX_C0402_SMALL_T01" list(7420.000000 1488.500000) nil) | 0@@list("SCB1" "MX_C0603_SMALL_T02" list(7830.000000 2412.000000) nil) | 0@@list("SCB10" "MX_C0201" list(6185.600000 1317.080000) nil) | 0@@list("SCB11" "MX_C0402_SMALL_T01" list(7406.000000 2195.200000) nil) | 0@@list("SCB118" "MX_C0201" list(6368.500000 966.000000) nil) | 0@@list("SCB119" "MX_C0402_SMALL_T01" list(8471.000000 874.000000) nil) | 0@@list("SCB12" "MX_C0603_SMALL_T02" list(7522.000000 2595.000000) nil) | 0@@list("SCB120" "MX_C0402_SMALL_T01" list(7408.000000 1635.000000) nil) | 0@@list("SCB121" "MX_C0402_SMALL_T01" list(7825.000000 420.000000) nil) | 0@@list("SCB122" "MX_C0402_SMALL_T01" list(7330.000000 1300.000000) nil) | 0@@list("SCB13" "MX_C0402_SMALL_T01" list(7475.000000 2604.880000) nil) | 0@@list("SCB14" "MX_C0603_SMALL_T02" list(5848.000000 2225.880000) nil) | 0@@list("SCB15" "MX_C0603_SMALL_T02" list(7575.000000 2635.000000) nil) | 0@@list("SCB16" "MX_C0603_SMALL_T02" list(7908.900000 2304.000000) nil) | 0@@list("SCB19" "MX_C0402_SMALL_T01" list(7290.000000 1300.000000) nil) | 0@@list("SCB2" "MX_C0603_SMALL_T02" list(7972.000000 2520.000000) nil) | 0@@list("SCB21" "MX_C0402_SMALL_T01" list(7480.000000 1635.000000) nil) | 0@@list("SCB25" "MX_C0402_SMALL_T01" list(6441.000000 1006.000000) nil) | 0@@list("SCB28" "MX_C0201" list(6013.000000 1065.000000) nil) | 0@@list("SCB29" "MX_C0201" list(6748.000000 954.000000) nil) | 0@@list("SCB3" "MX_C0402_SMALL_T01" list(7444.000000 1635.000000) nil) | 0@@list("SCB30" "MX_C0402_SMALL_T01" list(6826.000000 1059.000000) nil) | 0@@list("SCB31" "MX_C0402_SMALL_T01" list(6836.000000 1293.000000) nil) | 0@@list("SCB32" "MX_C0402_SMALL_T01" list(6892.000000 1294.000000) nil) | 0@@list("SCB35" "MX_C0402_SMALL_T01" list(6748.000000 990.000000) nil) | 0@@list("SCB36" "MX_C0201" list(6968.660000 1192.940000) nil) | 0@@list("SCB4" "MX_C0603_SMALL_T02" list(5923.000000 2225.880000) nil) | 0@@list("SCB5" "MX_C0402_SMALL_T01" list(5993.000000 2235.880000) nil) | 0@@list("SCB68" "MX_C0402_SMALL_T01" list(8543.000000 868.000000) nil) | 0@@list("SCB69" "MX_C0402_SMALL_T01" list(8235.000000 868.000000) nil) | 0@@list("SCB7" "MX_C0402_SMALL_T01" list(7530.000000 1875.000000) nil) | 0@@list("SCB70" "MX_C0402_SMALL_T01" list(8594.000000 804.000000) nil) | 0@@list("SCB75" "MX_C0402_SMALL_T01" list(8650.000000 1704.500000) nil) | 0@@list("SCB8" "MX_C0603_SMALL_T02" list(7440.000000 2370.000000) nil) | 0@@list("SCB9" "MX_C0402_SMALL_T01" list(7456.000000 2215.000000) nil) | 0@@list("SR1" "MX_R0402_SMALL_T01" list(5615.300000 1610.500000) nil) | 0@@list("SR100" "MX_R0402_SMALL_T01" list(5369.500000 2553.570000) nil) | 0@@list("SR101" "MX_R0402_SMALL_T01" list(6065.000000 1107.000000) nil) | 0@@list("SR102" "MX_R0402_SMALL_T01" list(6129.000000 1107.000000) nil) | 0@@list("SR115" "MX_R0402_SMALL_T01" list(6453.000000 1189.000000) nil) | 0@@list("SR119" "MX_R0402_SMALL_T01" list(6653.000000 1315.000000) nil) | 0@@list("SR12" "MX_R0603_SMALL_T01" list(7473.000000 2699.000000) nil) | 0@@list("SR129" "MX_R0402_SMALL_T01" list(7846.000000 2052.000000) nil) | 0@@list("SR13" "MX_R0402_SMALL_T01" list(7947.000000 1901.000000) nil) | 0@@list("SR139" "MX_R0402_SMALL_T01" list(5889.000000 1310.000000) nil) | 0@@list("SR14" "MX_R0402_SMALL_T01" list(7988.000000 2110.000000) nil) | 0@@list("SR15" "MX_R0402_SMALL_T01" list(7004.000000 1205.000000) nil) | 0@@list("SR153" "MX_R0402_SMALL_T01" list(3165.000000 4395.000000) nil) | 0@@list("SR154" "MX_R0402_SMALL_T01" list(3608.000000 4591.000000) nil) | 0@@list("SR160" "MX_R0402_SMALL_T01" list(5520.000000 1615.000000) nil) | 0@@list("SR162" "MX_R0402_SMALL_T01" list(3432.370000 4411.690000) nil) | 0@@list("SR164" "MX_R0402_SMALL_T01" list(3319.230000 4298.550000) nil) | 0@@list("SR165" "MX_R0402_SMALL_T01" list(3755.000000 3980.000000) nil) | 0@@list("SR166" "MX_R0402_SMALL_T01" list(3732.000000 3847.000000) nil) | 0@@list("SR17" "MX_R0805_SMALL_T02" list(380.000000 9380.000000) nil) | 0@@list("SR18" "MX_R0402_SMALL_T01" list(6648.000000 1063.000000) nil) | 0@@list("SR2" "MX_R0402_SMALL_T01" list(5945.000000 1890.000000) nil) | 0@@list("SR20" "MX_R0402_SMALL_T01" list(5615.300000 1647.900000) nil) | 0@@list("SR220" "MX_R0402_SMALL_T01" list(5686.800000 1867.300000) nil) | 0@@list("SR240" "MX_R0402_SMALL_T01" list(6030.000000 1475.000000) nil) | 0@@list("SR241" "MX_R0402_SMALL_T01" list(5965.000000 1457.000000) nil) | 0@@list("SR242" "MX_R0402_SMALL_T01" list(6030.000000 1358.000000) nil) | 0@@list("SR243" "MX_R0402_SMALL_T01" list(6030.000000 1439.000000) nil) | 0@@list("SR244" "MX_R0402_SMALL_T01" list(6030.000000 1395.000000) nil) | 0@@list("SR245" "MX_R0402_SMALL_T01" list(4878.000000 4721.000000) nil) | 0@@list("SR246" "MX_R0402_SMALL_T01" list(6027.000000 1749.000000) nil) | 0@@list("SR250" "MX_R0402_SMALL_T01" list(7558.000000 1578.000000) nil) | 0@@list("SR251" "MX_R0402_SMALL_T01" list(7558.000000 1544.000000) nil) | 0@@list("SR252" "MX_R0402_SMALL_T01" list(7558.000000 1473.000000) nil) | 0@@list("SR253" "MX_R0402_SMALL_T01" list(7558.000000 1439.000000) nil) | 0@@list("SR254" "MX_R0402_SMALL_T01" list(7558.000000 1613.000000) nil) | 0@@list("SR255" "MX_R0402_SMALL_T01" list(7558.000000 1511.000000) nil) | 0@@list("SR256" "MX_R0402_SMALL_T01" list(7693.000000 1532.000000) nil) | 0@@list("SR257" "MX_R0402_SMALL_T01" list(7693.000000 1498.000000) nil) | 0@@list("SR268" "MX_R0402_SMALL_T01" list(6786.010000 1308.500000) nil) | 0@@list("SR27" "MX_R0402_SMALL_T01" list(7013.000000 1300.000000) nil) | 0@@list("SR275" "MX_R0402_SMALL_T01" list(7490.400000 1722.400000) nil) | 0@@list("SR277" "MX_R0402_SMALL_T01" list(7562.000000 1663.000000) nil) | 0@@list("SR278" "MX_R0402_SMALL_T01" list(7625.000000 1663.000000) nil) | 0@@list("SR28" "MX_R0402_SMALL_T01" list(7049.000000 1300.000000) nil) | 0@@list("SR280" "MX_R0402_SMALL_T01" list(6030.000000 1550.000000) nil) | 0@@list("SR281" "MX_R0402_SMALL_T01" list(5725.000000 1802.000000) nil) | 0@@list("SR287" "MX_R0402_SMALL_T01" list(5958.000000 1650.000000) nil) | 0@@list("SR289" "MX_R0402_SMALL_T01" list(5825.000000 1638.000000) nil) | 0@@list("SR29" "MX_R0402_SMALL_T01" list(7121.000000 1300.000000) nil) | 0@@list("SR292" "MX_R0402_SMALL_T01" list(5861.000000 1638.000000) nil) | 0@@list("SR30" "MX_R0402_SMALL_T01" list(7085.000000 1300.000000) nil) | 0@@list("SR31" "MX_R0402_SMALL_T01" list(6976.000000 1300.000000) nil) | 0@@list("SR336" "MX_R0402_SMALL_T01" list(6202.000000 1171.000000) nil) | 0@@list("SR343" "MX_R0402_SMALL_T01" list(6590.000000 1187.000000) nil) | 0@@list("SR360" "MX_R0402_SMALL_T01" list(6270.000000 1110.000000) nil) | 0@@list("SR363" "MX_R0402_SMALL_T01" list(6270.000000 1146.000000) nil) | 0@@list("SR364" "MX_R0402_SMALL_T01" list(6150.000000 1157.000000) nil) | 0@@list("SR365" "MX_R0402_SMALL_T01" list(6266.000000 1182.000000) nil) | 0@@list("SR366" "MX_R0402_SMALL_T01" list(6986.000000 1054.000000) nil) | 0@@list("SR367" "MX_R0402_SMALL_T01" list(5920.000000 1830.000000) nil) | 0@@list("SR370" "MX_R0402_SMALL_T01" list(7383.000000 1279.000000) nil) | 0@@list("SR371" "MX_R0402_SMALL_T01" list(7383.000000 1315.000000) nil) | 0@@list("SR375" "MX_R0402_SMALL_T01" list(6270.000000 1074.000000) nil) | 0@@list("SR4" "MX_R0402_SMALL_T01" list(6477.000000 1006.000000) nil) | 0@@list("SR400" "MX_R0402_SMALL_T01" list(5773.000000 2544.000000) nil) | 0@@list("SR401" "MX_R0402_SMALL_T01" list(6394.000000 2588.000000) nil) | 0@@list("SR411" "MX_R0603_SMALL_T01" list(5770.000000 2231.000000) nil) | 0@@list("SR43" "MX_R0603_SMALL_T01" list(7672.700000 2382.900000) nil) | 0@@list("SR44" "MX_R0402_SMALL_T01" list(5991.000000 1230.000000) nil) | 0@@list("SR443" "MX_R0402_SMALL_T01" list(7475.000000 1774.000000) nil) | 0@@list("SR45" "MX_R0402_SMALL_T01" list(6030.000000 1207.000000) nil) | 0@@list("SR49" "MX_R0603_SMALL_T01" list(7524.500000 2698.900000) nil) | 0@@list("SR54" "MX_R0603_SMALL_T01" list(7586.000000 1866.000000) nil) | 0@@list("SR545" "MX_R0402_SMALL_T01" list(7683.000000 1929.000000) nil) | 0@@list("SR59" "MX_R0402_SMALL_T01" list(6027.000000 2458.000000) nil) | 0@@list("SR60" "MX_R0402_SMALL_T01" list(5855.000000 1890.000000) nil) | 0@@list("SR628" "MX_R0402_SMALL_T01" list(1034.000000 6705.000000) nil) | 0@@list("SR629" "MX_R0402_SMALL_T01" list(1034.000000 6669.000000) nil) | 0@@list("SR650" "MX_R0402_SMALL_T01" list(6935.000000 1201.000000) nil) | 0@@list("SR653" "MX_C0201" list(6030.000000 1320.000000) nil) | 0@@list("SR659" "MX_R0402_SMALL_T01" list(5194.000000 1192.000000) nil) | 0@@list("SR664" "MX_R0402_SMALL_T01" list(6030.000000 1511.700000) nil) | 0@@list("SR667" "MX_R0402_SMALL_T01" list(7697.000000 2171.000000) nil) | 0@@list("SR671" "MX_R0402_SMALL_T01" list(7625.000000 2171.000000) nil) | 0@@list("SR673" "MX_R0402_SMALL_T01" list(7796.000000 2171.000000) nil) | 0@@list("SR678" "MX_R0402_SMALL_T01" list(7213.000000 1231.000000) nil) | 0@@list("SR680" "MX_R0402_SMALL_T01" list(6743.000000 1199.000000) nil) | 0@@list("SR694" "MX_R0402_SMALL_T01" list(5785.000000 1890.000000) nil) | 0@@list("SR7" "MX_R0402_SMALL_T01" list(9130.980000 794.860000) nil) | 0@@list("SR70" "MX_R0402_SMALL_T01" list(6030.000000 1890.000000) nil) | 0@@list("SR711" "MX_R0402_SMALL_T01" list(7454.800000 2089.500000) nil) | 0@@list("SR712" "MX_R0402_SMALL_T01" list(7454.800000 2130.700000) nil) | 0@@list("SR713" "MX_R0402_SMALL_T01" list(2182.000000 4555.000000) nil) | 0@@list("SR714" "MX_R0402_SMALL_T01" list(2182.000000 4519.000000) nil) | 0@@list("SR738" "MX_R0402_SMALL_T01" list(6253.000000 895.000000) nil) | 0@@list("SR745" "MX_R0402_SMALL_T01" list(6528.000000 984.500000) nil) | 0@@list("SR746" "MX_R0402_SMALL_T01" list(6504.000000 1186.000000) nil) | 0@@list("SR747" "MX_R0402_SMALL_T01" list(5958.000000 2425.000000) nil) | 0@@list("SR749" "MX_R0402_SMALL_T01" list(6780.000000 1255.000000) nil) | 0@@list("SR75" "MX_R0402_SMALL_T01" list(5260.000000 4280.000000) nil) | 0@@list("SR7564" "MX_R0402_SMALL_T01" list(9021.000000 3947.000000) nil) | 0@@list("SR7565" "MX_R0402_SMALL_T01" list(8912.000000 4377.000000) nil) | 0@@list("SR758" "MX_R0402_SMALL_T01" list(5356.420000 2439.700000) nil) | 0@@list("SR759" "MX_R0402_SMALL_T01" list(5356.300000 2390.800000) nil) | 0@@list("SR7622" "MX_R0402_SMALL_T01" list(3685.000000 4668.000000) nil) | 0@@list("SR7627" "MX_R0402_SMALL_T01" list(7213.700000 1273.500000) nil) | 0@@list("SR7628" "MX_R0402_SMALL_T01" list(7213.700000 1309.500000) nil) | 0@@list("SR7629" "MX_R0402_SMALL_T01" list(6781.000000 1160.000000) nil) | 0@@list("SR7630" "MX_R0402_SMALL_T01" list(5770.000000 1542.000000) nil) | 0@@list("SR7634" "MX_R0402_SMALL_T01" list(3633.000000 4617.000000) nil) | 0@@list("SR7635" "MX_R0402_SMALL_T01" list(3290.000000 4474.000000) nil) | 0@@list("SR7637" "MX_R0402_SMALL_T01" list(5180.000000 1067.000000) nil) | 0@@list("SR7638" "MX_R0402_SMALL_T01" list(6421.000000 1080.000000) nil) | 0@@list("SR7642" "MX_R0402_SMALL_T01" list(3515.000000 4496.000000) nil) | 0@@list("SR7643" "MX_R0402_SMALL_T01" list(3490.000000 4470.000000) nil) | 0@@list("SR7646" "MX_R0402_SMALL_T01" list(6527.500000 1021.000000) nil) | 0@@list("SR7656" "MX_R0402_SMALL_T01" list(6506.000000 1253.000000) nil) | 0@@list("SR7658" "MX_R0402_SMALL_T01" list(5942.500000 1529.500000) nil) | 0@@list("SR7659" "MX_R0402_SMALL_T01" list(2281.000000 360.000000) nil) | 0@@list("SR7660" "MX_R0402_SMALL_T01" list(2201.000000 360.000000) nil) | 0@@list("SR7676" "MX_R0402_SMALL_T01" list(8787.000000 3981.310000) nil) | 0@@list("SR7677" "MX_R0402_SMALL_T01" list(2886.000000 365.000000) nil) | 0@@list("SR7678" "MX_R0402_SMALL_T01" list(2922.000000 365.000000) nil) | 0@@list("SR7682" "MX_R0402_SMALL_T01" list(1925.000000 1355.000000) nil) | 0@@list("SR7683" "MX_R0402_SMALL_T01" list(1975.000000 1355.000000) nil) | 0@@list("SR7684" "MX_R0402_SMALL_T01" list(1919.000000 2084.000000) nil) | 0@@list("SR7685" "MX_R0402_SMALL_T01" list(1955.000000 2084.000000) nil) | 0@@list("SR7686" "MX_R0402_SMALL_T01" list(1950.000000 549.000000) nil) | 0@@list("SR7687" "MX_R0402_SMALL_T01" list(1994.000000 549.000000) nil) | 0@@list("SR7688" "MX_R0402_SMALL_T01" list(1894.000000 2600.000000) nil) | 0@@list("SR7689" "MX_R0402_SMALL_T01" list(1959.000000 2600.000000) nil) | 0@@list("SR7690" "MX_R0402_SMALL_T01" list(5109.000000 1135.000000) nil) | 0@@list("SR7691" "MX_R0402_SMALL_T01" list(3769.000000 3880.000000) nil) | 0@@list("SR7696" "MX_R0402_SMALL_T01" list(7545.200000 2139.100000) nil) | 0@@list("SR7697" "MX_R0402_SMALL_T01" list(7545.200000 2088.000000) nil) | 0@@list("SR7698" "MX_R0402_SMALL_T01" list(7683.000000 1966.000000) nil) | 0@@list("SR7701" "MX_R0402_SMALL_T01" list(8787.000000 3944.000000) nil) | 0@@list("SR7702" "MX_R0402_SMALL_T01" list(7736.000000 1712.000000) nil) | 0@@list("SR7703" "MX_R0402_SMALL_T01" list(1013.000000 9024.000000) nil) | 0@@list("SR7704" "MX_R0402_SMALL_T01" list(767.000000 9087.000000) nil) | 0@@list("SR7705" "MX_R0402_SMALL_T01" list(714.000000 9103.500000) nil) | 0@@list("SR7706" "MX_R0402_SMALL_T01" list(698.000000 9173.100000) nil) | 0@@list("SR7707" "MX_R0805_SMALL_T02" list(919.000000 9228.000000) nil) | 0@@list("SR7713" "MX_R0402_SMALL_T01" list(6654.000000 1273.000000) nil) | 0@@list("SR7714" "MX_R0402_SMALL_T01" list(5211.000000 9246.000000) nil) | 0@@list("SR7717" "MX_R0402_SMALL_T01" list(3562.130000 4549.900000) nil) | 0@@list("SR7748" "MX_R0402_SMALL_T01" list(7653.000000 1809.000000) nil) | 0@@list("SR7767" "MX_R0402_SMALL_T01" list(2340.500000 380.400000) nil) | 0@@list("SR7768" "MX_R0402_SMALL_T01" list(3034.000000 365.000000) nil) | 0@@list("SR7769" "MX_R0402_SMALL_T01" list(7545.000000 2183.000000) nil) | 0@@list("SR7776" "MX_R0402_SMALL_T01" list(2303.230000 584.300000) nil) | 0@@list("SR7777" "MX_R0402_SMALL_T01" list(2339.230000 584.300000) nil) | 0@@list("SR7778" "MX_R0402_SMALL_T01" list(7651.000000 1758.000000) nil) | 0@@list("SR7779" "MX_R0402_SMALL_T01" list(7689.000000 1758.000000) nil) | 0@@list("SR7780" "MX_R0402_SMALL_T01" list(2393.000000 1368.000000) nil) | 0@@list("SR7781" "MX_R0402_SMALL_T01" list(6150.700000 478.600000) nil) | 0@@list("SR7784" "MX_R0402_SMALL_T01" list(7742.500000 2171.000000) nil) | 0@@list("SR8" "MX_R0402_SMALL_T01" list(9078.000000 719.000000) nil) | 0@@list("SR80" "MX_R0402_SMALL_T01" list(6654.000000 918.000000) nil) | 0@@list("SR81" "MX_R0402_SMALL_T01" list(6698.000000 918.000000) nil) | 0@@list("SR82" "MX_R0402_SMALL_T01" list(6608.000000 1086.000000) nil) | 0@@list("SR83" "MX_R0402_SMALL_T01" list(6304.500000 983.000000) nil) | 0@@list("SR839" "MX_R0402_SMALL_T01" list(8415.000000 880.000000) nil) | 0@@list("SR84" "MX_R0402_SMALL_T01" list(6255.000000 948.000000) nil) | 0@@list("SR85" "MX_R0402_SMALL_T01" list(6318.000000 895.000000) nil) | 0@@list("SR87" "MX_R0402_SMALL_T01" list(6485.000000 1116.000000) nil) | 0@@list("SR92" "MX_R0402_SMALL_T01" list(6463.000000 1239.000000) nil) | 0@@list("SR94" "MX_R0402_SMALL_T01" list(7559.800000 1932.600000) nil) | 0@@list("TC1" "MX_C0402_SMALL_T01" list(9125.000000 2556.000000) nil) | 0@@list("TC10" "MX_C0402_SMALL_T01" list(9129.000000 1874.000000) nil) | 0@@list("TC11" "MX_C0402_SMALL_T01" list(9129.000000 1765.000000) nil) | 0@@list("TC12" "MX_C0402_SMALL_T01" list(9129.000000 1729.000000) nil) | 0@@list("TC2" "MX_C0402_SMALL_T01" list(9125.000000 2520.000000) nil) | 0@@list("TC21" "MX_C0402_SMALL_T01" list(9110.000000 1249.000000) nil) | 0@@list("TC22" "MX_C0402_SMALL_T01" list(9110.180000 1213.000000) nil) | 0@@list("TC23" "MX_C0402_SMALL_T01" list(9111.180000 1172.000000) nil) | 0@@list("TC24" "MX_C0402_SMALL_T01" list(9111.000000 1135.000000) nil) | 0@@list("TC3" "MX_C0402_SMALL_T01" list(9125.000000 2436.000000) nil) | 0@@list("TC4" "MX_C0402_SMALL_T01" list(9125.000000 2400.000000) nil) | 0@@list("TC5" "MX_C0402_SMALL_T01" list(9128.000000 511.000000) nil) | 0@@list("TC6" "MX_C0402_SMALL_T01" list(9128.000000 475.000000) nil) | 0@@list("TC7" "MX_C0402_SMALL_T01" list(9123.000000 347.000000) nil) | 0@@list("TC8" "MX_C0402_SMALL_T01" list(9123.000000 311.000000) nil) | 0@@list("TC9" "MX_C0402_SMALL_T01" list(9129.000000 1910.000000) nil) | 0@@list("TUC21" "MX_C0603_SMALL_T01" list(449.000000 6063.000000) nil) | 0@@list("TUC22" "MX_C0402_SMALL_T01" list(342.100000 5784.100000) nil) | 0@@list("U10" "A_QFN_40P_16_201X201_PA" list(1377.000000 8489.000000) nil) | 0@@list("U104" "MX_QFP_128P_16_S630_H47" list(8470.040000 1285.120000) nil) | 0@@list("U15" "A_QFP_48P_20_283X283" list(4495.000000 1418.000000) nil) | 0@@list("U2FC1" "MX_C0805_SMALL_T02" list(3454.000000 516.000000) nil) | 0@@list("U2FC2" "MX_C0402_SMALL_T01" list(3510.000000 499.000000) nil) | 0@@list("U4" "MX_QFN_64P_20_S354_P_MA_12V" list(1447.470000 5684.090000) nil) | 0@@list("U5" "MX_QFN_32P_16_S161_PD_8V" list(740.000000 5825.000000) nil) | 0@@list("U51" "MX_QFN_16P_20_S118_PAD_RIC" list(8910.810000 4009.840000) nil) | 0@@list("U942691" "MX_QFN_16P_20_S118_PAD_RIC" list(8836.810000 4477.520000) nil) | 0@@list("UC1" "MX_C0402_SMALL_T01" list(1289.000000 5411.000000) nil) | 0@@list("UC10" "MX_C0603_SMALL_T02" list(9146.000000 4482.000000) nil) | 0@@list("UC11" "MX_C0603_SMALL_T02" list(9067.000000 3410.000000) nil) | 0@@list("UC12" "MX_C0402_SMALL_T01" list(9183.000000 4292.000000) nil) | 0@@list("UC16" "MX_C0402_SMALL_T01" list(9183.000000 4256.000000) nil) | 0@@list("UC29" "MX_C0402_SMALL_T01" list(1172.090000 5213.920000) nil) | 0@@list("UC30" "MX_C0402_SMALL_T01" list(1146.640000 5188.460000) nil) | 0@@list("UC31" "MX_C0402_SMALL_T01" list(1058.510000 5509.000000) nil) | 0@@list("UC32" "MX_C0402_SMALL_T01" list(1094.520000 5509.000000) nil) | 0@@list("UC50" "MX_C0402_SMALL_T01" list(9117.000000 3815.000000) nil) | 0@@list("UC51" "MX_C0402_SMALL_T01" list(9081.000000 3815.000000) nil) | 0@@list("UC52" "MX_C0402_SMALL_T01" list(9160.000000 3728.000000) nil) | 0@@list("UC53" "MX_C0402_SMALL_T01" list(9196.000000 3728.000000) nil) | 0@@list("UC641" "MX_C0603_SMALL_T01" list(1416.000000 7098.000000) nil) | 0@@list("UC68" "MX_C0402_SMALL_T01" list(1665.000000 5761.000000) nil) | 0@@list("UC69" "MX_C0402_SMALL_T01" list(1656.000000 5466.000000) nil) | 0@@list("UC72" "MX_C0201" list(1520.000000 5941.000000) nil) | 0@@list("UC74" "MX_C0201" list(1664.000000 5557.000000) nil) | 0@@list("UC75" "MX_C0201" list(1431.000000 5959.000000) nil) | 0@@list("UC77" "MX_C0402_SMALL_T01" list(1209.000000 5820.000000) nil) | 0@@list("UC78" "MX_C0402_SMALL_T01" list(1165.900000 5657.900000) nil) | 0@@list("UC79" "MX_C0402_SMALL_T01" list(1417.940000 5434.000000) nil) | 0@@list("UC81" "MX_C0402_SMALL_T01" list(1217.000000 5748.000000) nil) | 0@@list("UC82" "MX_C0402_SMALL_T01" list(1593.000000 5442.300000) nil) | 0@@list("UC83" "MX_C0402_SMALL_T01" list(1503.000000 5415.000000) nil) | 0@@list("UC86" "MX_C0402_SMALL_T01" list(1389.000000 5320.000000) nil) | 0@@list("UC87" "MX_C0402_SMALL_T01" list(1425.000000 5320.000000) nil) | 0@@list("UC9" "MX_C0402_SMALL_T01" list(9006.000000 4062.000000) nil) | 0@@list("UC90" "MX_C0402_SMALL_T01" list(1202.000000 5502.000000) nil) | 0@@list("UC91" "MX_C0603_SMALL_T01" list(1781.380000 5516.720000) nil) | 0@@list("UC92" "MX_C0603_SMALL_T01" list(1535.200000 6111.600000) nil) | 0@@list("UC93" "MX_C0603_SMALL_T01" list(1694.720000 5149.620000) nil) | 0@@list("UC94" "MX_C0201" list(1500.000000 7504.000000) nil) | 0@@list("UC943" "MX_C0402_SMALL_T01" list(1461.000000 5349.000000) nil) | 0@@list("UC944" "MX_C0402_SMALL_T01" list(1497.000000 5349.000000) nil) | 0@@list("UC946" "MX_C0402_SMALL_T01" list(531.000000 5868.000000) nil) | 0@@list("UC947" "MX_C0402_SMALL_T01" list(531.000000 5832.000000) nil) | 0@@list("UC948" "MX_C0402_SMALL_T01" list(576.000000 5710.000000) nil) | 0@@list("UC949" "MX_C0402_SMALL_T01" list(612.000000 5710.000000) nil) | 0@@list("UC950" "MX_C0402_SMALL_T01" list(1307.000000 5943.000000) nil) | 0@@list("UC959" "MX_C0402_SMALL_T01" list(9146.000000 4854.000000) nil) | 0@@list("UC96" "MX_C0402_SMALL_T01" list(1251.000000 5057.000000) nil) | 0@@list("UC960" "MX_C0402_SMALL_T01" list(9067.000000 4939.000000) nil) | 0@@list("UC963" "MX_C0402_SMALL_T01" list(9103.000000 4939.000000) nil) | 0@@list("UC964" "MX_C0402_SMALL_T01" list(9182.000000 4854.000000) nil) | 0@@list("UC965" "MX_C0201" list(905.000000 5825.000000) nil) | 0@@list("UC968" "MX_C0402_SMALL_T01" list(9171.000000 4569.000000) nil) | 0@@list("UC969" "MX_C0402_SMALL_T01" list(1632.000000 5906.000000) nil) | 0@@list("UC97" "MX_C0402_SMALL_T01" list(1251.000000 5021.000000) nil) | 0@@list("UC970" "MX_C0402_SMALL_T01" list(1209.000000 5859.000000) nil) | 0@@list("UC971" "MX_C0402_SMALL_T01" list(1537.000000 5991.000000) nil) | 0@@list("UC972" "MX_C0402_SMALL_T01" list(9130.000000 4569.000000) nil) | 0@@list("UC973" "MX_C0402_SMALL_T01" list(9239.000000 4472.000000) nil) | 0@@list("UC974" "MX_C0402_SMALL_T01" list(9290.000000 3483.000000) nil) | 0@@list("UC975" "MX_C0402_SMALL_T01" list(478.000000 5908.000000) nil) | 0@@list("UC976" "MX_C0402_SMALL_T01" list(478.000000 5944.000000) nil) | 0@@list("UC977" "MX_C0402_SMALL_T01" list(505.000000 5755.000000) nil) | 0@@list("UC978" "MX_C0402_SMALL_T01" list(505.000000 5791.000000) nil) | 0@@list("UC979" "MX_C0402_SMALL_T01" list(1058.800000 5330.800000) nil) | 0@@list("UC98" "MX_C0402_SMALL_T01" list(1213.390000 5131.150000) nil) | 0@@list("UC980" "MX_C0402_SMALL_T01" list(1058.800000 5294.400000) nil) | 0@@list("UC981" "MX_C0402_SMALL_T01" list(1019.000000 5072.000000) nil) | 0@@list("UC982" "MX_C0402_SMALL_T01" list(1019.000000 5036.000000) nil) | 0@@list("UC983" "MX_C0402_SMALL_T01" list(1119.000000 5015.000000) nil) | 0@@list("UC984" "MX_C0402_SMALL_T01" list(1119.000000 4979.000000) nil) | 0@@list("UC985" "MX_C0402_SMALL_T01" list(1054.000000 4957.000000) nil) | 0@@list("UC986" "MX_C0402_SMALL_T01" list(1054.000000 4921.000000) nil) | 0@@list("UC987" "MX_C0402_SMALL_T01" list(9061.000000 3645.220000) nil) | 0@@list("UC988" "MX_C0402_SMALL_T01" list(9097.190000 3645.220000) nil) | 0@@list("UC99" "MX_C0402_SMALL_T01" list(1213.390000 5095.150000) nil) | 0@@list("UC991" "MX_C0402_SMALL_T01" list(9102.180000 3538.190000) nil) | 0@@list("UC992" "MX_C0402_SMALL_T01" list(9102.180000 3502.190000) nil) | 0@@list("UC993" "MX_C0402_SMALL_T01" list(9073.600000 4814.800000) nil) | 0@@list("UC994" "MX_C0402_SMALL_T01" list(9073.600000 4778.800000) nil) | 0@@list("UC995" "MX_C0402_SMALL_T01" list(9102.000000 4689.400000) nil) | 0@@list("UC996" "MX_C0402_SMALL_T01" list(9102.000000 4726.400000) nil) | 0@@list("UCB1" "MX_C0603_SMALL_T02" list(357.150000 5543.380000) nil) | 0@@list("UCB18" "MX_C0201" list(2435.000000 355.000000) nil) | 0@@list("UCB19" "MX_C0201" list(2595.000000 355.000000) nil) | 0@@list("UCB2" "MX_C0603_SMALL_T02" list(943.840000 5479.380000) nil) | 0@@list("UCB23" "MX_C0201" list(326.000000 5467.000000) nil) | 0@@list("UCB24" "MX_C0201" list(899.000000 5470.000000) nil) | 0@@list("UCB25" "MX_C0201" list(1017.000000 7624.000000) nil) | 0@@list("UCB26" "MX_C0201" list(2733.000000 355.000000) nil) | 0@@list("UCB27" "MX_C0402_SMALL_T01" list(2159.000000 360.000000) nil) | 0@@list("UCB28" "MX_C0402_SMALL_T01" list(2244.000000 360.000000) nil) | 0@@list("UCB3" "MX_C0603_SMALL_T02" list(1000.530000 5479.380000) nil) | 0@@list("UCB4" "MX_C0603_SMALL_T02" list(409.220000 5543.380000) nil) | 0@@list("UCB5" "MX_C0603_SMALL_T02" list(834.000000 8551.000000) nil) | 0@@list("UCB6" "MX_C0603_SMALL_T02" list(834.000000 8607.000000) nil) | 0@@list("UCB9" "MX_C0201" list(977.000000 7624.000000) nil) | 0@@list("UCC1" "C0402" list(4625.000000 1655.000000) nil) | 0@@list("UCC10" "MX_C0402_SMALL_T01" list(4385.000000 1672.000000) nil) | 0@@list("UCC11" "MX_C0201" list(3978.000000 1490.000000) nil) | 0@@list("UCC12" "MX_C0402_SMALL_T01" list(4014.000000 1494.000000) nil) | 0@@list("UCC13" "MX_C0402_SMALL_T01" list(4241.000000 1283.000000) nil) | 0@@list("UCC14" "MX_C0402_SMALL_T01" list(4242.000000 1350.000000) nil) | 0@@list("UCC2" "C0402" list(4543.000000 1695.000000) nil) | 0@@list("UCC3" "MX_C0201" list(4468.600000 1658.000000) nil) | 0@@list("UCC4" "MX_C0201" list(4238.000000 1224.000000) nil) | 0@@list("UCC5" "MX_C0201" list(4610.700000 1173.800000) nil) | 0@@list("UCC6" "MX_C0201" list(4744.000000 1508.000000) nil) | 0@@list("UCC7" "MX_C0201" list(4685.000000 1640.000000) nil) | 0@@list("UCC8" "MX_C0603_SMALL_T01" list(4764.000000 1553.000000) nil) | 0@@list("UCC9" "MX_C0603_SMALL_T01" list(4306.000000 1618.000000) nil) | 0@@list("UCR11" "MX_R0402_SMALL_T01" list(4524.300000 1123.900000) nil) | 0@@list("UCR12" "MX_R0402_SMALL_T01" list(4558.800000 1123.900000) nil) | 0@@list("UCR13" "MX_R0402_SMALL_T01" list(4215.000000 1416.000000) nil) | 0@@list("UCR14" "MX_R0402_SMALL_T01" list(4215.000000 1451.000000) nil) | 0@@list("UCR15" "MX_R0402_SMALL_T01" list(4115.000000 1488.000000) nil) | 0@@list("UCR19" "MX_R0402_SMALL_T01" list(4787.000000 1451.000000) nil) | 0@@list("UCR22" "MX_R0402_SMALL_T01" list(4436.000000 1704.000000) nil) | 0@@list("UCR23" "MX_R0402_SMALL_T01" list(4787.000000 1416.000000) nil) | 0@@list("UCR24" "MX_R0402_SMALL_T01" list(4115.000000 1523.000000) nil) | 0@@list("UCR25" "MX_R0402_SMALL_T01" list(4050.000000 1108.000000) nil) | 0@@list("UCR26" "MX_R0603_SMALL_T01" list(4764.000000 1602.000000) nil) | 0@@list("UCR27" "MX_R0603_SMALL_T01" list(4277.000000 1676.000000) nil) | 0@@list("UCR28" "MX_R0402_SMALL_T01" list(4772.000000 1288.000000) nil) | 0@@list("UCR29" "MX_R0402_SMALL_T01" list(4844.000000 1288.000000) nil) | 0@@list("UCR3" "MX_R0402_SMALL_T01" list(4392.000000 1737.000000) nil) | 0@@list("UCR30" "MX_R0402_SMALL_T01" list(4614.000000 1698.000000) nil) | 0@@list("UCR31" "MX_R0402_SMALL_T01" list(4354.000000 1108.000000) nil) | 0@@list("UCR34" "MX_R0402_SMALL_T01" list(4354.000000 1143.000000) nil) | 0@@list("UCR36" "MX_R0402_SMALL_T01" list(4409.000000 1093.000000) nil) | 0@@list("UCR39" "MX_R0402_SMALL_T01" list(4445.000000 1093.000000) nil) | 0@@list("UCR41" "MX_R0603_SMALL_T01" list(4848.000000 1527.000000) nil) | 0@@list("UCR43" "MX_R0402_SMALL_T01" list(5562.500000 495.500000) nil) | 0@@list("UCR44" "MX_R0402_SMALL_T01" list(5472.800000 435.400000) nil) | 0@@list("UCR45" "MX_R0402_SMALL_T01" list(4202.800000 1139.700000) nil) | 0@@list("UCR46" "MX_R0402_SMALL_T01" list(4629.600000 1113.300000) nil) | 0@@list("UCR47" "MX_R0402_SMALL_T01" list(4596.000000 1113.400000) nil) | 0@@list("UD8869" "MX_SOD123" list(1360.000000 7285.000000) nil) | 0@@list("UD8878" "MX_S0402_AMAZ_COLAY" list(1114.000000 8035.000000) nil) | 0@@list("UD8879" "MX_S0402_AMAZ_COLAY" list(1116.000000 7877.000000) nil) | 0@@list("UD8880" "MX_S0402_AMAZ_COLAY" list(1114.000000 8104.000000) nil) | 0@@list("UD8881" "MX_S0402_AMAZ_COLAY" list(1116.000000 7822.000000) nil) | 0@@list("UF5" "MX_POLYSWITCH_2P_0805_H30" list(2475.000000 450.000000) nil) | 0@@list("UF6" "MX_POLYSWITCH_2P_0805_H30" list(2585.000000 450.000000) nil) | 0@@list("UF7" "MX_POLYSWITCH_2P_0805_H30" list(2736.000000 447.000000) nil) | 0@@list("UR195" "MX_R0402_SMALL_T01" list(1423.000000 7350.000000) nil) | 0@@list("UR30" "MX_R0402_SMALL_T01" list(637.000000 5556.000000) nil) | 0@@list("UR5" "MX_R0402_SMALL_T01" list(8789.000000 4703.000000) nil) | 0@@list("UR6" "MX_R0402_SMALL_T01" list(8876.000000 4605.000000) nil) | 0@@list("UR69686" "MX_R0402_SMALL_T01" list(1557.000000 5440.800000) nil) | 0@@list("UR69692" "MX_R0402_SMALL_T01" list(1423.000000 7210.000000) nil) | 0@@list("UR69695" "MX_R0402_SMALL_T01" list(1723.000000 5466.000000) nil) | 0@@list("UR69703" "MX_R0402_SMALL_T01" list(1606.000000 7603.000000) nil) | 0@@list("UR69704" "MX_R0402_SMALL_T01" list(1642.000000 7603.000000) nil) | 0@@list("UR69705" "MX_R0402_SMALL_T01" list(1271.000000 5943.000000) nil) | 0@@list("UR69710" "MX_R0402_SMALL_T01" list(765.000000 5612.000000) nil) | 0@@list("UR69711" "MX_R0402_SMALL_T01" list(940.000000 8935.000000) nil) | 0@@list("UR69714" "MX_R0402_SMALL_T01" list(8965.500000 5491.000000) nil) | 0@@list("UR69715" "MX_R0402_SMALL_T01" list(8859.000000 4197.000000) nil) | 0@@list("UR69716" "MX_R0402_SMALL_T01" list(8957.000000 4150.000000) nil) | 0@@list("UR69717" "MX_R0402_SMALL_T01" list(8820.000000 5300.000000) nil) | 0@@list("UR69718" "MX_R0402_SMALL_T01" list(8820.000000 5337.000000) nil) | 0@@list("UR69719" "MX_R0402_SMALL_T01" list(815.000000 5597.000000) nil) | 0@@list("UR69720" "MX_R0402_SMALL_T01" list(868.000000 5568.000000) nil) | 0@@list("UR69721" "MX_R0402_SMALL_T01" list(513.000000 5494.000000) nil) | 0@@list("UR69722" "MX_R0402_SMALL_T01" list(513.000000 5458.000000) nil) | 0@@list("UR69723" "MX_R0402_SMALL_T01" list(1446.000000 7900.000000) nil) | 0@@list("UR69724" "MX_R0402_SMALL_T01" list(1482.000000 7900.000000) nil) | 0@@list("UR69725" "MX_R0402_SMALL_T01" list(908.000000 8806.000000) nil) | 0@@list("UR69726" "MX_R0402_SMALL_T01" list(948.000000 8806.000000) nil) | 0@@list("UR69729" "MX_R0402_SMALL_T01" list(8982.000000 5441.000000) nil) | 0@@list("UR69730" "MX_R0402_SMALL_T01" list(8980.500000 5181.190000) nil) | 0@@list("UR69741" "MX_R0402_SMALL_T01" list(8820.000000 4248.000000) nil) | 0@@list("UR69742" "MX_R0402_SMALL_T01" list(9022.000000 4271.000000) nil) | 0@@list("UR69743" "MX_R0402_SMALL_T01" list(8986.000000 4318.000000) nil) | 0@@list("UR69744" "MX_R0402_SMALL_T01" list(8859.500000 4706.000000) nil) | 0@@list("UR69745" "MX_R0402_SMALL_T01" list(8843.000000 4759.000000) nil) | 0@@list("UR69746" "MX_R0402_SMALL_T01" list(8795.170000 4931.000000) nil) | 0@@list("UR69747" "MX_R0402_SMALL_T01" list(9201.000000 5405.000000) nil) | 0@@list("UR69748" "MX_R0402_SMALL_T01" list(9382.000000 3503.000000) nil) | 0@@list("URN10" "MX_2R4P0402" list(847.040000 4613.000000) nil) | 0@@list("URN126" "MX_2R4P0402" list(1196.000000 7697.000000) nil) | 0@@list("URN130" "MX_2R4P0402" list(865.000000 4512.000000) nil) | 0@@list("URN131" "MX_2R4P0402" list(552.000000 4713.000000) nil) | 0@@list("URN134" "MX_2R4P0402" list(1196.000000 7757.000000) nil) | 0@@list("URN137" "MX_2R4P0402" list(1076.000000 7118.000000) nil) | 0@@list("URN138" "MX_2R4P0402" list(1076.000000 7177.000000) nil) | 0@@list("URN139" "MX_2R4P0402" list(1075.000000 7307.000000) nil) | 0@@list("URN140" "MX_2R4P0402" list(1075.100000 7246.500000) nil) | 0@@list("URN143" "MX_2R4P0402" list(9080.000000 5246.000000) nil) | 0@@list("URN144" "MX_2R4P0402" list(9147.000000 5186.000000) nil) | 0@@list("URN148" "MX_2R4P0402" list(446.000000 6005.000000) nil) | 0@@list("URN149" "MX_2R4P0402" list(1075.570000 5425.600000) nil) | 0@@list("URN151" "MX_2R4P0402" list(1041.000000 5121.950000) nil) | 0@@list("URN155" "MX_2R4P0402" list(1041.000000 5245.390000) nil) | 0@@list("URN156" "MX_2R4P0402" list(1041.000000 5183.750000) nil) | 0@@list("URN159" "MX_2R4P0402" list(499.170000 5680.000000) nil) | 0@@list("URN161" "MX_2R4P0402" list(448.000000 5848.000000) nil) | 0@@list("URN163" "MX_2R4P0402" list(9103.000000 3895.270000) nil) | 0@@list("URN164" "MX_2R4P0402" list(9178.000000 3809.630000) nil) | 0@@list("URN167" "MX_2R4P0402" list(9086.000000 5018.000000) nil) | 0@@list("URN168" "MX_2R4P0402" list(9163.000000 4934.000000) nil) | 0@@list("URN60" "MX_2R4P0402" list(9092.000000 4252.000000) nil) | 0@@list("URN62" "MX_2R4P0402" list(9128.830000 4046.000000) nil) | 0@@list("URN9" "MX_2R4P0402" list(552.040000 4654.000000) nil) | 0@@list("UU10" "A_DFN_10P_20_98X39_ONSEM" list(350.000000 5907.000000) nil) | 0@@list("UU14" "MX_ESD_10P_20_98X39_NXP" list(950.000000 4943.000000) nil) | 0@@list("UU22" "MX_ESD_10P_20_98X39_NXP" list(9186.500000 3560.000000) nil) | 0@@list("UU26" "MX_ESD_10P_20_98X39_NXP" list(9185.000000 3930.000000) nil) | 0@@list("UU34" "A_DFN_10P_20_98X39_ONSEM" list(410.000000 5708.000000) nil) | 0@@list("UU39" "A_DFN_10P_20_98X39_ONSEM" list(951.000000 5330.000000) nil) | 0@@list("UU4" "MX_ESD_10P_20_98X39_NXP" list(9164.000000 4161.000000) nil) | 0@@list("UU40" "MX_ESD_10P_20_98X39_NXP" list(950.000000 5207.000000) nil) | 0@@list("UU43" "MX_ESD_10P_20_98X39_NXP" list(9186.500000 4745.000000) nil) | 0@@list("UU44" "MX_ESD_10P_20_98X39_NXP" list(9182.000000 5046.000000) nil) | 0@@list("UU5" "MX_ESD_10P_20_98X39_NXP" list(9171.000000 5301.000000) nil) | 0@@list("UU52" "MX_ESD_10P_20_98X39_NXP" list(344.000000 6034.000000) nil) | 0@@list("UU53" "MX_ESD_10P_20_98X39_NXP" list(950.000000 5083.000000) nil) | 0@@list("UU54" "MX_SOT23_S5_2D4_122X67_H35" list(1405.000000 6395.000000) nil) | 0@@list("VCB155" "MX_C0402_SMALL_T01" list(1034.000000 6632.600000) nil) | 0@@list("X1" "MX_XTAL_4P_126X98_HELE_H31" list(1287.000000 5323.000000) nil) | 0@@list("XC1" "MX_C0402_SMALL_T01" list(2464.000000 3410.000000) nil) | 0@@list("XC10" "MX_C0402_SMALL_T01" list(3109.000000 3410.000000) nil) | 0@@list("XC11" "MX_C0402_SMALL_T01" list(3305.000000 3410.000000) nil) | 0@@list("XC112" "MX_C0402_SMALL_T01" list(2441.000000 1015.000000) nil) | 0@@list("XC113" "MX_C0402_SMALL_T01" list(2405.000000 1015.000000) nil) | 0@@list("XC114" "MX_C0402_SMALL_T01" list(2591.000000 1015.000000) nil) | 0@@list("XC115" "MX_C0402_SMALL_T01" list(2555.000000 1015.000000) nil) | 0@@list("XC116" "MX_C0402_SMALL_T01" list(2751.000000 1015.000000) nil) | 0@@list("XC117" "MX_C0402_SMALL_T01" list(2715.000000 1015.000000) nil) | 0@@list("XC118" "MX_C0402_SMALL_T01" list(2911.000000 1015.000000) nil) | 0@@list("XC119" "MX_C0402_SMALL_T01" list(2875.000000 1015.000000) nil) | 0@@list("XC12" "MX_C0402_SMALL_T01" list(3269.000000 3410.000000) nil) | 0@@list("XC120" "MX_C0402_SMALL_T01" list(3151.000000 1015.000000) nil) | 0@@list("XC121" "MX_C0402_SMALL_T01" list(3115.000000 1015.000000) nil) | 0@@list("XC122" "MX_C0402_SMALL_T01" list(3306.000000 1015.000000) nil) | 0@@list("XC123" "MX_C0402_SMALL_T01" list(3270.000000 1015.000000) nil) | 0@@list("XC124" "MX_C0402_SMALL_T01" list(3430.000000 1015.000000) nil) | 0@@list("XC125" "MX_C0402_SMALL_T01" list(3466.000000 1015.000000) nil) | 0@@list("XC126" "MX_C0402_SMALL_T01" list(3615.000000 1015.000000) nil) | 0@@list("XC127" "MX_C0402_SMALL_T01" list(3579.000000 1015.000000) nil) | 0@@list("XC128" "MX_C0402_SMALL_T01" list(2353.500000 1864.500000) nil) | 0@@list("XC129" "MX_C0402_SMALL_T01" list(2770.000000 3785.000000) nil) | 0@@list("XC13" "MX_C0402_SMALL_T01" list(3460.000000 3410.000000) nil) | 0@@list("XC130" "MX_C0402_SMALL_T01" list(2770.000000 3745.000000) nil) | 0@@list("XC131" "MX_C0402_SMALL_T01" list(2232.000000 3018.000000) nil) | 0@@list("XC14" "MX_C0402_SMALL_T01" list(3424.000000 3410.000000) nil) | 0@@list("XC15" "MX_C0402_SMALL_T01" list(3620.000000 3410.000000) nil) | 0@@list("XC16" "MX_C0402_SMALL_T01" list(3584.000000 3410.000000) nil) | 0@@list("XC2" "MX_C0402_SMALL_T01" list(2428.000000 3410.000000) nil) | 0@@list("XC3" "MX_C0402_SMALL_T01" list(2595.000000 3410.000000) nil) | 0@@list("XC33" "MX_C0402_SMALL_T01" list(2198.000000 2605.000000) nil) | 0@@list("XC35" "MX_C0402_SMALL_T01" list(2295.000000 3395.000000) nil) | 0@@list("XC4" "MX_C0402_SMALL_T01" list(2559.000000 3410.000000) nil) | 0@@list("XC5" "MX_C0402_SMALL_T01" list(2750.000000 3410.000000) nil) | 0@@list("XC6" "MX_C0402_SMALL_T01" list(2714.000000 3410.000000) nil) | 0@@list("XC7" "MX_C0402_SMALL_T01" list(2910.000000 3410.000000) nil) | 0@@list("XC8" "MX_C0402_SMALL_T01" list(2874.000000 3410.000000) nil) | 0@@list("XC89" "MX_C0201" list(2255.000000 2979.000000) nil) | 0@@list("XC9" "MX_C0402_SMALL_T01" list(3145.000000 3410.000000) nil) | 0@@list("XC90" "MX_C0201" list(1670.000000 3025.000000) nil) | 0@@list("XC91" "MX_C0201" list(2089.000000 3020.000000) nil) | 0@@list("XC92" "MX_C0402_SMALL_T01" list(2236.000000 1032.000000) nil) | 0@@list("XC93" "MX_C0201" list(2151.000000 553.000000) nil) | 0@@list("XC94" "MX_C0201" list(2077.000000 554.000000) nil) | 0@@list("XC95" "MX_C0402_SMALL_T01" list(1670.000000 1000.000000) nil) | 0@@list("XCB5" "MX_C0201" list(1963.000000 2168.000000) nil) | 0@@list("XCB6" "MX_C0201" list(2165.000000 1375.000000) nil) | 0@@list("XCE14" "MX_C0402_SMALL_T01" list(2770.000000 3680.000000) nil) | 0@@list("XDP2" "BTOB_60P_20_F_SAMT" list(3692.940000 4195.040000) nil) | 0@@list("XR1" "MX_R0402_SMALL_T01" list(2064.000000 2620.000000) nil) | 0@@list("XR10" "MX_R0402_SMALL_T01" list(1887.000000 3016.000000) nil) | 0@@list("XR11" "MX_R0402_SMALL_T01" list(1773.000000 3399.000000) nil) | 0@@list("XR12" "MX_R0402_SMALL_T01" list(2055.000000 1020.000000) nil) | 0@@list("XR13" "MX_R0402_SMALL_T01" list(2114.000000 553.000000) nil) | 0@@list("XR14" "MX_R0402_SMALL_T01" list(1945.000000 1005.000000) nil) | 0@@list("XR15" "MX_R0402_SMALL_T01" list(1805.000000 1005.000000) nil) | 0@@list("XR16" "MX_R0402_SMALL_T01" list(2000.000000 1020.000000) nil) | 0@@list("XR17" "MX_R0402_SMALL_T01" list(2012.000000 1821.000000) nil) | 0@@list("XR18" "MX_R0402_SMALL_T01" list(1976.000000 1821.000000) nil) | 0@@list("XR19" "MX_R0402_SMALL_T01" list(2255.000000 1370.000000) nil) | 0@@list("XR2" "MX_R0402_SMALL_T01" list(2100.000000 2620.000000) nil) | 0@@list("XR20" "MX_R0402_SMALL_T01" list(1940.000000 1821.000000) nil) | 0@@list("XR3" "MX_R0402_SMALL_T01" list(2238.000000 2180.000000) nil) | 0@@list("XR4" "MX_R0402_SMALL_T01" list(2024.000000 2620.000000) nil) | 0@@list("XR5" "MX_R0402_SMALL_T01" list(2155.000000 3020.000000) nil) | 0@@list("XR8" "MX_R0402_SMALL_T01" list(2040.000000 3401.000000) nil) | 0@@list("XR9" "MX_R0402_SMALL_T01" list(2106.000000 3401.000000) nil) | 0@@list("Y10" "MX_XTAL_4P_126X98_HOSON_H35" list(1223.000000 8853.000000) nil) | 0@@list("Y18" "MX_XTAL_4P_126X98_HELE" list(5870.000000 2458.000000) nil) | 0@@list("Y19" "MX_XTAL_4P_126X98_HELE" list(4591.000000 1788.000000) nil) | 100@@5s-ipcfl-sc.x001@@C151001753-PC@@Cissy_Fang@@Jun 27 11:53:53 2017 | 12@@list("" "INDEXB_CROSS" list(1273.000000 661.000000) nil) | 12@@list("" "INDEXB_CROSS" list(704.000000 9363.000000) nil) | 12@@list("" "INDEXB_CROSS" list(9035.000000 1014.000000) nil) | 12@@list("AC129" "MX_C0402_SMALL_T01" list(1580.000000 330.000000) nil) | 12@@list("AC130" "MX_C0402_SMALL_T01" list(735.000000 3255.000000) nil) | 12@@list("AC136" "MX_C0402_SMALL_T01" list(549.000000 6907.000000) nil) | 12@@list("AC15" "MX_C0603_SMALL_T01" list(987.080000 687.000000) nil) | 12@@list("AC16" "MX_C0603_SMALL_T01" list(300.000000 695.080000) nil) | 12@@list("AC161" "C1206_H75" list(595.000000 950.000000) nil) | 12@@list("AC162" "C1206_H75" list(695.000000 950.000000) nil) | 12@@list("AC163" "C1206_H75" list(490.000000 950.000000) nil) | 12@@list("AC164" "C1206_H75" list(390.000000 950.000000) nil) | 12@@list("AC173" "MX_C0402_SMALL_T01" list(298.000000 2700.000000) nil) | 12@@list("AC174" "MX_C0402_SMALL_T01" list(207.000000 2700.000000) nil) | 12@@list("AC175" "MX_C0402_SMALL_T01" list(389.000000 2700.000000) nil) | 12@@list("AC176" "MX_C0402_SMALL_T01" list(480.000000 2700.000000) nil) | 12@@list("AC177" "MX_C0402_SMALL_T01" list(662.000000 2700.000000) nil) | 12@@list("AC178" "MX_C0402_SMALL_T01" list(571.000000 2700.000000) nil) | 12@@list("AC179" "MX_C0402_SMALL_T01" list(682.000000 3504.000000) nil) | 12@@list("AC18" "MX_C0603_SMALL_T01" list(465.000000 335.080000) nil) | 12@@list("AC180" "MX_C0402_SMALL_T01" list(770.000000 3502.000000) nil) | 12@@list("AC181" "MX_C0402_SMALL_T01" list(470.000000 3470.000000) nil) | 12@@list("AC182" "MX_C0402_SMALL_T01" list(398.000000 3530.000000) nil) | 12@@list("AC183" "MX_C0402_SMALL_T01" list(261.500000 3475.000000) nil) | 12@@list("AC184" "MX_C0402_SMALL_T01" list(215.000000 2830.000000) nil) | 12@@list("AC185" "MX_C0402_SMALL_T01" list(575.000000 8755.000000) nil) | 12@@list("AC186" "MX_C0402_SMALL_T01" list(630.000000 8920.000000) nil) | 12@@list("AC188" "MX_C0603_SMALL_T01" list(940.000000 539.920000) nil) | 12@@list("AC193" "MX_C0402_SMALL_T01" list(2340.500000 345.500000) nil) | 12@@list("AC194" "MX_C0402_SMALL_T01" list(2850.000000 365.000000) nil) | 12@@list("AC195" "MX_C0402_SMALL_T01" list(2958.000000 365.000000) nil) | 12@@list("AC196" "MX_C0402_SMALL_T01" list(3069.000000 365.000000) nil) | 12@@list("AC197" "MX_C0402_SMALL_T01" list(2357.000000 453.000000) nil) | 12@@list("AC198" "MX_C0402_SMALL_T01" list(1130.000000 1178.000000) nil) | 12@@list("AC20" "MX_C0603_SMALL_T01" list(1049.000000 541.000000) nil) | 12@@list("AC22" "MX_C0402_SMALL_T01" list(930.000000 585.000000) nil) | 12@@list("AC23" "MX_C0603_SMALL_T01" list(300.000000 640.080000) nil) | 12@@list("AC24" "MX_C0402_SMALL_T01" list(1170.000000 445.000000) nil) | 12@@list("AC25" "MX_C0402_SMALL_T01" list(1235.000000 445.000000) nil) | 12@@list("AC26" "MX_C0402_SMALL_T01" list(715.000000 2795.000000) nil) | 12@@list("AC27" "MX_C0402_SMALL_T01" list(765.000000 1370.000000) nil) | 12@@list("AC3" "MX_C0603_SMALL_T01" list(271.000000 585.080000) nil) | 12@@list("AC47" "MX_C0402_SMALL_T01" list(8040.000000 1390.000000) nil) | 12@@list("AC52" "MX_C0402_SMALL_T01" list(715.000000 2955.000000) nil) | 12@@list("AC55" "MX_C0402_SMALL_T01" list(715.000000 2285.000000) nil) | 12@@list("AC71" "MX_C0603_SMALL_T02" list(1190.000000 1063.000000) nil) | 12@@list("AC72" "MX_C0402_SMALL_T01" list(1621.000000 215.000000) nil) | 12@@list("AC73" "MX_C0402_SMALL_T01" list(810.000000 440.000000) nil) | 12@@list("AC74" "MX_C0402_SMALL_T01" list(1072.000000 305.000000) nil) | 12@@list("AC75" "MX_C0402_SMALL_T01" list(1215.000000 305.000000) nil) | 12@@list("AC76" "MX_C0402_SMALL_T01" list(1360.000000 305.000000) nil) | 12@@list("AC77" "MX_C0402_SMALL_T01" list(1495.000000 305.000000) nil) | 12@@list("AD1" "MX_SOT23_2D4_H43" list(923.000000 222.000000) nil) | 12@@list("AD10" "MX_VARISTOR_0402" list(1130.000000 445.000000) nil) | 12@@list("AD11" "MX_VARISTOR_0402" list(1295.000000 445.000000) nil) | 12@@list("AD12" "MX_VARISTOR_0402" list(1455.000000 430.000000) nil) | 12@@list("AD13" "MX_VARISTOR_0402" list(292.000000 2740.000000) nil) | 12@@list("AD14" "MX_VARISTOR_0402" list(207.000000 2740.000000) nil) | 12@@list("AD15" "MX_VARISTOR_0402" list(389.000000 2740.000000) nil) | 12@@list("AD16" "MX_VARISTOR_0402" list(495.000000 2740.000000) nil) | 12@@list("AD17" "MX_VARISTOR_0402" list(662.000000 2740.000000) nil) | 12@@list("AD18" "MX_VARISTOR_0402" list(571.000000 2740.000000) nil) | 12@@list("AD19" "MX_VARISTOR_0402" list(688.000000 3542.000000) nil) | 12@@list("AD2" "MX_S0402_AMAZ_COLAY" list(800.000000 1270.000000) nil) | 12@@list("AD20" "MX_VARISTOR_0402" list(2410.770000 411.600000) nil) | 12@@list("AD21" "MX_VARISTOR_0402" list(2812.000000 366.000000) nil) | 12@@list("AD22" "MX_VARISTOR_0402" list(2996.000000 366.000000) nil) | 12@@list("AD23" "MX_VARISTOR_0402" list(2664.000000 355.000000) nil) | 12@@list("AD3" "MX_VARISTOR_0402" list(765.000000 3541.000000) nil) | 12@@list("AD4" "MX_VARISTOR_0402" list(480.000000 3525.000000) nil) | 12@@list("AD5" "MX_VARISTOR_0402" list(437.000000 3525.000000) nil) | 12@@list("AD6" "MX_VARISTOR_0402" list(265.000000 3535.000000) nil) | 12@@list("AD7" "MX_VARISTOR_0402" list(175.000000 2830.000000) nil) | 12@@list("AD8" "MX_VARISTOR_0402" list(1615.000000 175.000000) nil) | 12@@list("AD9" "MX_VARISTOR_0402" list(1014.000000 430.000000) nil) | 12@@list("AL1" "MX_L0603_SMALL_T02" list(765.000000 1200.000000) nil) | 12@@list("AL10" "MX_L0603_SMALL_T02" list(372.000000 3472.000000) nil) | 12@@list("AL11" "MX_L0603_SMALL_T02" list(207.000000 2655.000000) nil) | 12@@list("AL12" "MX_L0603_SMALL_T02" list(200.000000 3484.000000) nil) | 12@@list("AL13" "MX_L0603_SMALL_T02" list(298.000000 2655.000000) nil) | 12@@list("AL14" "MX_L0603_SMALL_T02" list(260.000000 2825.000000) nil) | 12@@list("AL15" "MX_L0603_SMALL_T02" list(1505.000000 370.000000) nil) | 12@@list("AL16" "MX_L0603_SMALL_T02" list(1350.000000 350.000000) nil) | 12@@list("AL17" "MX_L0603_SMALL_T02" list(1177.000000 360.000000) nil) | 12@@list("AL18" "MX_L0603_SMALL_T02" list(995.000000 318.000000) nil) | 12@@list("AL2" "MX_L0603_SMALL_T02" list(1040.000000 687.020000) nil) | 12@@list("AL3" "MX_L0603_SMALL_T02" list(571.000000 2655.000000) nil) | 12@@list("AL4" "MX_L0603_SMALL_T02" list(685.000000 3460.000000) nil) | 12@@list("AL5" "MX_L0603_SMALL_T02" list(662.000000 2655.000000) nil) | 12@@list("AL6" "MX_L0603_SMALL_T02" list(770.000000 3440.000000) nil) | 12@@list("AL7" "MX_L0603_SMALL_T02" list(480.000000 2655.000000) nil) | 12@@list("AL8" "MX_L0603_SMALL_T02" list(550.000000 3484.000000) nil) | 12@@list("AL9" "MX_L0603_SMALL_T02" list(389.000000 2655.000000) nil) | 12@@list("AMB_Q1" "MX_SOT23" list(8964.000000 3027.000000) nil) | 12@@list("APR112" "MX_R0402_SMALL_T01" list(997.000000 5653.000000) nil) | 12@@list("APR13" "MX_R0402_SMALL_T01" list(8397.000000 325.000000) nil) | 12@@list("AQ1" "MX_SOT363_PHILIPS" list(615.000000 2475.000000) nil) | 12@@list("AQ11" "MX_SOT23" list(898.500000 990.000000) nil) | 12@@list("AQ13" "MX_SOT23" list(1024.500000 990.000000) nil) | 12@@list("AQ14" "MX_SOT23" list(1005.000000 1143.000000) nil) | 12@@list("AQ16" "MX_SOT363_PHILIPS" list(245.000000 2475.000000) nil) | 12@@list("AQ17" "MX_SOT363_PHILIPS" list(235.000000 2300.000000) nil) | 12@@list("AQ18" "MX_SOT363_PHILIPS" list(516.000000 2302.360000) nil) | 12@@list("AQ2" "MX_SOT363_PHILIPS" list(430.000000 2475.000000) nil) | 12@@list("AQ23" "MX_SOT23" list(1160.000000 602.000000) nil) | 12@@list("AR1" "MX_R0402_SMALL_T01" list(1080.000000 885.000000) nil) | 12@@list("AR10" "MX_R0402_SMALL_T01" list(917.000000 373.000000) nil) | 12@@list("AR11" "MX_R0402_SMALL_T01" list(339.000000 505.000000) nil) | 12@@list("AR12" "MX_R0402_SMALL_T01" list(1255.000000 375.000000) nil) | 12@@list("AR13" "MX_R0402_SMALL_T01" list(1430.000000 339.000000) nil) | 12@@list("AR14" "MX_R0402_SMALL_T01" list(732.000000 1082.000000) nil) | 12@@list("AR15" "MX_R0402_SMALL_T01" list(732.000000 1117.000000) nil) | 12@@list("AR16" "MX_R0402_SMALL_T01" list(732.000000 1048.000000) nil) | 12@@list("AR17" "MX_R0402_SMALL_T01" list(770.000000 995.000000) nil) | 12@@list("AR18" "MX_R0402_SMALL_T01" list(267.000000 505.000000) nil) | 12@@list("AR19" "MX_R0402_SMALL_T01" list(375.000000 505.000000) nil) | 12@@list("AR199" "MX_R0402_SMALL_T01" list(223.000000 2390.000000) nil) | 12@@list("AR2" "MX_R0402_SMALL_T01" list(930.010000 630.000000) nil) | 12@@list("AR20" "MX_R0402_SMALL_T01" list(578.500000 8974.000000) nil) | 12@@list("AR200" "MX_R0402_SMALL_T01" list(186.620000 2390.260000) nil) | 12@@list("AR201" "MX_R0402_SMALL_T01" list(295.000000 2390.000000) nil) | 12@@list("AR202" "MX_R0402_SMALL_T01" list(259.000000 2390.000000) nil) | 12@@list("AR203" "MX_R0402_SMALL_T01" list(535.000000 2390.000000) nil) | 12@@list("AR204" "MX_R0402_SMALL_T01" list(499.000000 2390.000000) nil) | 12@@list("AR205" "MX_R0402_SMALL_T01" list(563.000000 2610.000000) nil) | 12@@list("AR206" "MX_R0402_SMALL_T01" list(649.500000 2610.000000) nil) | 12@@list("AR207" "MX_R0402_SMALL_T01" list(563.000000 2570.000000) nil) | 12@@list("AR208" "MX_R0402_SMALL_T01" list(649.500000 2570.000000) nil) | 12@@list("AR209" "MX_R0402_SMALL_T01" list(685.000000 3415.000000) nil) | 12@@list("AR210" "MX_R0402_SMALL_T01" list(705.000000 3365.000000) nil) | 12@@list("AR211" "MX_R0402_SMALL_T01" list(478.010000 2570.000000) nil) | 12@@list("AR212" "MX_R0402_SMALL_T01" list(610.000000 3424.000000) nil) | 12@@list("AR213" "MX_R0402_SMALL_T01" list(389.010000 2570.000000) nil) | 12@@list("AR214" "MX_R0402_SMALL_T01" list(308.500000 3479.990000) nil) | 12@@list("AR215" "MX_R0402_SMALL_T01" list(207.010000 2570.000000) nil) | 12@@list("AR216" "MX_R0402_SMALL_T01" list(190.000000 3404.000000) nil) | 12@@list("AR217" "MX_R0402_SMALL_T01" list(298.010000 2570.000000) nil) | 12@@list("AR218" "MX_R0402_SMALL_T01" list(329.500000 2793.000000) nil) | 12@@list("AR219" "MX_R0402_SMALL_T01" list(190.000000 3440.000000) nil) | 12@@list("AR220" "MX_R0402_SMALL_T01" list(298.000000 2610.000000) nil) | 12@@list("AR221" "MX_R0402_SMALL_T01" list(207.000000 2610.000000) nil) | 12@@list("AR222" "MX_R0402_SMALL_T01" list(389.000000 2610.000000) nil) | 12@@list("AR223" "MX_R0402_SMALL_T01" list(329.500000 2829.000000) nil) | 12@@list("AR224" "MX_R0402_SMALL_T01" list(476.000000 2610.000000) nil) | 12@@list("AR225" "MX_R0402_SMALL_T01" list(350.000000 3530.000000) nil) | 12@@list("AR226" "MX_R0402_SMALL_T01" list(560.000000 3439.000000) nil) | 12@@list("AR227" "MX_R0402_SMALL_T01" list(575.010000 8798.130000) nil) | 12@@list("AR228" "MX_R0402_SMALL_T01" list(575.010000 8838.130000) nil) | 12@@list("AR229" "MX_R0402_SMALL_T01" list(1660.000000 251.000000) nil) | 12@@list("AR23" "MX_R0402_SMALL_T01" list(810.000000 1095.000000) nil) | 12@@list("AR231" "MX_R0402_SMALL_T01" list(1335.000000 445.000000) nil) | 12@@list("AR232" "MX_R0402_SMALL_T01" list(715.000000 3015.000000) nil) | 12@@list("AR237" "MX_R0402_SMALL_T01" list(905.000000 5770.000000) nil) | 12@@list("AR238" "MX_R0402_SMALL_T01" list(896.000000 5912.000000) nil) | 12@@list("AR241" "MX_R0402_SMALL_T01" list(605.000000 6010.000000) nil) | 12@@list("AR242" "MX_R0402_SMALL_T01" list(997.000000 5689.000000) nil) | 12@@list("AR243" "MX_R0402_SMALL_T01" list(770.000000 5686.000000) nil) | 12@@list("AR244" "MX_R0402_SMALL_T01" list(1300.000000 6345.000000) nil) | 12@@list("AR247" "MX_R0402_SMALL_T01" list(916.000000 5990.000000) nil) | 12@@list("AR25" "MX_R0402_SMALL_T01" list(303.000000 505.000000) nil) | 12@@list("AR26" "MX_R0402_SMALL_T01" list(580.000000 330.000000) nil) | 12@@list("AR263" "MX_R0402_SMALL_T01" list(968.000000 430.000000) nil) | 12@@list("AR3" "MX_R0402_SMALL_T01" list(980.010000 805.000000) nil) | 12@@list("AR4" "MX_R0402_SMALL_T01" list(895.000000 835.000000) nil) | 12@@list("AR5" "MX_R0402_SMALL_T01" list(1430.000000 375.000000) nil) | 12@@list("AR50" "MX_R0402_SMALL_T01" list(840.000000 873.000000) nil) | 12@@list("AR53" "MX_R0402_SMALL_T01" list(960.000000 885.000000) nil) | 12@@list("AR55" "MX_R0402_SMALL_T01" list(1125.000000 1052.000000) nil) | 12@@list("AR56" "MX_R0402_SMALL_T01" list(1125.000000 1088.000000) nil) | 12@@list("AR57" "MX_R0603_SMALL_T01" list(1140.000000 1133.000000) nil) | 12@@list("AR6" "MX_R0402_SMALL_T01" list(1265.000000 325.000000) nil) | 12@@list("AR61" "MX_R0402_SMALL_T01" list(630.000000 2390.000000) nil) | 12@@list("AR62" "MX_R0402_SMALL_T01" list(594.000000 2390.000000) nil) | 12@@list("AR63" "MX_R0402_SMALL_T01" list(409.000000 2390.000000) nil) | 12@@list("AR64" "MX_R0402_SMALL_T01" list(445.000000 2390.000000) nil) | 12@@list("AR7" "MX_R0402_SMALL_T01" list(917.000000 337.000000) nil) | 12@@list("AR8" "MX_R0402_SMALL_T01" list(1079.000000 365.000000) nil) | 12@@list("AR9" "MX_R0402_SMALL_T01" list(1115.000000 365.000000) nil) | 12@@list("ASR7" "MX_R0402_SMALL_T01" list(1437.000000 5912.000000) nil) | 12@@list("AU1" "MX_QFP_48P_20_354X354_H63" list(630.000000 613.000000) nil) | 12@@list("C1" "MX_C0402_SMALL_T01" list(8486.000000 1775.000000) nil) | 12@@list("C2" "MX_C0402_SMALL_T01" list(8422.000000 1775.000000) nil) | 12@@list("C414" "MX_C0402_SMALL_T01" list(6654.000000 982.000000) nil) | 12@@list("C415" "MX_C0402_SMALL_T01" list(6698.000000 982.000000) nil) | 12@@list("C416" "MX_C0402_SMALL_T01" list(6632.000000 1175.000000) nil) | 12@@list("C417" "MX_C0402_SMALL_T01" list(6391.000000 1239.000000) nil) | 12@@list("C5" "MX_C0402_SMALL_T01" list(4187.000000 412.000000) nil) | 12@@list("C81" "MX_C0402_SMALL_T01" list(8040.000000 1130.000000) nil) | 12@@list("C82" "MX_C0402_SMALL_T01" list(8720.500000 1704.500000) nil) | 12@@list("C83" "MX_C0402_SMALL_T01" list(8894.000000 1031.500000) nil) | 12@@list("C85" "MX_C0603_SMALL_T01" list(8069.000000 906.000000) nil) | 12@@list("C941402" "MX_C0402_SMALL_T01" list(8787.000000 3908.000000) nil) | 12@@list("CB2" "MX_C0402_SMALL_T01" list(1096.000000 1694.000000) nil) | 12@@list("CB4119" "MX_C0402_SMALL_T01" list(1670.000000 8130.000000) nil) | 12@@list("CB4122" "MX_C0402_SMALL_T01" list(8982.000000 5405.000000) nil) | 12@@list("CB4128" "MX_C0402_SMALL_T01" list(902.000000 5654.000000) nil) | 12@@list("CB4129" "MX_C0402_SMALL_T01" list(829.000000 5995.000000) nil) | 12@@list("CR17" "MX_R0402_SMALL_T01" list(1410.000000 7900.000000) nil) | 12@@list("CR19" "MX_R0402_SMALL_T01" list(1518.000000 7935.000000) nil) | 12@@list("CR2" "MX_LED_2P_63X31_H16" list(3746.000000 329.000000) nil) | 12@@list("CR25" "MX_LED_2P_63X31_H16" list(3931.000000 329.000000) nil) | 12@@list("CR26" "MX_LED_2P_63X31_H16" list(3871.000000 329.000000) nil) | 12@@list("CR27" "MX_LED_2P_63X31_H16" list(3807.000000 329.000000) nil) | 12@@list("CR7" "MX_LED_2P_63X31_H16" list(3989.000000 329.000000) nil) | 12@@list("CR9" "MX_LED_2P_63X31_EVER" list(4051.000000 329.000000) nil) | 12@@list("D20" "MX_SOT323" list(5253.750000 2516.750000) nil) | 12@@list("D4C1" "MX_C0402_SMALL_T01" list(8160.500000 7221.290000) nil) | 12@@list("D4C21" "MX_C0603_SMALL_T01" list(7505.000000 8999.000000) nil) | 12@@list("D4C22" "MX_C0603_SMALL_T01" list(6785.000000 9030.000000) nil) | 12@@list("D4C23" "MX_C0603_SMALL_T01" list(8155.000000 8975.000000) nil) | 12@@list("D4C24" "MX_C0603_SMALL_T01" list(8205.000000 8975.000000) nil) | 12@@list("D4C4" "MX_C0402_SMALL_T01" list(6805.000000 4065.000000) nil) | 12@@list("D4C5" "MX_C0402_SMALL_T01" list(6805.000000 4130.000000) nil) | 12@@list("D4CB1" "MX_C0603_SMALL_T01" list(6830.000000 6480.000000) nil) | 12@@list("D4CB13" "MX_C0603_SMALL_T01" list(8172.000000 6134.000000) nil) | 12@@list("D4CB17" "MX_C0402_SMALL_T01" list(8325.000000 6330.000000) nil) | 12@@list("D4CB18" "MX_C0402_SMALL_T01" list(8170.000000 7095.000000) nil) | 12@@list("D4CB19" "MX_C0402_SMALL_T01" list(6785.000000 7290.000000) nil) | 12@@list("D4CB20" "MX_C0402_SMALL_T01" list(7505.000000 6069.000000) nil) | 12@@list("D4CB21" "MX_C0603_SMALL_T02" list(7510.000000 6150.000000) nil) | 12@@list("D4CB22" "MX_C0603_SMALL_T02" list(7510.000000 6630.000000) nil) | 12@@list("D4CB23" "MX_C0603_SMALL_T02" list(8252.000000 6599.500000) nil) | 12@@list("D4CB24" "MX_C0603_SMALL_T02" list(8199.000000 6614.000000) nil) | 12@@list("D4CB26" "MX_C0603_SMALL_T02" list(6540.000000 7137.000000) nil) | 12@@list("D4CB27" "MX_C0402_SMALL_T01" list(6850.000000 6855.000000) nil) | 12@@list("D4CB28" "MX_C0603_SMALL_T02" list(6611.000000 6317.000000) nil) | 12@@list("D4CB29" "MX_C0603_SMALL_T02" list(7512.000000 6857.000000) nil) | 12@@list("D4CB30" "MX_C0603_SMALL_T02" list(8302.000000 6483.000000) nil) | 12@@list("D4CB31" "MX_C0603_SMALL_T02" list(6665.000000 6317.000000) nil) | 12@@list("D4CB32" "MX_C0603_SMALL_T02" list(8237.500000 6779.000000) nil) | 12@@list("D4CB33" "MX_C0402_SMALL_T01" list(8193.500000 6780.000000) nil) | 12@@list("D4CB34" "MX_C0402_SMALL_T01" list(6253.000000 6842.000000) nil) | 12@@list("D4CB35" "MX_C0402_SMALL_T01" list(8254.000000 6481.000000) nil) | 12@@list("D4CB36" "MX_C0402_SMALL_T01" list(8283.000000 6779.000000) nil) | 12@@list("D4CB37" "MX_C0402_SMALL_T01" list(6489.000000 7081.000000) nil) | 12@@list("D4CB38" "MX_C0603_SMALL_T02" list(8170.000000 6940.000000) nil) | 12@@list("D4CB39" "MX_C0603_SMALL_T02" list(8170.000000 6885.000000) nil) | 12@@list("D4CB40" "MX_C0603_SMALL_T02" list(6430.000000 7025.000000) nil) | 12@@list("D4CB41" "MX_C0603_SMALL_T02" list(8170.000000 6995.000000) nil) | 12@@list("D4CB48" "MX_C0402_SMALL_T01" list(5159.000000 6005.000000) nil) | 12@@list("D4CB49" "MX_C0402_SMALL_T01" list(8157.500000 6780.000000) nil) | 12@@list("D4CB5" "MX_C0603_SMALL_T01" list(8262.000000 6175.000000) nil) | 12@@list("D4CB50" "MX_C0402_SMALL_T01" list(7510.000000 7760.000000) nil) | 12@@list("D4CB51" "MX_C0402_SMALL_T01" list(6710.000000 6332.000000) nil) | 12@@list("D4CB52" "MX_C0402_SMALL_T01" list(7510.000000 8463.000000) nil) | 12@@list("D4CB53" "MX_C0402_SMALL_T01" list(7510.000000 8130.000000) nil) | 12@@list("D4CB54" "MX_C0402_SMALL_T01" list(7510.000000 6710.000000) nil) | 12@@list("D4CB55" "MX_C0402_SMALL_T01" list(7513.000000 7030.000000) nil) | 12@@list("D4CB63" "MX_C0603_SMALL_T02" list(6359.000000 6947.000000) nil) | 12@@list("D4CB66" "MX_C0402_SMALL_T01" list(6850.000000 7145.000000) nil) | 12@@list("D4CB67" "MX_C0402_SMALL_T01" list(6818.000000 6084.000000) nil) | 12@@list("D4CB68" "MX_C0402_SMALL_T01" list(6598.000000 7181.000000) nil) | 12@@list("D4CB71" "MX_C0603_SMALL_T02" list(6305.000000 6893.000000) nil) | 12@@list("D4CB86" "MX_C0402_SMALL_T01" list(8210.000000 9220.000000) nil) | 12@@list("D4CB87" "MX_C0402_SMALL_T01" list(6520.000000 8920.000000) nil) | 12@@list("D4CB88" "MX_C0603_SMALL_T02" list(5146.000000 6144.000000) nil) | 12@@list("D4CB89" "MX_C0603_SMALL_T02" list(5146.000000 6090.000000) nil) | 12@@list("D4CB9" "MX_C0603_SMALL_T01" list(8172.000000 6085.000000) nil) | 12@@list("D4R1" "MX_R0402_SMALL_T01" list(7510.000000 6232.000000) nil) | 12@@list("D4R10" "MX_R0402_SMALL_T01" list(7510.000000 6300.000000) nil) | 12@@list("D4R15" "MX_R0402_SMALL_T01" list(7510.000000 6375.000000) nil) | 12@@list("D4R20" "MX_R0402_SMALL_T01" list(8195.000000 9076.000000) nil) | 12@@list("D4R21" "MX_R0402_SMALL_T01" list(8145.000000 9160.000000) nil) | 12@@list("D4R24" "MX_R0402_SMALL_T01" list(8145.000000 6313.000000) nil) | 12@@list("D4R3" "MX_R0402_SMALL_T01" list(8160.500000 7185.280000) nil) | 12@@list("D4R30" "MX_R0402_SMALL_T01" list(8195.000000 9112.000000) nil) | 12@@list("D4R31" "MX_R0402_SMALL_T01" list(8160.000000 9235.000000) nil) | 12@@list("D4R32" "MX_R0402_SMALL_T01" list(6600.000000 8920.000000) nil) | 12@@list("D4R33" "MX_R0402_SMALL_T01" list(6740.000000 9022.000000) nil) | 12@@list("D4R34" "MX_R0402_SMALL_T01" list(6560.000000 8920.000000) nil) | 12@@list("D4R35" "MX_R0402_SMALL_T01" list(6480.000000 8920.000000) nil) | 12@@list("ECC55" "MX_C0402_SMALL_T01" list(5225.000000 3780.000000) nil) | 12@@list("ECC56" "MX_C0402_SMALL_T01" list(5093.000000 3641.000000) nil) | 12@@list("ECQ12" "MX_SOT23" list(4990.000000 3665.000000) nil) | 12@@list("ECQ13" "MX_SOT23" list(5232.000000 3684.000000) nil) | 12@@list("ECR101" "MX_R0402_SMALL_T01" list(8594.000000 768.000000) nil) | 12@@list("ECR104" "MX_R0402_SMALL_T01" list(8894.000000 995.500000) nil) | 12@@list("ECR105" "MX_R0402_SMALL_T01" list(5129.000000 3641.000000) nil) | 12@@list("ECR67" "MX_R0402_SMALL_T01" list(8068.000000 948.000000) nil) | 12@@list("ECR90" "MX_R0402_SMALL_T01" list(4880.000000 3700.000000) nil) | 12@@list("ECR92" "MX_R0402_SMALL_T01" list(5189.000000 3780.000000) nil) | 12@@list("ECR96" "MX_R0402_SMALL_T01" list(8758.500000 1705.000000) nil) | 12@@list("ECR97" "MX_R0402_SMALL_T01" list(8038.000000 986.000000) nil) | 12@@list("ECR98" "MX_R0402_SMALL_T01" list(8879.500000 1386.000000) nil) | 12@@list("F3CB1" "MX_C0402_SMALL_T01" list(7322.000000 348.240000) nil) | 12@@list("F3CB3" "MX_C0402_SMALL_T01" list(7019.500000 432.000000) nil) | 12@@list("F3R10" "MX_R0402_SMALL_T01" list(7144.000000 365.000000) nil) | 12@@list("F3R12" "MX_R0402_SMALL_T01" list(6880.000000 191.000000) nil) | 12@@list("F3R13" "MX_R0402_SMALL_T01" list(7216.500000 365.000000) nil) | 12@@list("F3R14" "MX_R0402_SMALL_T01" list(7355.000000 915.000000) nil) | 12@@list("F3R20" "MX_R0402_SMALL_T01" list(7317.000000 915.000000) nil) | 12@@list("F3R21" "MX_R0402_SMALL_T01" list(7191.000000 870.000000) nil) | 12@@list("F3R3" "MX_R0402_SMALL_T01" list(6965.000000 341.000000) nil) | 12@@list("F3R4" "MX_R0402_SMALL_T01" list(7374.000000 365.000000) nil) | 12@@list("F3R6" "MX_R0402_SMALL_T01" list(6940.000000 510.000000) nil) | 12@@list("F3R7" "MX_R0402_SMALL_T01" list(7238.000000 870.000000) nil) | 12@@list("F3R8" "MX_R0402_SMALL_T01" list(7393.000000 832.510000) nil) | 12@@list("F3U1" "MX_SOIC_8P_50_213X311" list(7169.310000 587.520000) nil) | 12@@list("F3U2" "MX_SOIC_8P_50_197X236" list(1560.000000 7330.000000) nil) | 12@@list("FC13" "MX_C0805_SMALL_T02" list(733.000000 6047.000000) nil) | 12@@list("FC14" "MX_C0402_SMALL_T01" list(9235.000000 8587.000000) nil) | 12@@list("FC15" "MX_C0402_SMALL_T01" list(5481.000000 9393.000000) nil) | 12@@list("FC16" "MX_C0402_SMALL_T01" list(4519.000000 9365.000000) nil) | 12@@list("FC2" "MX_C0402_SMALL_T01" list(5131.000000 9193.000000) nil) | 12@@list("FC3" "MX_C0402_SMALL_T01" list(5340.000000 9230.000000) nil) | 12@@list("FC5" "MX_C0402_SMALL_T01" list(9217.000000 8887.000000) nil) | 12@@list("FC6" "MX_C0402_SMALL_T01" list(9156.000000 8924.000000) nil) | 12@@list("FC8" "MX_C0402_SMALL_T01" list(7559.800000 1969.500000) nil) | 12@@list("FCE1" "MX_C1206_H75" list(4442.000000 9336.000000) nil) | 12@@list("FCE4" "MX_C1206_H75" list(5651.000000 9359.000000) nil) | 12@@list("FCE5" "MX_C1206_H75" list(9155.000000 8703.000000) nil) | 12@@list("FD1" "MX_SOT323" list(5045.000000 9215.000000) nil) | 12@@list("FD10" "MX_SOT323" list(5970.000000 9213.000000) nil) | 12@@list("FD3" "MX_SOT323" list(4910.000000 9215.000000) nil) | 12@@list("FD7" "MX_SOT323" list(5722.000000 9166.000000) nil) | 12@@list("FD8" "MX_SOT323" list(9139.750000 9006.250000) nil) | 12@@list("FD9" "MX_SOT323" list(9121.750000 8857.750000) nil) | 12@@list("FR1" "MX_R0402_SMALL_T01" list(5380.000000 9230.000000) nil) | 12@@list("FR17" "MX_R0402_SMALL_T01" list(5340.000000 9165.000000) nil) | 12@@list("FR2" "MX_R0805_SMALL_T02" list(5280.000000 9206.000000) nil) | 12@@list("FR28" "MX_R0805_SMALL_T02" list(9223.000000 8977.000000) nil) | 12@@list("FR29" "MX_R0402_SMALL_T01" list(9092.000000 8924.000000) nil) | 12@@list("FR30" "MX_R0402_SMALL_T01" list(9225.000000 9052.000000) nil) | 12@@list("FR31" "MX_R0402_SMALL_T01" list(9072.000000 8990.000000) nil) | 12@@list("FR32" "MX_R0805_SMALL_T02" list(5845.000000 9225.000000) nil) | 12@@list("FR33" "MX_R0402_SMALL_T01" list(5680.000000 9232.000000) nil) | 12@@list("FR35" "MX_R0402_SMALL_T01" list(5640.000000 9182.000000) nil) | 12@@list("FR36" "MX_R0402_SMALL_T01" list(5146.000000 9246.000000) nil) | 12@@list("FR37" "MX_R0402_SMALL_T01" list(3615.500000 499.500000) nil) | 12@@list("FR8" "MX_R0402_SMALL_T01" list(5380.000000 9165.000000) nil) | 12@@list("GFX_Q1" "MX_SOT23" list(2632.000000 2907.000000) nil) | 12@@list("H1" "MX_HOLE_160_T_U_HP" list(1299.980000 9350.000000) nil) | 12@@list("H13" "MX_SMT_NUT_CT276B195D165" list(1443.720000 3542.560000) nil) | 12@@list("H14" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 2888.890000) nil) | 12@@list("H15" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 3676.290000) nil) | 12@@list("H16" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 2180.230000) nil) | 12@@list("H2" "MX_HOLE_160_T_R_HP" list(9350.000000 3150.000000) nil) | 12@@list("H20" "MX_NUT_CT256BD146_H71" list(3763.810000 8731.590000) nil) | 12@@list("H21" "MX_NUT_CT256BD146_H71" list(2359.030000 8301.710000) nil) | 12@@list("H22" "MX_NUT_CT256BD146_H71" list(5858.300000 8731.590000) nil) | 12@@list("H23" "MX_NUT_CT256BD146_H71" list(2359.030000 5199.350000) nil) | 12@@list("H3" "MX_HOLE_160_T_U_HP" list(6500.000000 9350.000000) nil) | 12@@list("H4" "MX_HOLE_160_T_HP" list(6500.000000 3150.000000) nil) | 12@@list("H5" "MX_HOLE_160_T_HP" list(6500.000000 550.000000) nil) | 12@@list("H6" "MX_H_C315D189N_M2_P2_V8" list(9350.000000 9350.000000) nil) | 12@@list("H7" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 1350.000000) nil) | 12@@list("H8" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 3150.000000) nil) | 12@@list("HC11" "MX_C0402_SMALL_T01" list(6986.000000 1121.000000) nil) | 12@@list("HC23" "MX_C0402_SMALL_T01" list(4013.000000 4646.000000) nil) | 12@@list("HC24" "MX_C0402_SMALL_T01" list(3672.000000 8126.500000) nil) | 12@@list("HC25" "MX_C0402_SMALL_T01" list(5220.000000 4446.000000) nil) | 12@@list("HC27" "MX_C0402_SMALL_T01" list(5109.000000 5986.000000) nil) | 12@@list("HC29" "MX_C0402_SMALL_T01" list(8116.000000 2116.000000) nil) | 12@@list("HC3" "MX_C0603_SMALL_T02" list(5164.000000 4589.000000) nil) | 12@@list("HC30" "MX_C0402_SMALL_T01" list(523.000000 2842.000000) nil) | 12@@list("HC31" "MX_C0402_SMALL_T01" list(241.000000 1645.000000) nil) | 12@@list("HC4" "MX_C0402_SMALL_T01" list(5068.000000 4612.120000) nil) | 12@@list("HC5" "MX_C0402_SMALL_T01" list(4005.000000 4795.000000) nil) | 12@@list("HR11" "MX_R0402_SMALL_T01" list(3875.000000 5580.000000) nil) | 12@@list("HR14" "MX_R0402_SMALL_T01" list(3875.500000 5708.000000) nil) | 12@@list("HR15" "MX_R0402_SMALL_T01" list(3875.500000 5672.000000) nil) | 12@@list("HR17" "MX_R0402_SMALL_T01" list(3524.000000 8207.000000) nil) | 12@@list("HR18" "MX_R0402_SMALL_T01" list(3600.000000 8127.000000) nil) | 12@@list("HR20" "MX_R0402_SMALL_T01" list(3564.000000 8127.000000) nil) | 12@@list("HR22" "MX_R0402_T01" list(3999.800000 4891.300000) nil) | 12@@list("HR23" "MX_R0402_SMALL_T01" list(3955.000000 4800.000000) nil) | 12@@list("HR24" "MX_R0402_SMALL_T01" list(3640.000000 8207.000000) nil) | 12@@list("HR25" "MX_R0402_SMALL_T01" list(3958.000000 4714.000000) nil) | 12@@list("HR26" "MX_R0402_SMALL_T01" list(3636.000000 8127.000000) nil) | 12@@list("HR27" "MX_R0402_SMALL_T01" list(4045.000000 4795.000000) nil) | 12@@list("HR28" "MX_R0402_SMALL_T01" list(6027.000000 1713.000000) nil) | 12@@list("HR29" "MX_R0402_SMALL_T01" list(4060.000000 4645.000000) nil) | 12@@list("HR31" "MX_R0402_SMALL_T01" list(4719.000000 6044.000000) nil) | 12@@list("HR32" "MX_R0402_SMALL_T01" list(3604.000000 8207.000000) nil) | 12@@list("HR33" "MX_R0402_SMALL_T01" list(3564.000000 8207.000000) nil) | 12@@list("HR36" "MX_R0402_SMALL_T01" list(3738.500000 4674.000000) nil) | 12@@list("HR4" "MX_R0402_SMALL_T01" list(4719.000000 6007.000000) nil) | 12@@list("HR6" "MX_R0402_SMALL_T01" list(4719.000000 5971.000000) nil) | 12@@list("HR615" "MX_R0402_SMALL_T01" list(3765.000000 4700.000000) nil) | 12@@list("HR616" "MX_R0402_SMALL_T01" list(3792.500000 4748.000000) nil) | 12@@list("HR617" "MX_R0402_SMALL_T01" list(3828.500000 4748.000000) nil) | 12@@list("HR618" "MX_R0402_SMALL_T01" list(3870.000000 4690.000000) nil) | 12@@list("HR619" "MX_R0402_SMALL_T01" list(4058.800000 4557.700000) nil) | 12@@list("HR620" "MX_R0402_SMALL_T01" list(3978.000000 4584.000000) nil) | 12@@list("HR621" "MX_R0402_SMALL_T01" list(3942.000000 4631.000000) nil) | 12@@list("HR622" "MX_R0402_SMALL_T01" list(3906.000000 4653.000000) nil) | 12@@list("HR626" "MX_R0402_SMALL_T01" list(3925.000000 4280.000000) nil) | 12@@list("HR627" "MX_R0402_SMALL_T01" list(7430.000000 1735.000000) nil) | 12@@list("HR629" "MX_R0402_SMALL_T01" list(7404.060000 1836.930000) nil) | 12@@list("HR630" "MX_R0402_SMALL_T01" list(4758.000000 4722.000000) nil) | 12@@list("HR631" "MX_R0402_SMALL_T01" list(5391.000000 8289.000000) nil) | 12@@list("HR78" "MX_R0402_SMALL_T01" list(4082.000000 4795.000000) nil) | 12@@list("HR86" "MX_R0402_SMALL_T01" list(4014.000000 4557.000000) nil) | 12@@list("HR9" "MX_R0402_SMALL_T01" list(3898.000000 5471.000000) nil) | 12@@list("J60" "MX_MINI_PCI_67P_4HD_COLAY" list(1443.730000 4652.000000) nil) | 12@@list("J_TYPEC" "A_USB_CON_2X12P_8HOLD_ACON" list(222.430000 5765.000000) nil) | 12@@list("L1" "MX_L0603_SMALL_T02" list(1595.000000 8285.000000) nil) | 12@@list("L2" "MX_L0603_SMALL_T02" list(1355.000000 8825.000000) nil) | 12@@list("LC10" "MX_C0402_SMALL_T01" list(1421.000000 8293.000000) nil) | 12@@list("LC12" "MX_C0402_SMALL_T01" list(1106.000000 8149.000000) nil) | 12@@list("LC18" "MX_C0402_SMALL_T01" list(1505.000000 8680.000000) nil) | 12@@list("LC4" "MX_C0402_SMALL_T01" list(1253.000000 8765.000000) nil) | 12@@list("LC44" "MX_C0402_SMALL_T01" list(980.000000 8665.000000) nil) | 12@@list("LC47" "MX_C0402_SMALL_T01" list(1585.000000 8470.000000) nil) | 12@@list("LC48" "MX_C0402_SMALL_T01" list(1585.000000 8506.000000) nil) | 12@@list("LC5" "MX_C0402_SMALL_T01" list(1179.000000 8765.000000) nil) | 12@@list("LC6" "MX_C0402_SMALL_T01" list(1223.000000 8140.000000) nil) | 12@@list("LC7" "MX_C0402_SMALL_T01" list(1650.000000 8652.000000) nil) | 12@@list("LC8" "MX_C0402_SMALL_T01" list(1020.000000 8665.000000) nil) | 12@@list("LC9" "MX_C0402_SMALL_T01" list(1457.000000 8293.000000) nil) | 12@@list("LCB11" "MX_C0402_SMALL_T01" list(1185.000000 8685.000000) nil) | 12@@list("LCB13" "MX_C0603_SMALL_T01" list(1595.000000 8353.000000) nil) | 12@@list("LCB15" "MX_C0402_SMALL_T01" list(1187.000000 8543.000000) nil) | 12@@list("LCB16" "MX_C0603_SMALL_T01" list(1585.000000 8795.000000) nil) | 12@@list("LCB18" "MX_C0402_SMALL_T01" list(1574.000000 8640.000000) nil) | 12@@list("LCB19" "MX_C0402_SMALL_T01" list(1602.000000 8395.000000) nil) | 12@@list("LCB2" "MX_C0402_SMALL_T01" list(1574.000000 8750.000000) nil) | 12@@list("LCB22" "MX_C0402_SMALL_T01" list(1612.000000 8565.000000) nil) | 12@@list("LCB3" "MX_C0603_SMALL_T01" list(1585.000000 8845.000000) nil) | 12@@list("LCB5" "MX_C0402_SMALL_T01" list(1574.000000 8713.000000) nil) | 12@@list("LR1" "MX_R0402_SMALL_T01" list(1505.000000 8794.000000) nil) | 12@@list("LR10" "MX_R0402_SMALL_T01" list(1375.000000 8290.000000) nil) | 12@@list("LR2" "MX_R0402_SMALL_T01" list(1407.000000 8794.500000) nil) | 12@@list("LR20" "MX_R0402_SMALL_T01" list(940.000000 8665.000000) nil) | 12@@list("LR22" "MX_R0402_SMALL_T01" list(1183.000000 8728.000000) nil) | 12@@list("LR23" "MX_R0402_SMALL_T01" list(1407.000000 8680.000000) nil) | 12@@list("LR24" "MX_R0402_SMALL_T01" list(1185.000000 8625.000000) nil) | 12@@list("LR3" "MX_R0402_SMALL_T01" list(1070.000000 8665.000000) nil) | 12@@list("LR4" "MX_R0603_SMALL_T01" list(1202.000000 8092.000000) nil) | 12@@list("LR5" "MX_R0603_SMALL_T01" list(1328.000000 8110.000000) nil) | 12@@list("LR6" "MX_R0402_SMALL_T01" list(1465.000000 8680.000000) nil) | 12@@list("LR9" "MX_R0402_SMALL_T01" list(1687.000000 8652.000000) nil) | 12@@list("M1C12" "MX_C0402_SMALL_T01" list(1400.000000 6896.000000) nil) | 12@@list("M1C13" "MX_C0402_SMALL_T01" list(1400.000000 6860.000000) nil) | 12@@list("M1D1" "MX_S0402_AMAZ_COLAY" list(660.000000 6710.000000) nil) | 12@@list("M1F1" "MX_POLYSWITCH_2P_0805_H30" list(693.500000 6923.000000) nil) | 12@@list("M1R11" "MX_R0402_SMALL_T01" list(1140.000000 6850.000000) nil) | 12@@list("M1R12" "MX_R0402_SMALL_T01" list(908.000000 6874.000000) nil) | 12@@list("M1R13" "MX_R0402_SMALL_T01" list(908.000000 6829.000000) nil) | 12@@list("M1R36" "MX_R0402_SMALL_T01" list(770.000000 6726.000000) nil) | 12@@list("M1R37" "MX_R0402_SMALL_T01" list(583.600000 6702.800000) nil) | 12@@list("M1R4" "MX_R0402_SMALL_T01" list(1534.000000 7035.000000) nil) | 12@@list("M1R40" "MX_R0402_SMALL_T01" list(5355.000000 3780.000000) nil) | 12@@list("M1R5" "MX_R0402_SMALL_T01" list(1440.000000 6975.000000) nil) | 12@@list("M1R8" "MX_R0402_SMALL_T01" list(1211.000000 6950.000000) nil) | 12@@list("M1U1" "MX_ESD_10P_20_98X39_NXP" list(621.000000 6459.000000) nil) | 12@@list("M1U2" "MX_ESD_10P_20_98X39_NXP" list(621.000000 6601.000000) nil) | 12@@list("M1U3" "MX_ESD_10P_20_98X39_NXP" list(1111.000000 7727.000000) nil) | 12@@list("M1U4" "MX_ESD_10P_20_98X39_NXP" list(986.180000 7147.240000) nil) | 12@@list("M1U5" "MX_ESD_10P_20_98X39_NXP" list(986.440000 7276.500000) nil) | 12@@list("M1U6" "MX_ESD_10P_20_98X39_NXP" list(442.000000 4688.000000) nil) | 12@@list("M1U7" "MX_ESD_10P_20_98X39_NXP" list(732.000000 4700.000000) nil) | 12@@list("M1U8" "MX_ESD_10P_20_98X39_NXP" list(1012.000000 8507.000000) nil) | 12@@list("M1U9" "MX_ESD_10P_20_98X39_NXP" list(1114.000000 8336.000000) nil) | 12@@list("M2C1" "MX_C0603_SMALL_T02" list(2002.500000 4556.000000) nil) | 12@@list("M2C13" "MX_C0603_SMALL_T02" list(8007.000000 628.000000) nil) | 12@@list("M2C15" "MX_C0402_SMALL_T01" list(8851.920000 784.210000) nil) | 12@@list("M2C16" "MX_C0603_SMALL_T02" list(8007.000000 575.000000) nil) | 12@@list("M2C18" "MX_C0402_SMALL_T01" list(8958.000000 784.000000) nil) | 12@@list("M2C19" "MX_C0603_SMALL_T02" list(8754.000000 778.000000) nil) | 12@@list("M2C21" "MX_C0402_SMALL_T01" list(8014.000000 676.000000) nil) | 12@@list("M2C22" "MX_C0402_SMALL_T01" list(8517.430000 339.530000) nil) | 12@@list("M2C23" "MX_C0402_SMALL_T01" list(8481.430000 339.530000) nil) | 12@@list("M2C24" "MX_C0402_SMALL_T01" list(8598.870000 340.530000) nil) | 12@@list("M2C25" "MX_C0402_SMALL_T01" list(8634.870000 340.530000) nil) | 12@@list("M2C26" "MX_C0402_SMALL_T01" list(8716.020000 340.530000) nil) | 12@@list("M2C27" "MX_C0402_SMALL_T01" list(8752.020000 340.530000) nil) | 12@@list("M2C28" "MX_C0402_SMALL_T01" list(8836.360000 340.530000) nil) | 12@@list("M2C29" "MX_C0402_SMALL_T01" list(8872.360000 340.530000) nil) | 12@@list("M2C3" "MX_C0402_SMALL_T01" list(910.000000 4597.000000) nil) | 12@@list("M2C4" "MX_C0603_SMALL_T02" list(866.000000 4171.000000) nil) | 12@@list("M2C40" "MX_C0402_SMALL_T01" list(1939.000000 4822.000000) nil) | 12@@list("M2C41" "MX_C0402_SMALL_T01" list(1939.000000 4861.000000) nil) | 12@@list("M2C44" "MX_C0402_SMALL_T01" list(8361.000000 325.000000) nil) | 12@@list("M2C46" "MX_C0402_SMALL_T01" list(2008.000000 4637.000000) nil) | 12@@list("M2C47" "MX_C0402_SMALL_T01" list(2008.000000 4683.000000) nil) | 12@@list("M2C48" "MX_C0402_SMALL_T01" list(2097.000000 4671.000000) nil) | 12@@list("M2C49" "MX_C0402_SMALL_T01" list(1958.000000 4598.000000) nil) | 12@@list("M2C50" "MX_C0402_SMALL_T01" list(878.000000 4219.000000) nil) | 12@@list("M2C51" "MX_C0402_SMALL_T01" list(8070.000000 693.000000) nil) | 12@@list("M2C52" "MX_C0402_SMALL_T01" list(8119.000000 551.000000) nil) | 12@@list("M2C53" "MX_C0402_SMALL_T01" list(1939.000000 4765.000000) nil) | 12@@list("M2C54" "MX_C0402_SMALL_T01" list(8252.000000 325.000000) nil) | 12@@list("M2C55" "MX_C0402_SMALL_T01" list(8079.000000 552.000000) nil) | 12@@list("M2C6" "MX_C0402_SMALL_T01" list(946.000000 4598.000000) nil) | 12@@list("M2R1" "MX_R0402_SMALL_T01" list(8180.000000 325.000000) nil) | 12@@list("M2R33" "MX_R0402_SMALL_T01" list(8216.000000 325.000000) nil) | 12@@list("M2R34" "MX_R0402_SMALL_T01" list(8288.000000 325.000000) nil) | 12@@list("M2R36" "MX_R0402_SMALL_T01" list(8325.000000 325.000000) nil) | 12@@list("M2R39" "MX_R0402_SMALL_T01" list(1267.000000 4954.000000) nil) | 12@@list("M2R4" "MX_R0402_SMALL_T01" list(1730.000000 4960.000000) nil) | 12@@list("M2R40" "MX_R0402_SMALL_T01" list(2487.000000 2959.000000) nil) | 12@@list("M2R41" "MX_R0402_SMALL_T01" list(2510.000000 2160.000000) nil) | 12@@list("M2R43" "MX_R0402_SMALL_T01" list(2498.000000 1364.000000) nil) | 12@@list("M2R44" "MX_R0402_SMALL_T01" list(2451.000000 625.000000) nil) | 12@@list("M2R46" "MX_R0402_SMALL_T01" list(1939.000000 4685.000000) nil) | 12@@list("M2R47" "MX_R0402_SMALL_T01" list(1939.000000 4649.000000) nil) | 12@@list("M2R52" "MX_R0402_SMALL_T01" list(907.000000 6065.000000) nil) | 12@@list("M2R54" "MX_R0402_SMALL_T01" list(1695.000000 4960.000000) nil) | 12@@list("MQ10" "MX_SOT363" list(1300.000000 6895.000000) nil) | 12@@list("MQ12" "MX_SOT363" list(1035.000000 6880.000000) nil) | 12@@list("MQ15" "MX_SOT23_H43" list(619.000000 6808.000000) nil) | 12@@list("MQ18" "MX_SOT23_H43" list(1440.000000 8100.000000) nil) | 12@@list("MQ19" "MX_SOT363" list(8978.620000 3176.900000) nil) | 12@@list("MQ20" "MX_SOT363" list(8740.000000 4259.000000) nil) | 12@@list("MQ21" "MX_SOT363" list(5138.100000 4356.620000) nil) | 12@@list("MQ22" "MX_SOT23_H43" list(870.000000 9056.000000) nil) | 12@@list("MQ23" "MX_SOT23_2D4_H43" list(800.000000 9194.000000) nil) | 12@@list("MQ24" "MX_SOT363" list(8240.000000 8490.000000) nil) | 12@@list("MQ25" "MX_SOT363" list(8996.000000 6048.000000) nil) | 12@@list("MQ26" "MX_SOT363" list(8950.000000 7870.000000) nil) | 12@@list("MQ28" "MX_SOT363" list(8110.000000 1905.000000) nil) | 12@@list("MQ29" "MX_SOT363" list(5425.000000 3715.000000) nil) | 12@@list("MQ34" "MX_SOT363" list(8903.000000 4268.000000) nil) | 12@@list("MQ35" "MX_SOT363" list(8304.640000 1999.100000) nil) | 12@@list("MQ36" "MX_SOT363" list(8837.260000 4843.790000) nil) | 12@@list("MQ4" "MX_SOT23_2D4_H44" list(913.000000 6611.000000) nil) | 12@@list("MQ8" "MX_SOT363" list(1540.000000 6960.000000) nil) | 12@@list("MR41" "MX_R0402_SMALL_T01" list(515.000000 6770.000000) nil) | 12@@list("O2C1" "MX_C0402_SMALL_T01" list(8915.000000 1159.000000) nil) | 12@@list("O2C2" "MX_C0402_SMALL_T01" list(2637.000000 2802.000000) nil) | 12@@list("O2C4" "MX_C0402_SMALL_T01" list(8966.000000 2946.000000) nil) | 12@@list("O2C5" "MX_C0402_SMALL_T01" list(8884.000000 1115.000000) nil) | 12@@list("O2CB12" "MX_C0402_SMALL_T01" list(8039.000000 1094.000000) nil) | 12@@list("O2CB15" "MX_C0402_SMALL_T01" list(8910.000000 959.500000) nil) | 12@@list("O2Q6" "MX_SOT363_PHILIPS" list(8645.000000 1815.000000) nil) | 12@@list("O2R1" "MX_R0402_SMALL_T01" list(8743.000000 865.000000) nil) | 12@@list("O2R10" "MX_R0402_SMALL_T01" list(8910.000000 923.000000) nil) | 12@@list("O2R11" "MX_R0402_SMALL_T01" list(8675.000000 1885.000000) nil) | 12@@list("O2R2" "MX_R0402_SMALL_T01" list(8986.000000 1283.000000) nil) | 12@@list("O2R20" "MX_R0402_SMALL_T01" list(8577.000000 1705.000000) nil) | 12@@list("O2R21" "MX_R0402_SMALL_T01" list(8120.000000 1805.000000) nil) | 12@@list("O2R22" "MX_R0402_SMALL_T01" list(9006.000000 1333.000000) nil) | 12@@list("O2R3" "MX_R0402_SMALL_T01" list(8536.000000 1892.000000) nil) | 12@@list("O2R5" "MX_R0402_SMALL_T01" list(8879.500000 1422.000000) nil) | 12@@list("O2R8" "MX_R0402_SMALL_T01" list(8600.000000 1892.000000) nil) | 12@@list("O3R5" "MX_R0402_SMALL_T01" list(2357.000000 418.810000) nil) | 12@@list("OR22" "MX_R0402_SMALL_T01" list(8040.000000 1218.000000) nil) | 12@@list("OR29" "MX_R0402_SMALL_T01" list(7973.000000 989.000000) nil) | 12@@list("OR3" "MX_R0402_SMALL_T01" list(8797.000000 865.000000) nil) | 12@@list("OR34" "MX_R0402_SMALL_T01" list(8040.000000 1058.000000) nil) | 12@@list("OR35" "MX_R0402_SMALL_T01" list(8039.500000 1354.000000) nil) | 12@@list("OR37" "MX_R0402_SMALL_T01" list(8536.000000 1793.500000) nil) | 12@@list("OR44" "MX_R0402_SMALL_T01" list(8038.000000 1022.000000) nil) | 12@@list("OR5" "MX_R0402_SMALL_T01" list(8475.000000 768.000000) nil) | 12@@list("OR51" "MX_R0402_SMALL_T01" list(8181.000000 2116.000000) nil) | 12@@list("OR52" "MX_R0402_SMALL_T01" list(8180.000000 1935.000000) nil) | 12@@list("OR53" "MX_R0402_SMALL_T01" list(8358.000000 1705.000000) nil) | 12@@list("OR56" "MX_R0402_SMALL_T01" list(8686.000000 1704.500000) nil) | 12@@list("OR57" "MX_R0402_SMALL_T01" list(8614.000000 1704.500000) nil) | 12@@list("OR59" "MX_R0402_SMALL_T01" list(8943.000000 1387.000000) nil) | 12@@list("OR6" "TX_R0402" list(8475.000000 804.000000) nil) | 12@@list("OR60" "MX_R0402_SMALL_T01" list(8395.000000 1705.000000) nil) | 12@@list("OR61" "MX_R0402_SMALL_T01" list(8467.000000 1705.000000) nil) | 12@@list("OR65" "MX_R0402_SMALL_T01" list(8180.000000 1870.000000) nil) | 12@@list("OR68" "MX_R0402_SMALL_T01" list(8392.000000 1946.000000) nil) | 12@@list("OR69" "MX_R0402_SMALL_T01" list(8339.000000 1929.000000) nil) | 12@@list("OR70" "MX_R0402_SMALL_T01" list(8059.000000 290.200000) nil) | 12@@list("P118" "MX_FPC_12P_20_2HD_ACES_B" list(7695.000000 250.000000) nil) | 12@@list("P1C2" "MX_C0402_SMALL_T01" list(9255.000000 5835.000000) nil) | 12@@list("P1CB1" "MX_C0402_SMALL_T01" list(9050.000000 7645.000000) nil) | 12@@list("P1CB10" "MX_C0402_SMALL_T01" list(2470.000000 8620.000000) nil) | 12@@list("P1CB11" "MX_C0402_SMALL_T01" list(2470.000000 8660.000000) nil) | 12@@list("P1CB12" "MX_C0402_SMALL_T01" list(9063.000000 6545.000000) nil) | 12@@list("P1CB13" "MX_C1206_H75" list(1963.000000 7933.000000) nil) | 12@@list("P1CB14" "MX_C1206_H75" list(2015.000000 6436.000000) nil) | 12@@list("P1CB15" "MX_C1206_H75" list(2015.000000 6336.000000) nil) | 12@@list("P1CB16" "MX_C1206_H75" list(1966.000000 7192.000000) nil) | 12@@list("P1CB17" "MX_C0402_SMALL_T01" list(2470.000000 8582.000000) nil) | 12@@list("P1CB5" "MX_C0402_SMALL_T01" list(9063.000000 6421.000000) nil) | 12@@list("P1CB8" "MX_C0402_SMALL_T01" list(9042.000000 5918.000000) nil) | 12@@list("P1R1" "MX_R0402_SMALL_T01" list(9065.000000 6625.000000) nil) | 12@@list("P1R2" "MX_R0402_SMALL_T01" list(9255.000000 5755.000000) nil) | 12@@list("P1R3" "MX_R0402_SMALL_T01" list(9254.990000 5795.000000) nil) | 12@@list("P1R4" "MX_R0402_SMALL_T01" list(9065.000000 6690.000000) nil) | 12@@list("PC10" "MX_C0603_SMALL_T02" list(4835.760000 6573.000000) nil) | 12@@list("PC118" "MX_C0805_SMALL_T02" list(8295.000000 5055.000000) nil) | 12@@list("PC121" "MX_C0402_SMALL_T01" list(2058.000000 4870.000000) nil) | 12@@list("PC122" "MX_C0402_SMALL_T01" list(8395.000000 5061.000000) nil) | 12@@list("PC126" "MX_C0402_SMALL_T01" list(8443.000000 4915.000000) nil) | 12@@list("PC131" "MX_C0603_SMALL_T01" list(8426.620000 5241.240000) nil) | 12@@list("PC132" "MX_C0603_SMALL_T01" list(9405.620000 8325.960000) nil) | 12@@list("PC133" "MX_C0402_SMALL_T01" list(5349.000000 4312.000000) nil) | 12@@list("PC137" "MX_C1206_H75" list(2604.000000 5081.000000) nil) | 12@@list("PC138" "MX_C1206_H75" list(2598.000000 5280.000000) nil) | 12@@list("PC142" "MX_C0603_SMALL_T02" list(3112.000000 5339.000000) nil) | 12@@list("PC149" "MX_C0603_SMALL_T02" list(5047.000000 5980.000000) nil) | 12@@list("PC15" "MX_C0603_SMALL_T01" list(4855.000000 3830.000000) nil) | 12@@list("PC150" "MX_C0603_SMALL_T01" list(5275.000000 4000.000000) nil) | 12@@list("PC151" "MX_C0603_SMALL_T01" list(5060.000000 3895.000000) nil) | 12@@list("PC152" "MX_C0402_SMALL_T01" list(5319.000000 3780.000000) nil) | 12@@list("PC153" "MX_C0402_SMALL_T01" list(4925.000000 4060.000000) nil) | 12@@list("PC154" "MX_C0402_SMALL_T01" list(5115.000000 3765.000000) nil) | 12@@list("PC155" "MX_C0402_SMALL_T01" list(5170.000000 3895.000000) nil) | 12@@list("PC156" "MX_C0603_SMALL_T02" list(4835.000000 3970.000000) nil) | 12@@list("PC157" "MX_C0603_SMALL_T02" list(4780.000000 3970.000000) nil) | 12@@list("PC158" "MX_C0402_SMALL_T01" list(5190.000000 3845.000000) nil) | 12@@list("PC159" "MX_C0402_SMALL_T01" list(5185.000000 3950.000000) nil) | 12@@list("PC160" "MX_C0402_SMALL_T01" list(4926.000000 3910.000000) nil) | 12@@list("PC161" "MX_C0603_SMALL_T02" list(4965.000000 4268.000000) nil) | 12@@list("PC162" "MX_C0603_SMALL_T02" list(4965.000000 4320.000000) nil) | 12@@list("PC163" "MX_C0603_SMALL_T02" list(4780.000000 6000.000000) nil) | 12@@list("PC164" "MX_C0603_SMALL_T02" list(4835.000000 6000.000000) nil) | 12@@list("PC193" "MX_C0603_SMALL_T02" list(8269.000000 4423.000000) nil) | 12@@list("PC194" "MX_C0603_SMALL_T02" list(8432.000000 4405.000000) nil) | 12@@list("PC205" "MX_C1206" list(7950.000000 3732.000000) nil) | 12@@list("PC206" "MX_C1206" list(7950.000000 3636.000000) nil) | 12@@list("PC207" "MX_C0805_SMALL_T02" list(7905.000000 3550.000000) nil) | 12@@list("PC208" "MX_C0603_SMALL_T01" list(8681.000000 4392.000000) nil) | 12@@list("PC209" "MX_C0402_SMALL_T01" list(7458.000000 3601.000000) nil) | 12@@list("PC210" "MX_C0603_SMALL_T01" list(7713.000000 3623.000000) nil) | 12@@list("PC211" "MX_C0402_SMALL_T01" list(8127.870000 3516.920000) nil) | 12@@list("PC212" "MX_C0603_SMALL_T01" list(7705.000000 3550.000000) nil) | 12@@list("PC213" "MX_C0603_SMALL_T01" list(7972.000000 2571.000000) nil) | 12@@list("PC214" "MX_C0603" list(8155.000000 3410.000000) nil) | 12@@list("PC215" "MX_C0402_SMALL_T01" list(7970.000000 3250.000000) nil) | 12@@list("PC217" "MX_C0402_SMALL_T01" list(7448.000000 3529.000000) nil) | 12@@list("PC218" "MX_C0603_SMALL_T01" list(7379.000000 3575.000000) nil) | 12@@list("PC232" "MX_C0603_SMALL_T01" list(8975.000000 6520.000000) nil) | 12@@list("PC233" "MX_C0603_SMALL_T01" list(8990.000000 7490.000000) nil) | 12@@list("PC236" "MX_C0603_SMALL_T01" list(8900.000000 7490.000000) nil) | 12@@list("PC239" "MX_C0603_SMALL_T02" list(8855.000000 6520.000000) nil) | 12@@list("PC240" "MX_C0603_SMALL_T02" list(8855.000000 6465.000000) nil) | 12@@list("PC241" "MX_C0402_SMALL_T01" list(9045.000000 7265.000000) nil) | 12@@list("PC242" "MX_C0402_SMALL_T01" list(9220.000000 8010.880000) nil) | 12@@list("PC243" "MX_C0805_SMALL_T02" list(9327.000000 8099.000000) nil) | 12@@list("PC247" "MX_C0402_SMALL_T01" list(8980.000000 6440.000000) nil) | 12@@list("PC272" "MX_C0603_SMALL_T02" list(5112.000000 4589.000000) nil) | 12@@list("PC273" "MX_C0603_SMALL_T02" list(5176.000000 4480.380000) nil) | 12@@list("PC274" "MX_C0603_SMALL_T01" list(4869.000000 4604.000000) nil) | 12@@list("PC329" "MX_C0603_SMALL_T02" list(4908.000000 6035.000000) nil) | 12@@list("PC331" "MX_C0603_SMALL_T02" list(4908.000000 5980.000000) nil) | 12@@list("PC339" "MX_C0402_SMALL_T01" list(8569.500000 5722.000000) nil) | 12@@list("PC341" "MX_C0805_SMALL_T02" list(8570.000000 5359.000000) nil) | 12@@list("PC343" "MX_C0402_SMALL_T01" list(8075.000000 3350.000000) nil) | 12@@list("PC4" "MX_C0603_SMALL_T02" list(4730.000000 6570.000000) nil) | 12@@list("PC481" "MX_C0603_SMALL_T02" list(7512.000000 6457.000000) nil) | 12@@list("PC483" "MX_C0603_SMALL" list(8380.000000 6148.000000) nil) | 12@@list("PC484" "MX_C0402_SMALL_T01" list(8182.000000 5716.000000) nil) | 12@@list("PC485" "MX_C0402_SMALL_T01" list(8234.000000 6105.000000) nil) | 12@@list("PC486" "MX_C0402_SMALL_T01" list(8594.000000 6204.000000) nil) | 12@@list("PC566" "MX_C0402_SMALL_T01" list(4725.000000 2210.000000) nil) | 12@@list("PC567" "MX_C0402_SMALL_T01" list(4536.800000 2089.900000) nil) | 12@@list("PC568" "MX_C0603_SMALL_T01" list(4578.000000 1955.000000) nil) | 12@@list("PC5802" "MX_C0603_SMALL_T01" list(2885.000000 8335.000000) nil) | 12@@list("PC5803" "MX_C0603_SMALL_T01" list(2965.000000 8332.000000) nil) | 12@@list("PC5805" "MX_C0603_SMALL_T01" list(2873.000000 8458.000000) nil) | 12@@list("PC5807" "MX_C0603_SMALL_T01" list(3027.500000 8885.000000) nil) | 12@@list("PC5809" "MX_C0603_SMALL_T01" list(3081.500000 8885.000000) nil) | 12@@list("PC5811" "MX_C0603_SMALL_T01" list(3085.000000 8334.000000) nil) | 12@@list("PC5813" "MX_C0402_SMALL_T01" list(2880.000000 8600.000000) nil) | 12@@list("PC5815" "MX_C0402_SMALL_T01" list(3265.000000 8320.000000) nil) | 12@@list("PC5816" "MX_C0402_SMALL_T01" list(3170.000000 8400.000000) nil) | 12@@list("PC5817" "MX_C0402_SMALL_T01" list(3222.000000 8245.000000) nil) | 12@@list("PC5818" "MX_C0402_SMALL_T01" list(3150.000000 8245.000000) nil) | 12@@list("PC5819" "MX_C0402_SMALL_T01" list(3250.000000 8380.000000) nil) | 12@@list("PC5820" "MX_C0402_SMALL_T01" list(3272.500000 8900.000000) nil) | 12@@list("PC5821" "MX_C0402_SMALL_T01" list(3150.000000 8990.000000) nil) | 12@@list("PC5822" "MX_C0402_SMALL_T01" list(3225.000000 9007.000000) nil) | 12@@list("PC5823" "MX_C0402_SMALL_T01" list(3175.000000 8850.000000) nil) | 12@@list("PC5824" "MX_C0402_SMALL_T01" list(3240.000000 8850.000000) nil) | 12@@list("PC5827" "MX_C0603_SMALL_T01" list(3498.000000 8664.000000) nil) | 12@@list("PC5828" "MX_C0402_SMALL_T01" list(3400.000000 8881.000000) nil) | 12@@list("PC5829" "MX_C0603_SMALL_T01" list(3335.000000 8870.000000) nil) | 12@@list("PC5830" "MX_C0402_SMALL_T01" list(2865.000000 8730.000000) nil) | 12@@list("PC5901" "MX_C0603_SMALL_T01" list(2820.000000 7231.000000) nil) | 12@@list("PC5902" "MX_C0402_SMALL_T01" list(2514.000000 7203.000000) nil) | 12@@list("PC5903" "MX_C0603_SMALL_T01" list(2720.000000 7439.000000) nil) | 12@@list("PC5904" "MX_C0603_SMALL_T02" list(2910.000000 6838.000000) nil) | 12@@list("PC5905" "MX_C0402_SMALL_T01" list(2586.000000 7203.000000) nil) | 12@@list("PC5906" "MX_C0402_SMALL_T01" list(2580.000000 6770.000000) nil) | 12@@list("PC5907" "MX_C0402_SMALL_T01" list(2325.000000 6830.000000) nil) | 12@@list("PC5908" "MX_C0402_SMALL_T01" list(2550.000000 6831.990000) nil) | 12@@list("PC5909" "MX_C0402_SMALL_T01" list(2585.000000 7895.000000) nil) | 12@@list("PC5910" "MX_C0402_SMALL_T01" list(2581.000000 7458.000000) nil) | 12@@list("PC5911" "MX_C0402_SMALL_T01" list(2513.000000 7895.000000) nil) | 12@@list("PC5912" "MX_C0402_SMALL_T01" list(2340.000000 7525.000000) nil) | 12@@list("PC5913" "MX_C0402_SMALL_T01" list(2585.000000 7525.000000) nil) | 12@@list("PC5914" "MX_C0603_SMALL_T02" list(2940.000000 7526.000000) nil) | 12@@list("PC5915" "MX_C0603_SMALL_T01" list(2650.000000 7955.000000) nil) | 12@@list("PC5916" "MX_C0603_SMALL_T01" list(2540.000000 8115.000000) nil) | 12@@list("PC5917" "MX_C1206_H75" list(1966.000000 7349.000000) nil) | 12@@list("PC5918" "MX_C1206_H75" list(1966.000000 7445.000000) nil) | 12@@list("PC5919" "MX_C1206_H75" list(1962.000000 7675.000000) nil) | 12@@list("PC5920" "MX_C1206_H75" list(1962.000000 7771.000000) nil) | 12@@list("PC601" "MX_C0402_SMALL_T01" list(2588.530000 6515.000000) nil) | 12@@list("PC602" "MX_C0402_SMALL_T01" list(2583.000000 6074.000000) nil) | 12@@list("PC603" "MX_C0402_SMALL_T01" list(2516.530000 6515.000000) nil) | 12@@list("PC604" "MX_C0402_SMALL_T01" list(2553.000000 6140.530000) nil) | 12@@list("PC605" "MX_C0402_SMALL_T01" list(2325.000000 6140.000000) nil) | 12@@list("PC606" "MX_C0603_SMALL_T02" list(2908.000000 6145.000000) nil) | 12@@list("PC607" "MX_C0603_SMALL_T01" list(2805.000000 6545.000000) nil) | 12@@list("PC608" "MX_C0603_SMALL_T01" list(2690.000000 6691.000000) nil) | 12@@list("PC609" "MX_C0402_SMALL_T01" list(2587.000000 5814.000000) nil) | 12@@list("PC610" "MX_C0402_SMALL_T01" list(2594.000000 5391.000000) nil) | 12@@list("PC6101" "MX_C0402_SMALL_T01" list(4485.000000 8835.000000) nil) | 12@@list("PC6102" "MX_C0402_SMALL_T01" list(4530.000000 8835.000000) nil) | 12@@list("PC6103" "MX_C0402_SMALL_T01" list(4730.000000 8599.000000) nil) | 12@@list("PC6104" "MX_C0402_SMALL_T01" list(4265.000000 8955.000000) nil) | 12@@list("PC6105" "MX_C0402_SMALL_T01" list(4070.000000 8940.000000) nil) | 12@@list("PC6106" "MX_C0603_SMALL_T02" list(4280.000000 7935.000000) nil) | 12@@list("PC6107" "MX_C0603_SMALL_T01" list(3880.000000 9005.000000) nil) | 12@@list("PC6108" "MX_C0603_SMALL_T01" list(3648.000000 8921.000000) nil) | 12@@list("PC6109" "MX_C0402_SMALL_T01" list(5320.000000 8830.000000) nil) | 12@@list("PC611" "MX_C0402_SMALL_T01" list(2515.000000 5814.000000) nil) | 12@@list("PC6110" "MX_C0402_SMALL_T01" list(5362.000000 8830.000000) nil) | 12@@list("PC6111" "MX_C0402_SMALL_T01" list(5575.000000 8600.000000) nil) | 12@@list("PC6112" "MX_C0402_SMALL_T01" list(4880.000000 8940.000000) nil) | 12@@list("PC6113" "MX_C0402_SMALL_T01" list(5110.000000 8955.000000) nil) | 12@@list("PC6114" "MX_C0603_SMALL_T02" list(4860.000000 7935.000000) nil) | 12@@list("PC6115" "MX_C0603_SMALL_T01" list(5885.000000 8914.000000) nil) | 12@@list("PC6116" "MX_C0603_SMALL_T01" list(5694.000000 9003.000000) nil) | 12@@list("PC6117" "MX_C1206_H75" list(4509.000000 8963.000000) nil) | 12@@list("PC6118" "MX_C1206_H75" list(4691.000000 9210.000000) nil) | 12@@list("PC6119" "MX_C1206_H75" list(5527.000000 9138.000000) nil) | 12@@list("PC612" "MX_C0402_SMALL_T01" list(2325.000000 5444.000000) nil) | 12@@list("PC6120" "MX_C1206_H75" list(5351.000000 8974.000000) nil) | 12@@list("PC613" "MX_C0402_SMALL_T01" list(2546.000000 5444.530000) nil) | 12@@list("PC614" "MX_C0603_SMALL_T02" list(3100.000000 5525.000000) nil) | 12@@list("PC615" "MX_C0603_SMALL_T01" list(2842.000000 5887.000000) nil) | 12@@list("PC616" "MX_C0603_SMALL_T01" list(2710.000000 5996.000000) nil) | 12@@list("PC617" "MX_C1206_H75" list(2015.000000 6048.000000) nil) | 12@@list("PC618" "MX_C1206_H75" list(2015.000000 6144.000000) nil) | 12@@list("PC619" "MX_C1206_H75" list(1993.000000 6714.000000) nil) | 12@@list("PC620" "MX_C1206_H75" list(1993.000000 6617.000000) nil) | 12@@list("PC6201" "MX_C0603_SMALL_T02" list(4945.000000 6375.000000) nil) | 12@@list("PC6202" "MX_C0603_SMALL_T02" list(5000.000000 6375.000000) nil) | 12@@list("PC6203" "MX_C0603_SMALL_T02" list(4945.000000 6265.000000) nil) | 12@@list("PC6204" "MX_C0603_SMALL_T02" list(5000.000000 6265.000000) nil) | 12@@list("PC6205" "MX_C0603_SMALL_T02" list(4945.000000 6500.000000) nil) | 12@@list("PC6206" "MX_C0603_SMALL_T02" list(5110.000000 6500.000000) nil) | 12@@list("PC6207" "MX_C0603_SMALL_T02" list(4730.000000 6625.000000) nil) | 12@@list("PC6208" "MX_C0603_SMALL_T02" list(4780.000000 6265.000000) nil) | 12@@list("PC6209" "MX_C0603_SMALL_T02" list(4835.000000 6500.000000) nil) | 12@@list("PC6210" "MX_C0603_SMALL_T02" list(4890.000000 6265.000000) nil) | 12@@list("PC6211" "MX_C0603_SMALL_T02" list(4725.000000 6265.000000) nil) | 12@@list("PC6212" "MX_C0603_SMALL_T02" list(4725.000000 6375.000000) nil) | 12@@list("PC6213" "MX_C0603_SMALL_T02" list(5165.000000 6375.000000) nil) | 12@@list("PC6214" "MX_C0603_SMALL_T02" list(4835.000000 6170.000000) nil) | 12@@list("PC6215" "MX_C0603_SMALL_T02" list(4780.000000 6170.000000) nil) | 12@@list("PC6216" "MX_C0603_SMALL_T02" list(4890.000000 6375.000000) nil) | 12@@list("PC6217" "MX_C0603_SMALL_T02" list(4725.000000 6170.000000) nil) | 12@@list("PC6218" "MX_C0603_SMALL_T02" list(4890.000000 6500.000000) nil) | 12@@list("PC6219" "MX_C0603_SMALL_T02" list(5055.000000 6500.000000) nil) | 12@@list("PC6220" "MX_C0603_SMALL_T02" list(5000.000000 6500.000000) nil) | 12@@list("PC6221" "MX_C0603_SMALL_T02" list(3915.000000 8435.000000) nil) | 12@@list("PC6222" "MX_C0603_SMALL_T02" list(5087.000000 8244.000000) nil) | 12@@list("PC6223" "MX_C0603_SMALL_T02" list(3975.000000 7935.000000) nil) | 12@@list("PC6224" "MX_C0603_SMALL_T02" list(4860.000000 7880.000000) nil) | 12@@list("PC6225" "MX_C0603_SMALL_T02" list(5044.620000 6735.000000) nil) | 12@@list("PC6226" "MX_C0603_SMALL_T02" list(4939.520000 6680.000000) nil) | 12@@list("PC6227" "MX_C0603_SMALL_T01" list(5044.620000 6680.000000) nil) | 12@@list("PC6228" "MX_C0603_SMALL_T02" list(4939.520000 6625.000000) nil) | 12@@list("PC6229" "MX_C0603_SMALL_T02" list(4939.520000 6735.000000) nil) | 12@@list("PC6230" "MX_C0603_SMALL_T02" list(4834.760000 6625.000000) nil) | 12@@list("PC6231" "MX_C0603_SMALL_T02" list(5044.620000 6625.000000) nil) | 12@@list("PC6232" "MX_C0603_SMALL_T02" list(4834.760000 6735.000000) nil) | 12@@list("PC6233" "MX_C0603_SMALL_T02" list(3975.000000 7880.000000) nil) | 12@@list("PC6234" "MX_C0603_SMALL_T02" list(4280.000000 7880.000000) nil) | 12@@list("PC6235" "MX_C0603_SMALL_T02" list(5149.380000 6680.000000) nil) | 12@@list("PC6236" "MX_C0603_SMALL_T02" list(5149.380000 6735.000000) nil) | 12@@list("PC6237" "MX_C0603_SMALL_T02" list(3810.000000 6290.000000) nil) | 12@@list("PC6238" "MX_C0603_SMALL_T02" list(3810.000000 6500.000000) nil) | 12@@list("PC6239" "MX_C0603_SMALL_T02" list(3810.000000 7055.000000) nil) | 12@@list("PC6240" "MX_C0603_SMALL_T02" list(3810.000000 6865.000000) nil) | 12@@list("PC6241" "MX_C0603_SMALL_T02" list(4575.000000 7935.000000) nil) | 12@@list("PC6242" "MX_C0603_SMALL_T02" list(4575.000000 7880.000000) nil) | 12@@list("PC6243" "MX_C0603_SMALL_T02" list(5149.380000 6624.000000) nil) | 12@@list("PC6244" "MX_C0603_SMALL_T02" list(4834.760000 6680.000000) nil) | 12@@list("PC640625" "MX_C0603_SMALL_T02" list(4730.000000 6680.000000) nil) | 12@@list("PC640626" "MX_C0603_SMALL_T02" list(5110.000000 6265.000000) nil) | 12@@list("PC640627" "MX_C0603_SMALL_T02" list(5110.000000 6375.000000) nil) | 12@@list("PC640628" "MX_C0603_SMALL_T02" list(5165.000000 6265.000000) nil) | 12@@list("PC640629" "MX_C0603_SMALL_T02" list(4780.000000 6375.000000) nil) | 12@@list("PC640630" "MX_C0603_SMALL_T02" list(3810.000000 6690.000000) nil) | 12@@list("PC640632" "MX_C0603_SMALL_T02" list(4908.000000 6145.000000) nil) | 12@@list("PC640633" "MX_C0603_SMALL_T02" list(4908.000000 6090.000000) nil) | 12@@list("PC640634" "MX_C0603_SMALL_T02" list(5050.000000 6145.000000) nil) | 12@@list("PC640635" "MX_C0603_SMALL_T02" list(5050.000000 6090.000000) nil) | 12@@list("PC640636" "MX_C0603_SMALL_T02" list(5047.000000 6035.000000) nil) | 12@@list("PC640637" "MX_C0402_SMALL_T01" list(2615.000000 4705.000000) nil) | 12@@list("PC640639" "MX_C0402_SMALL_T01" list(2995.000000 5406.000000) nil) | 12@@list("PC640641" "MX_C0402_SMALL_T01" list(2775.000000 5108.000000) nil) | 12@@list("PC640644" "MX_C0402_SMALL_T01" list(2615.000000 4770.000000) nil) | 12@@list("PC640645" "MX_C0402_SMALL_T01" list(2707.000000 5329.000000) nil) | 12@@list("PC640646" "MX_C0402_SMALL_T01" list(2885.000000 5350.000000) nil) | 12@@list("PC640647" "MX_C0603_SMALL_T01" list(2885.000000 4780.000000) nil) | 12@@list("PC640648" "MX_C0402_SMALL_T01" list(2625.000000 4940.000000) nil) | 12@@list("PC640649" "MX_C0805_SMALL_T02" list(2768.000000 4904.000000) nil) | 12@@list("PC640651" "MX_C0402_SMALL_T01" list(2995.000000 5442.000000) nil) | 12@@list("PC640653" "MX_C0402_SMALL_T01" list(8350.000000 8820.000000) nil) | 12@@list("PC640656" "MX_C0402_SMALL_T01" list(8295.000000 7621.000000) nil) | 12@@list("PC640658" "MX_C0402_SMALL_T01" list(8649.000000 7808.000000) nil) | 12@@list("PC640660" "MX_C0402_SMALL_T01" list(8237.200000 7799.600000) nil) | 12@@list("PC640661" "MX_C0402_SMALL_T01" list(8409.000000 8835.000000) nil) | 12@@list("PC640662" "MX_C0402_SMALL_T01" list(8638.000000 7384.000000) nil) | 12@@list("PC640663" "MX_C0603_SMALL_T01" list(8395.000000 8511.500000) nil) | 12@@list("PC640664" "MX_C0402_SMALL_T01" list(8555.000000 8815.000000) nil) | 12@@list("PC640665" "MX_C0603_SMALL_T01" list(8515.000000 8575.000000) nil) | 12@@list("PC640667" "MX_C0402_SMALL_T01" list(8294.900000 7397.500000) nil) | 12@@list("PC640671" "MX_C0603_SMALL_T01" list(8490.000000 8840.000000) nil) | 12@@list("PC640672" "MX_C0402_SMALL_T01" list(2591.000000 4844.000000) nil) | 12@@list("PC640674" "MX_C0603_SMALL_T01" list(2470.000000 4935.000000) nil) | 12@@list("PC640675" "MX_C0402_SMALL_T01" list(1555.000000 9090.000000) nil) | 12@@list("PC640676" "MX_C0805_SMALL_T02" list(1415.000000 8985.000000) nil) | 12@@list("PC640679" "MX_C0603_SMALL_T01" list(2116.020000 4948.000000) nil) | 12@@list("PC640682" "MX_C0603_SMALL_T01" list(755.000000 5985.000000) nil) | 12@@list("PC640683" "MX_C0402_SMALL_T01" list(2199.000000 7952.000000) nil) | 12@@list("PC640684" "MX_C0402_SMALL_T01" list(2797.000000 7445.000000) nil) | 12@@list("PC640685" "MX_C0402_SMALL_T01" list(2600.000000 8177.000000) nil) | 12@@list("PC640686" "MX_C0402_SMALL_T01" list(2201.000000 6076.000000) nil) | 12@@list("PC640687" "MX_C0402_SMALL_T01" list(2755.000000 6745.000000) nil) | 12@@list("PC640688" "MX_C0402_SMALL_T01" list(2710.000000 6059.000000) nil) | 12@@list("PC640689" "MX_C0402_SMALL_T01" list(2932.000000 7479.000000) nil) | 12@@list("PC640690" "MX_C0402_SMALL_T01" list(2920.000000 6784.000000) nil) | 12@@list("PC640691" "MX_C0402_SMALL_T01" list(3153.000000 5528.000000) nil) | 12@@list("PC640692" "MX_C0402_SMALL_T01" list(2916.000000 6100.000000) nil) | 12@@list("PC642" "MX_C0402_SMALL_T01" list(1817.000000 9333.000000) nil) | 12@@list("PC6501" "MX_C1206_H75" list(8302.000000 8100.000000) nil) | 12@@list("PC6502" "MX_C1206_H75" list(8302.000000 7999.000000) nil) | 12@@list("PC6521" "MX_C0603_SMALL_T02" list(8369.000000 6328.000000) nil) | 12@@list("PC6522" "MX_C0603_SMALL_T02" list(8382.000000 6089.000000) nil) | 12@@list("PC6523" "MX_C0603_SMALL_T02" list(6735.000000 7235.000000) nil) | 12@@list("PC6524" "MX_C0603_SMALL_T02" list(8328.500000 6778.000000) nil) | 12@@list("PC6525" "MX_C0603_SMALL_T02" list(8170.000000 7050.000000) nil) | 12@@list("PC6526" "MX_C0603_SMALL_T01" list(8994.000000 8132.000000) nil) | 12@@list("PC6527" "MX_C0603_SMALL_T01" list(8625.000000 8950.000000) nil) | 12@@list("PC661" "MX_C0402_SMALL_T01" list(8400.000000 5199.000000) nil) | 12@@list("PC6805" "MX_C0603_SMALL_T01" list(1703.000000 9364.000000) nil) | 12@@list("PC6807" "MX_C0603_SMALL_T01" list(1650.000000 8945.000000) nil) | 12@@list("PC6808" "MX_C0603_SMALL_T01" list(1700.000000 8945.000000) nil) | 12@@list("PC6809" "MX_C0402_SMALL_T01" list(1763.000000 8972.000000) nil) | 12@@list("PC6810" "MX_C0402_SMALL_T01" list(1642.000000 9317.000000) nil) | 12@@list("PC832" "MX_C0603_SMALL_T02" list(8269.000000 4370.000000) nil) | 12@@list("PC834" "MX_C0603_SMALL_T02" list(5165.000000 6500.000000) nil) | 12@@list("PCH" "BGA_885P_909X949_N" list(6725.000000 1995.000000) nil) | 12@@list("PD1" "MX_SMA" list(2010.000000 9245.000000) nil) | 12@@list("PD2" "MX_SMA" list(2010.000000 9380.000000) nil) | 12@@list("PD3" "MX_SMA" list(3553.260000 3828.040000) nil) | 12@@list("PL1" "MX_INDUCTOR_2P_287X260" list(8753.000000 8284.000000) nil) | 12@@list("PL13" "MX_INDUCTOR_2P_287X260" list(7720.000000 3260.000000) nil) | 12@@list("PL631" "MX_INDUCTOR_2P_287X260" list(3028.000000 5131.000000) nil) | 12@@list("PL661" "MX_INDUCTOR_2P_287X260" list(8363.430000 4636.660000) nil) | 12@@list("PQ10" "MX_SOT23_H43" list(8255.000000 8690.000000) nil) | 12@@list("PQ11" "MX_SOT363" list(9060.820000 819.350000) nil) | 12@@list("PQ115" "MX_SOT23" list(8432.000000 5938.000000) nil) | 12@@list("PQ19" "MX_SO_8FL_COLAY_9VI" list(5099.000000 4118.000000) nil) | 12@@list("PQ2" "MX_SOT23_H43" list(2597.000000 8484.000000) nil) | 12@@list("PQ23" "MX_SOT23_H43" list(2075.000000 4789.000000) nil) | 12@@list("PQ28" "MX_SOT1220_NXP" list(2705.000000 5130.000000) nil) | 12@@list("PQ29" "MX_SOT1220_NXP" list(2970.580000 5336.000000) nil) | 12@@list("PQ30" "MX_SOT1220_NXP" list(2803.000000 5339.000000) nil) | 12@@list("PQ31" "MX_SOT23_2D4_H51" list(8945.000000 7600.000000) nil) | 12@@list("PQ33" "MX_TO252_LF3" list(8934.500000 7050.000000) nil) | 12@@list("PQ34" "MX_SO_8FL_COLAY" list(9140.000000 8213.000000) nil) | 12@@list("PQ37" "MX_SOT23_2D4_H43" list(9365.000000 8233.000000) nil) | 12@@list("PQ40" "MX_POWERPAIR_8P_2PAD_VISHAY" list(8035.000000 3480.000000) nil) | 12@@list("PQ46" "MX_SOT323_S5" list(5366.000000 4431.000000) nil) | 12@@list("PQ54" "MX_SOT23_2D4_H43" list(8560.000000 5252.000000) nil) | 12@@list("PQ56" "MX_SO_8FL_COLAY" list(8661.000000 5546.000000) nil) | 12@@list("PQ591" "MX_SO_8FL_COLAY_9VI" list(2373.010000 7323.230000) nil) | 12@@list("PQ592" "MX_SO_8FL_COLAY_9VI" list(2480.000000 7018.230000) nil) | 12@@list("PQ593" "MX_SO_8FL_COLAY_9VI" list(2235.010000 7018.230000) nil) | 12@@list("PQ594" "MX_SO_8FL_COLAY_9VI" list(2373.010000 8019.230000) nil) | 12@@list("PQ595" "MX_SO_8FL_COLAY_9VI" list(2480.000000 7713.230000) nil) | 12@@list("PQ596" "MX_SO_8FL_COLAY_9VI" list(2235.010000 7713.230000) nil) | 12@@list("PQ60" "MX_SOT23_2D4_H44" list(5009.000000 4495.000000) nil) | 12@@list("PQ601" "MX_SO_8FL_COLAY_9VI" list(2375.530000 6638.230000) nil) | 12@@list("PQ602" "MX_SO_8FL_COLAY_9VI" list(2234.530000 6329.230000) nil) | 12@@list("PQ603" "MX_SO_8FL_COLAY_9VI" list(2482.000000 6329.430000) nil) | 12@@list("PQ604" "MX_SO_8FL_COLAY_9VI" list(2375.530000 5935.230000) nil) | 12@@list("PQ605" "MX_SO_8FL_COLAY_9VI" list(2234.530000 5630.230000) nil) | 12@@list("PQ606" "MX_SO_8FL_COLAY_9VI" list(2482.000000 5630.450000) nil) | 12@@list("PQ611" "MX_SO_8FL_COLAY_9VI" list(4679.000000 8772.230000) nil) | 12@@list("PQ612" "MX_SO_8FL_COLAY_9VI" list(4094.990000 8767.770000) nil) | 12@@list("PQ613" "MX_SO_8FL_COLAY_9VI" list(4338.990000 8767.770000) nil) | 12@@list("PQ614" "MX_SO_8FL_COLAY_9VI" list(5525.010000 8772.230000) nil) | 12@@list("PQ615" "MX_SO_8FL_COLAY_9VI" list(5180.000000 8767.770000) nil) | 12@@list("PQ616" "MX_SO_8FL_COLAY_9VI" list(4930.000000 8767.770000) nil) | 12@@list("PQ651" "MX_SO_8FL_COLAY_9VI" list(8530.010000 7984.230000) nil) | 12@@list("PQ652" "MX_SO_8FL_COLAY_9VI" list(8467.230000 7705.990000) nil) | 12@@list("PQ653" "MX_SO_8FL_COLAY_9VI" list(8467.230000 7456.000000) nil) | 12@@list("PQ691" "MX_SOT23_2D4_H43" list(8975.000000 6335.000000) nil) | 12@@list("PQ80" "MX_SOT23_H43_COLAY" list(8579.000000 6085.000000) nil) | 12@@list("PQ9777" "MX_SOT23_H43" list(8125.000000 2035.000000) nil) | 12@@list("PQ9779" "MX_SOT23_H61" list(8034.000000 1736.000000) nil) | 12@@list("PQ9784" "MX_SOT23_2D4_H55" list(1535.000000 8975.000000) nil) | 12@@list("PQ9786" "MX_SOT23_2D4_H43" list(2070.000000 5056.000000) nil) | 12@@list("PQ9787" "MX_SOT23_H43" list(5456.900000 516.400000) nil) | 12@@list("PR11" "MX_R0402_SMALL_T01" list(8505.000000 8965.000000) nil) | 12@@list("PR115" "MX_R0402_SMALL_T01" list(5400.000000 3630.000000) nil) | 12@@list("PR12" "MX_R0402_SMALL_T01" list(8560.000000 8980.000000) nil) | 12@@list("PR121" "MX_R0402_SMALL_T01" list(9432.000000 8498.000000) nil) | 12@@list("PR122" "MX_R0402_SMALL_T01" list(9095.000000 8440.000000) nil) | 12@@list("PR123" "MX_R0603_SMALL_T01" list(8257.000000 5716.000000) nil) | 12@@list("PR124" "MX_R0402_SMALL_T01" list(4880.000000 3770.000000) nil) | 12@@list("PR125" "MX_R0402_SMALL_T01" list(8306.000000 6105.000000) nil) | 12@@list("PR126" "MX_R0402_SMALL_T01" list(8270.000000 6105.000000) nil) | 12@@list("PR127" "MX_R0805_SMALL_T02" list(5074.000000 3954.000000) nil) | 12@@list("PR128" "MX_R0402_SMALL_T01" list(5154.000000 3845.000000) nil) | 12@@list("PR129" "MX_R0402_SMALL_T01" list(5149.000000 3950.000000) nil) | 12@@list("PR130" "MX_R0402_SMALL_T01" list(4889.000000 3975.000000) nil) | 12@@list("PR131" "MX_R1206" list(4700.000000 3945.000000) nil) | 12@@list("PR132" "MX_R0402_SMALL_T01" list(4890.000000 3910.000000) nil) | 12@@list("PR133" "MX_R0402_SMALL_T01" list(4962.000000 3910.000000) nil) | 12@@list("PR134" "MX_R0402_SMALL_T01" list(8465.000000 5676.000000) nil) | 12@@list("PR135" "MX_R0402_SMALL_T01" list(8481.000000 5366.000000) nil) | 12@@list("PR136" "MX_R0402_SMALL_T01" list(1493.500000 9065.190000) nil) | 12@@list("PR137" "MX_R0402_SMALL_T01" list(8429.000000 5299.500000) nil) | 12@@list("PR138" "MX_R0402_SMALL_T01" list(9263.380000 8012.500000) nil) | 12@@list("PR139" "MX_R0402_SMALL_T01" list(8586.000000 5774.000000) nil) | 12@@list("PR14" "MX_R0402_SMALL_T01" list(8218.000000 4165.000000) nil) | 12@@list("PR161" "MX_R0805_SMALL_T02" list(7668.000000 3702.000000) nil) | 12@@list("PR162" "MX_R0402_SMALL_T01" list(7458.000000 3637.000000) nil) | 12@@list("PR163" "MX_R0805_SMALL_T02" list(8145.000000 3605.000000) nil) | 12@@list("PR164" "MX_R0402_SMALL_T01" list(8165.870000 3516.920000) nil) | 12@@list("PR165" "MX_R0805_SMALL_T02" list(7740.000000 3490.000000) nil) | 12@@list("PR166" "MX_R1206" list(7910.000000 3360.000000) nil) | 12@@list("PR167" "MX_R0402_SMALL_T01" list(7384.000000 3675.000000) nil) | 12@@list("PR168" "MX_R0402_SMALL_T01" list(7573.000000 3506.000000) nil) | 12@@list("PR170" "MX_R0402_SMALL_T01" list(7351.000000 3637.000000) nil) | 12@@list("PR171" "MX_R0402_SMALL_T01" list(8075.000000 3387.000000) nil) | 12@@list("PR172" "MX_R0402_SMALL_T01" list(7448.000000 3565.000000) nil) | 12@@list("PR173" "MX_R0402_SMALL_T01" list(7441.000000 3493.000000) nil) | 12@@list("PR174" "MX_R0402_SMALL_T01" list(7458.000000 3673.000000) nil) | 12@@list("PR175" "MX_R0402_SMALL_T01" list(7509.000000 3493.000000) nil) | 12@@list("PR187" "MX_R0402_SMALL_T01" list(8980.000000 6476.000000) nil) | 12@@list("PR188" "MX_R0402_SMALL_T01" list(9018.000000 7446.000000) nil) | 12@@list("PR189" "MX_R0402_SMALL_T01" list(9030.000000 7410.000000) nil) | 12@@list("PR191" "MX_R0402_SMALL_T01" list(8965.000000 7410.000000) nil) | 12@@list("PR192" "MX_R0402_SMALL_T01" list(8940.000000 7265.000000) nil) | 12@@list("PR193" "MX_R0402_SMALL_T01" list(8990.000000 7285.000000) nil) | 12@@list("PR195" "MX_R0402_SMALL_T01" list(9432.000000 8433.000000) nil) | 12@@list("PR198" "MX_R0402_SMALL_T01" list(9402.000000 8368.000000) nil) | 12@@list("PR199" "MX_R0402_SMALL_T01" list(9029.000000 8440.000000) nil) | 12@@list("PR2" "MX_R0805_SMALL_T02" list(2597.000000 8644.000000) nil) | 12@@list("PR234" "MX_R0402_SMALL_T01" list(2179.000000 4881.000000) nil) | 12@@list("PR235" "MX_R0402_SMALL_T01" list(2122.000000 4870.000000) nil) | 12@@list("PR236" "MX_R0402_SMALL_T01" list(2178.000000 4725.000000) nil) | 12@@list("PR244" "MX_R0402_SMALL_T01" list(5022.000000 4612.500000) nil) | 12@@list("PR245" "MX_R0402_SMALL_T01" list(4971.900000 4597.000000) nil) | 12@@list("PR248" "MX_R0402_SMALL_T01" list(5445.000000 4385.000000) nil) | 12@@list("PR249" "MX_R0402_SMALL_T01" list(5313.000000 4312.000000) nil) | 12@@list("PR3" "MX_R0805_SMALL_T02" list(4704.000000 4480.000000) nil) | 12@@list("PR302" "MX_R0402_SMALL_T01" list(8443.000000 5570.000000) nil) | 12@@list("PR305" "MX_R0402_SMALL_T01" list(8481.000000 5402.000000) nil) | 12@@list("PR312" "MX_R0402_SMALL_T01" list(4998.000000 3910.000000) nil) | 12@@list("PR313" "MX_R0402_SMALL_T01" list(4925.000000 3975.000000) nil) | 12@@list("PR317" "MX_R0402_SMALL_T01" list(2513.000000 4940.000000) nil) | 12@@list("PR340" "MX_R0805_SMALL_T02" list(5115.620000 4488.000000) nil) | 12@@list("PR341" "MX_R0805_SMALL_T02" list(1958.000000 5012.000000) nil) | 12@@list("PR381" "MX_R0402_SMALL_T01" list(8491.000000 6058.000000) nil) | 12@@list("PR4" "MX_R0805_SMALL_T02" list(5240.000000 4357.000000) nil) | 12@@list("PR432" "MX_R0402_SMALL_T01" list(8632.000000 6204.000000) nil) | 12@@list("PR5" "MX_R0402_SMALL_T01" list(9050.000000 7790.000000) nil) | 12@@list("PR511" "MX_R0402_SMALL_T01" list(8959.500000 5896.000000) nil) | 12@@list("PR512" "MX_R0402_SMALL_T01" list(8230.000000 8793.000000) nil) | 12@@list("PR5801" "MX_R0402_SMALL_T01" list(2905.000000 8240.000000) nil) | 12@@list("PR5802" "MX_R0402_SMALL_T01" list(2975.000000 8270.000000) nil) | 12@@list("PR5803" "MX_R0402_SMALL_T01" list(3007.000000 8325.000000) nil) | 12@@list("PR5804" "MX_R0402_SMALL_T01" list(2805.000000 8455.000000) nil) | 12@@list("PR5805" "MX_R0402_SMALL_T01" list(2876.000000 8416.000000) nil) | 12@@list("PR5806" "MX_R0402_SMALL_T01" list(3114.000000 8210.000000) nil) | 12@@list("PR5807" "MX_R0402_SMALL_T01" list(2980.500000 8870.000000) nil) | 12@@list("PR5808" "MX_R0402_SMALL_T01" list(3079.000000 8954.000000) nil) | 12@@list("PR5809" "MX_R0402_SMALL_T01" list(3111.000000 8071.000000) nil) | 12@@list("PR5810" "MX_R0402_SMALL_T01" list(2885.000000 8290.000000) nil) | 12@@list("PR5811" "MX_R0402_SMALL_T01" list(2885.000000 8380.000000) nil) | 12@@list("PR5812" "MX_R0402_SMALL_T01" list(2880.000000 8690.000000) nil) | 12@@list("PR5813" "MX_R0402_SMALL_T01" list(2989.000000 8954.000000) nil) | 12@@list("PR5814" "MX_R0402_SMALL_T01" list(3060.000000 8267.000000) nil) | 12@@list("PR5815" "MX_R0402_SMALL_T01" list(3043.000000 8325.000000) nil) | 12@@list("PR5816" "MX_R0402_SMALL_T01" list(2795.000000 8630.000000) nil) | 12@@list("PR5817" "MX_R0402_SMALL_T01" list(3485.000000 8863.000000) nil) | 12@@list("PR5818" "MX_R0402_SMALL_T01" list(3485.000000 8827.000000) nil) | 12@@list("PR5819" "MX_R0402_SMALL_T01" list(3400.040000 8803.910000) nil) | 12@@list("PR5820" "MX_R0402_SMALL_T01" list(3400.000000 8845.000000) nil) | 12@@list("PR5821" "MX_R0402_SMALL_T01" list(3485.000000 8791.000000) nil) | 12@@list("PR5822" "MX_R0402_SMALL_T01" list(3400.000000 8731.000000) nil) | 12@@list("PR5823" "MX_R0402_SMALL_T01" list(3485.000000 8755.000000) nil) | 12@@list("PR5824" "MX_R0402_SMALL_T01" list(3308.000000 8259.000000) nil) | 12@@list("PR5825" "MX_R0402_SMALL_T01" list(3424.000000 8352.000000) nil) | 12@@list("PR5826" "MX_R0402_SMALL_T01" list(3426.000000 8267.000000) nil) | 12@@list("PR5827" "MX_R0402_SMALL_T01" list(3388.000000 8352.000000) nil) | 12@@list("PR5828" "MX_R0402_SMALL_T01" list(3487.000000 8402.000000) nil) | 12@@list("PR5829" "MX_R0402_SMALL_T01" list(3400.000000 8402.000000) nil) | 12@@list("PR5830" "MX_R0402_SMALL_T01" list(3487.000000 8438.000000) nil) | 12@@list("PR5831" "MX_R0402_SMALL_T01" list(3400.000000 8438.000000) nil) | 12@@list("PR5832" "MX_R0402_SMALL_T01" list(3487.000000 8474.000000) nil) | 12@@list("PR5833" "MX_R0402_SMALL_T01" list(3400.000000 8474.000000) nil) | 12@@list("PR5834" "MX_R0402_SMALL_T01" list(3487.000000 8582.000000) nil) | 12@@list("PR5835" "MX_R0402_SMALL_T01" list(3400.000000 8582.000000) nil) | 12@@list("PR5836" "MX_R0402_SMALL_T01" list(3345.000000 8259.000000) nil) | 12@@list("PR5837" "MX_R0402_SMALL_T01" list(3390.000000 8267.000000) nil) | 12@@list("PR5838" "MX_R0402_SMALL_T01" list(3400.000000 8546.000000) nil) | 12@@list("PR5839" "MX_R0402_SMALL_T01" list(3487.000000 8546.000000) nil) | 12@@list("PR5840" "MX_R0402_SMALL_T01" list(3487.000000 8510.000000) nil) | 12@@list("PR5841" "MX_R0402_SMALL_T01" list(3400.000000 8510.000000) nil) | 12@@list("PR5842" "MX_R0402_SMALL_T01" list(3345.000000 8355.000000) nil) | 12@@list("PR5843" "MX_R0402_SMALL_T01" list(3303.000000 8355.000000) nil) | 12@@list("PR5844" "MX_R0402_SMALL_T01" list(3229.000000 8320.000000) nil) | 12@@list("PR5845" "MX_R0402_SMALL_T01" list(3186.000000 8245.000000) nil) | 12@@list("PR5846" "MX_R0402_SMALL_T01" list(3150.000000 8330.000000) nil) | 12@@list("PR5847" "MX_R0402_SMALL_T01" list(3188.000000 8331.000000) nil) | 12@@list("PR5848" "MX_R0402_SMALL_T01" list(3236.500000 8900.000000) nil) | 12@@list("PR5849" "MX_R0402_SMALL_T01" list(3160.000000 8910.000000) nil) | 12@@list("PR5850" "MX_R0402_SMALL_T01" list(3187.000000 8990.000000) nil) | 12@@list("PR5851" "MX_R0402_SMALL_T01" list(3196.000000 8910.000000) nil) | 12@@list("PR5852" "MX_R0402_SMALL_T01" list(2795.000000 8590.000000) nil) | 12@@list("PR5853" "MX_R0402_SMALL_T01" list(2880.000000 8556.000000) nil) | 12@@list("PR5854" "MX_R0402_SMALL_T01" list(2829.000000 8940.000000) nil) | 12@@list("PR5855" "MX_R0402_SMALL_T01" list(2902.000000 8871.000000) nil) | 12@@list("PR5856" "MX_R0402_SMALL_T01" list(3345.000000 8938.000000) nil) | 12@@list("PR5857" "MX_R0402_SMALL_T01" list(3400.000000 8655.000000) nil) | 12@@list("PR5858" "MX_R0402_SMALL_T01" list(3400.040000 8766.910000) nil) | 12@@list("PR5859" "MX_R0402_SMALL_T01" list(2768.000000 8762.000000) nil) | 12@@list("PR5860" "MX_R0402_SMALL_T01" list(2743.000000 8801.000000) nil) | 12@@list("PR5862" "MX_R0402_SMALL_T01" list(3566.000000 8563.000000) nil) | 12@@list("PR5863" "MX_R0402_SMALL_T01" list(3602.000000 8563.000000) nil) | 12@@list("PR5864" "MX_R0402_SMALL_T01" list(3562.000000 8685.000000) nil) | 12@@list("PR5865" "MX_R0402_SMALL_T01" list(3598.000000 8685.000000) nil) | 12@@list("PR5866" "MX_R0402_SMALL_T01" list(3400.000000 8695.000000) nil) | 12@@list("PR5867" "MX_R0402" list(3400.000000 8618.000000) nil) | 12@@list("PR5868" "MX_R0402_SMALL_T01" list(3490.000000 8620.000000) nil) | 12@@list("PR5869" "MX_R0402_SMALL_T01" list(3485.000000 8718.000000) nil) | 12@@list("PR5870" "MX_R0402_SMALL_T01" list(2865.000000 8766.000000) nil) | 12@@list("PR5871" "MX_R0402_SMALL_T01" list(2881.000000 8512.000000) nil) | 12@@list("PR5872" "MX_R0402_SMALL_T01" list(2931.000000 8957.000000) nil) | 12@@list("PR5873" "MX_R0402_SMALL_T01" list(2944.000000 8870.000000) nil) | 12@@list("PR5874" "MX_R0402_SMALL_T01" list(2793.000000 8513.000000) nil) | 12@@list("PR5875" "MX_R0402_SMALL_T01" list(2820.000000 8850.000000) nil) | 12@@list("PR5876" "MX_R0805_SMALL_T02" list(3166.000000 8072.000000) nil) | 12@@list("PR5877" "MX_R0402_SMALL_T01" list(3124.000000 8873.000000) nil) | 12@@list("PR5878" "MX_R0402_SMALL_T01" list(3075.000000 8396.000000) nil) | 12@@list("PR5879" "MX_R0402_SMALL_T01" list(2880.000000 8640.000000) nil) | 12@@list("PR5880" "MX_R0402_SMALL_T01" list(2950.000000 8215.000000) nil) | 12@@list("PR5881" "MX_R0402_SMALL_T01" list(2769.000000 8455.000000) nil) | 12@@list("PR5882" "MX_R0402_SMALL_T01" list(3078.000000 8210.000000) nil) | 12@@list("PR5883" "MX_R0402_SMALL_T01" list(3024.000000 9005.000000) nil) | 12@@list("PR5884" "MX_R0402_SMALL_T01" list(3060.000000 9005.000000) nil) | 12@@list("PR5901" "MX_R1206_H26" list(2895.000000 7365.000000) nil) | 12@@list("PR5902" "MX_R0603_SMALL_T01" list(2682.000000 7370.000000) nil) | 12@@list("PR5903" "MX_R0805_SMALL_T02" list(2535.990000 7293.000000) nil) | 12@@list("PR5904" "MX_R0402_SMALL_T01" list(2550.000000 7203.000000) nil) | 12@@list("PR5905" "MX_R1206" list(2700.000000 6817.000000) nil) | 12@@list("PR5906" "MX_R0402_SMALL_T01" list(2586.000000 6831.990000) nil) | 12@@list("PR5908" "MX_R0402_SMALL_T01" list(2549.000000 7895.000000) nil) | 12@@list("PR5909" "MX_R0603_SMALL_T01" list(2553.000000 8221.000000) nil) | 12@@list("PR5910" "MX_R0805_SMALL_T02" list(2532.000000 7984.000000) nil) | 12@@list("PR5911" "MX_R1206_H26" list(2740.000000 8035.000000) nil) | 12@@list("PR5912" "MX_R0402_SMALL_T01" list(2549.000000 7525.000000) nil) | 12@@list("PR5913" "MX_R1206" list(2700.000000 7510.000000) nil) | 12@@list("PR6" "MX_R0805_SMALL_T02" list(9075.000000 7989.000000) nil) | 12@@list("PR601" "MX_R0402_SMALL_T01" list(2552.530000 6515.000000) nil) | 12@@list("PR602" "MX_R0603_SMALL_T01" list(2617.000000 6713.000000) nil) | 12@@list("PR603" "MX_R0805_SMALL_T02" list(2595.000000 6596.470000) nil) | 12@@list("PR604" "MX_R1206_H26" list(2880.000000 6665.000000) nil) | 12@@list("PR605" "MX_R0402_SMALL_T01" list(2589.000000 6140.530000) nil) | 12@@list("PR606" "MX_R1206" list(2703.000000 6125.000000) nil) | 12@@list("PR608" "MX_R0402_SMALL_T01" list(2551.000000 5814.000000) nil) | 12@@list("PR609" "MX_R0603_SMALL_T01" list(2603.000000 6007.000000) nil) | 12@@list("PR610" "MX_R0805_SMALL_T02" list(2595.000000 5910.000000) nil) | 12@@list("PR6101" "MX_R0402_SMALL_T01" list(4730.000000 8563.000000) nil) | 12@@list("PR6102" "MX_R0603_SMALL_T01" list(3604.000000 9037.000000) nil) | 12@@list("PR6103" "MX_R0805_SMALL_T02" list(4720.000000 8460.000000) nil) | 12@@list("PR6104" "MX_R1206_H26" list(3760.000000 9065.000000) nil) | 12@@list("PR6105" "MX_R0402_SMALL_T01" list(4070.000000 8976.000000) nil) | 12@@list("PR6106" "MX_R1206" list(4510.000000 8679.000000) nil) | 12@@list("PR6108" "MX_R0402_SMALL_T01" list(5575.000000 8564.000000) nil) | 12@@list("PR6109" "MX_R0603_SMALL_T01" list(5694.000000 8954.000000) nil) | 12@@list("PR611" "MX_R1206_H26" list(2931.000000 5981.000000) nil) | 12@@list("PR6110" "MX_R0805_SMALL_T02" list(5544.000000 8458.000000) nil) | 12@@list("PR6111" "MX_R1206_H26" list(5984.000000 9029.000000) nil) | 12@@list("PR6112" "MX_R0402_SMALL_T01" list(4880.000000 8976.000000) nil) | 12@@list("PR6113" "MX_R1206" list(5354.000000 8679.000000) nil) | 12@@list("PR612" "MX_R0402_SMALL_T01" list(2582.000000 5444.530000) nil) | 12@@list("PR613" "MX_R1206" list(2700.000000 5473.000000) nil) | 12@@list("PR621" "MX_R0402_SMALL_T01" list(3227.000000 8169.000000) nil) | 12@@list("PR622" "MX_R0402_SMALL_T01" list(3294.000000 8170.000000) nil) | 12@@list("PR623" "MX_R0402_SMALL_T01" list(3261.000000 9002.000000) nil) | 12@@list("PR624" "MX_R0402_SMALL_T01" list(3345.000000 8975.000000) nil) | 12@@list("PR641" "MX_R0805_SMALL_T02" list(914.000000 6716.000000) nil) | 12@@list("PR6506" "MX_R0402_SMALL_T01" list(8445.000000 8835.000000) nil) | 12@@list("PR6601" "MX_R0603_SMALL_T01" list(4670.000000 1955.000000) nil) | 12@@list("PR6602" "MX_R0402_SMALL_T01" list(4689.000000 2210.000000) nil) | 12@@list("PR6603" "MX_R0402_SMALL_T01" list(4735.300000 2011.800000) nil) | 12@@list("PR6605" "MX_R0402_SMALL_T01" list(4734.600000 2078.700000) nil) | 12@@list("PR6607" "MX_R0402_SMALL_T01" list(8443.000000 4879.000000) nil) | 12@@list("PR6608" "MX_R0402_SMALL_T01" list(8395.000000 5098.000000) nil) | 12@@list("PR6609" "MX_R0402_SMALL_T01" list(8385.000000 5149.000000) nil) | 12@@list("PR6610" "MX_R0402_SMALL_T01" list(8429.000000 4968.000000) nil) | 12@@list("PR6611" "MX_R0402_SMALL_T01" list(8425.000000 5148.990000) nil) | 12@@list("PR6806" "MX_R0402_SMALL_T01" list(1769.000000 8898.000000) nil) | 12@@list("PR6807" "MX_R0402_SMALL_T01" list(1768.990000 8934.000000) nil) | 12@@list("PR6809" "MX_R0402_SMALL_T01" list(1829.000000 8972.000000) nil) | 12@@list("PR6810" "MX_R0603_SMALL_T01" list(1655.000000 9380.000000) nil) | 12@@list("PR7" "MX_R0805_SMALL_T02" list(9020.000000 6180.000000) nil) | 12@@list("PR70176" "MX_R0402_SMALL_T01" list(2510.000000 4785.000000) nil) | 12@@list("PR70188" "MX_R0402_SMALL_T01" list(2440.000000 4715.000000) nil) | 12@@list("PR70189" "MX_R0402_SMALL_T01" list(2468.000000 4859.000000) nil) | 12@@list("PR70190" "MX_R0402_SMALL_T01" list(2860.000000 4840.000000) nil) | 12@@list("PR70193" "MX_R0805_SMALL_T02" list(2792.000000 5019.000000) nil) | 12@@list("PR70194" "MX_R0402_SMALL_T01" list(2535.000000 4730.000000) nil) | 12@@list("PR70195" "MX_R0603_SMALL_T01" list(3445.000000 5705.000000) nil) | 12@@list("PR70196" "MX_R0402_SMALL_T01" list(2440.000000 4655.000000) nil) | 12@@list("PR70198" "MX_R0805_SMALL_T02" list(2860.000000 4690.000000) nil) | 12@@list("PR70199" "MX_R1206" list(2743.010000 5236.000000) nil) | 12@@list("PR70201" "MX_R0402_SMALL_T01" list(2440.000000 4755.000000) nil) | 12@@list("PR70202" "MX_R0603_SMALL_T01" list(2889.000000 4899.000000) nil) | 12@@list("PR70203" "MX_R0805_SMALL_T02" list(2935.000000 4840.000000) nil) | 12@@list("PR70204" "MX_R0402_SMALL_T01" list(2811.000000 5108.000000) nil) | 12@@list("PR70205" "MX_R0402_SMALL_T01" list(2585.000000 4940.000000) nil) | 12@@list("PR70206" "MX_R0402_SMALL_T01" list(2665.000000 4940.000000) nil) | 12@@list("PR70210" "MX_R0805_SMALL_T02" list(8687.000000 7886.000000) nil) | 12@@list("PR70211" "MX_R0402_SMALL_T01" list(8350.000000 8881.000000) nil) | 12@@list("PR70212" "MX_R0603_SMALL_T01" list(8305.000000 6599.000000) nil) | 12@@list("PR70213" "MX_R0402_SMALL_T01" list(8352.200000 8964.200000) nil) | 12@@list("PR70215" "MX_R0805_SMALL_T02" list(8335.000000 8525.000000) nil) | 12@@list("PR70216" "MX_R1206" list(8312.200000 7878.600000) nil) | 12@@list("PR70217" "MX_R0402_SMALL_T01" list(8300.000000 8900.000000) nil) | 12@@list("PR70219" "MX_R0603_SMALL_T01" list(8541.380000 8646.000000) nil) | 12@@list("PR70220" "MX_R0805_SMALL_T02" list(8455.000000 8491.000000) nil) | 12@@list("PR70221" "MX_R0402_SMALL_T01" list(8649.000000 7771.000000) nil) | 12@@list("PR70222" "MX_R0402_SMALL_T01" list(8555.000000 8851.000000) nil) | 12@@list("PR70223" "MX_R0402_SMALL_T01" list(8545.000000 8905.000000) nil) | 12@@list("PR70225" "MX_R0402_SMALL_T01" list(8300.000000 8975.000000) nil) | 12@@list("PR70227" "MX_R0402_SMALL_T01" list(8455.000000 8567.000000) nil) | 12@@list("PR70228" "MX_R0402_SMALL_T01" list(2468.000000 4823.000000) nil) | 12@@list("PR70231" "MX_R0402_SMALL_T01" list(3460.000000 8915.000000) nil) | 12@@list("PR70238" "MX_R0402_SMALL_T01" list(4880.000000 3635.000000) nil) | 12@@list("PR70244" "MX_R0805_SMALL_T02" list(8840.000000 6335.000000) nil) | 12@@list("PR70245" "MX_R0805_SMALL_T02" list(8840.000000 6265.000000) nil) | 12@@list("PR70246" "MX_R0805_SMALL_T02" list(7760.000000 2617.000000) nil) | 12@@list("PR70250" "MX_R0402_SMALL_T01" list(8520.000000 5680.000000) nil) | 12@@list("PR70254" "MX_R0402_SMALL_T01" list(1600.000000 9090.000000) nil) | 12@@list("PR70256" "MX_R0402_SMALL_T01" list(2129.000000 4906.000000) nil) | 12@@list("PR70260" "MX_R0402_SMALL_T01" list(8581.000000 8905.000000) nil) | 12@@list("PR70261" "MX_R0402_SMALL_T01" list(2549.000000 4940.000000) nil) | 12@@list("PR70291" "MX_R0805_SMALL_T02" list(8117.000000 3296.000000) nil) | 12@@list("PR70296" "MX_R0805_SMALL_T02" list(9000.000000 7720.000000) nil) | 12@@list("PR70298" "MX_R0402_SMALL_T01" list(1781.000000 9333.000000) nil) | 12@@list("PR8" "MX_R0805_SMALL_T02" list(8562.000000 8496.000000) nil) | 12@@list("PR9" "MX_R0805_SMALL_T02" list(8215.000000 8330.000000) nil) | 12@@list("PRT581" "MX_R0402_SMALL_T01" list(2960.000000 7225.000000) nil) | 12@@list("PRT582" "MX_R0402_SMALL_T01" list(3953.000000 8511.000000) nil) | 12@@list("PRT583" "MX_R0402_SMALL_T01" list(2513.000000 7431.000000) nil) | 12@@list("PRT584" "MX_R0402_SMALL_T01" list(3995.000000 8980.000000) nil) | 12@@list("PU12" "MX_SOIC_8P_26_118X110_MAXIM" list(4642.000000 2072.000000) nil) | 12@@list("PU5" "MX_SOT23_S6_FITI" list(4990.000000 3802.000000) nil) | 12@@list("PU681" "MX_SOIC_8P_50_201X236_P_NIK" list(1737.000000 9144.000000) nil) | 12@@list("PU80" "MX_SOIC_8P_50_201X236_PAD" list(8250.000000 5906.000000) nil) | 12@@list("P_HDDFAN" "MX_WTOB_4P_49_2H_XINA" list(3488.000000 287.000000) nil) | 12@@list("Q3" "MX_SOT363" list(3820.000000 485.000000) nil) | 12@@list("Q35" "MX_SOT363" list(9047.000000 8510.000000) nil) | 12@@list("Q4" "MX_SOT23" list(4151.000000 307.000000) nil) | 12@@list("Q5" "MX_SOT363" list(4120.000000 485.000000) nil) | 12@@list("Q53" "MX_SOT363" list(8485.000000 5485.000000) nil) | 12@@list("Q9" "MX_SOT23" list(1112.000000 1610.000000) nil) | 12@@list("R18" "MX_R0402_SMALL_T01" list(8486.000000 1812.000000) nil) | 12@@list("R19" "MX_R0402_SMALL_T01" list(8422.000000 1812.000000) nil) | 12@@list("R25" "MX_R0603_SMALL_T01" list(4055.000000 224.000000) nil) | 12@@list("R27" "MX_R0603_SMALL_T01" list(3931.000000 224.000000) nil) | 12@@list("R30" "MX_R0603_SMALL_T01" list(3746.000000 224.000000) nil) | 12@@list("R31" "MX_R0603_SMALL_T01" list(3982.000000 224.000000) nil) | 12@@list("R36" "MX_R0805_SMALL_T02_H26" list(1239.000000 1653.000000) nil) | 12@@list("R37" "MX_R0402_SMALL_T01" list(1109.000000 1495.000000) nil) | 12@@list("R37456" "R0402" list(8760.000000 4136.000000) nil) | 12@@list("R60373" "MX_R0402_SMALL_T01" list(8886.000000 4124.000000) nil) | 12@@list("R60374" "MX_R0402_SMALL_T01" list(8808.000000 4605.000000) nil) | 12@@list("R60375" "R0402" list(8880.520000 3137.000000) nil) | 12@@list("R60381" "MX_R0402_SMALL_T01" list(8772.000000 4605.000000) nil) | 12@@list("R60385" "MX_R0402_SMALL_T01" list(8836.000000 4135.000000) nil) | 12@@list("R636" "MX_R0402_SMALL_T01" list(8880.000000 1350.000000) nil) | 12@@list("R69583" "MX_R0402_SMALL_T01" list(8882.000000 3175.000000) nil) | 12@@list("R69584" "MX_R0402_SMALL_T01" list(8798.000000 4135.000000) nil) | 12@@list("R69686" "MX_R0603_SMALL_T01" list(3871.000000 224.000000) nil) | 12@@list("R69687" "MX_R0603_SMALL_T01" list(3807.000000 224.000000) nil) | 12@@list("R69694" "MX_R0402_SMALL_T01" list(4653.000000 2210.000000) nil) | 12@@list("R69695" "MX_R0402_SMALL_T01" list(8720.500000 3908.000000) nil) | 12@@list("RFC100" "MX_C0402_SMALL_T01" list(8218.000000 5662.000000) nil) | 12@@list("RFC101" "MX_C0402_SMALL_T01" list(8221.980000 6259.950000) nil) | 12@@list("RFC102" "MX_C0402_SMALL_T01" list(8149.000000 4032.000000) nil) | 12@@list("RFC103" "MX_C0402_SMALL_T01" list(8182.000000 6480.000000) nil) | 12@@list("RFC104" "MX_C0402_SMALL_T01" list(6876.000000 3987.000000) nil) | 12@@list("RFC105" "MX_C0402_SMALL_T01" list(7510.000000 5697.000000) nil) | 12@@list("RFC106" "MX_C0402_SMALL_T01" list(8186.000000 6258.000000) nil) | 12@@list("RFC107" "MX_C0402_SMALL_T01" list(8185.000000 4060.000000) nil) | 12@@list("RFC108" "MX_C0402_SMALL_T01" list(7501.000000 5473.000000) nil) | 12@@list("RFC109" "MX_C0402_SMALL_T01" list(8257.980000 6259.950000) nil) | 12@@list("RFC110" "MX_C0402_SMALL_T01" list(8258.000000 4221.000000) nil) | 12@@list("RFC111" "MX_C0402_SMALL_T01" list(8218.000000 5626.000000) nil) | 12@@list("RFC112" "MX_C0402_SMALL_T01" list(2089.000000 2984.000000) nil) | 12@@list("RFC113" "MX_C0402_SMALL_T01" list(911.000000 475.000000) nil) | 12@@list("RFC114" "MX_C0402_SMALL_T01" list(944.000000 685.000000) nil) | 12@@list("RFC115" "MX_C0402_SMALL_T01" list(585.000000 6907.000000) nil) | 12@@list("RFC116" "MX_C0402_SMALL_T01" list(8905.000000 7736.000000) nil) | 12@@list("RFC117" "MX_C0402_SMALL_T01" list(8816.000000 6211.000000) nil) | 12@@list("RFC118" "MX_C0402_SMALL_T01" list(1940.500000 7603.420000) nil) | 12@@list("RFC119" "MX_C0402_SMALL_T01" list(1964.000000 6528.000000) nil) | 12@@list("RFC120" "MX_C0402_SMALL_T01" list(1500.000000 7540.000000) nil) | 12@@list("RFC121" "MX_C0402_SMALL_T01" list(1719.000000 5550.000000) nil) | 12@@list("RFC14" "MX_C0402_SMALL_T01" list(362.000000 5467.000000) nil) | 12@@list("RFC15" "MX_C0402_SMALL_T01" list(858.000000 5493.000000) nil) | 12@@list("RFC29" "MX_C0402_SMALL_T01" list(6837.000000 4195.000000) nil) | 12@@list("RFC30" "MX_C0402_SMALL_T01" list(7505.000000 4290.000000) nil) | 12@@list("RFC31" "MX_C0402_SMALL_T01" list(8181.000000 4300.000000) nil) | 12@@list("RFC32" "MX_C0402_SMALL_T01" list(8145.000000 4300.000000) nil) | 12@@list("RN23" "MX_4R8P0402" list(8040.000000 1286.000000) nil) | 12@@list("RN24" "MX_4R8P0402" list(8040.000000 1560.000000) nil) | 12@@list("RN25" "MX_4R8P0402" list(8040.000000 1460.000000) nil) | 12@@list("RN26" "MX_4R8P0402" list(8290.000000 1705.000000) nil) | 12@@list("SC101" "MX_C0603_SMALL_T01" list(5207.500000 2419.900000) nil) | 12@@list("SC102" "MX_C0603_SMALL_T01" list(6121.500000 1042.000000) nil) | 12@@list("SC103" "MX_C0603_SMALL_T01" list(6068.500000 1043.000000) nil) | 12@@list("SC105" "MX_C0402_SMALL_T01" list(5838.500000 1542.000000) nil) | 12@@list("SC121" "MX_C0402_SMALL_T01" list(5194.000000 1155.000000) nil) | 12@@list("SC141" "MX_C0402_SMALL_T01" list(6427.000000 1239.000000) nil) | 12@@list("SC146" "MX_C0402_SMALL_T01" list(5855.000000 1830.000000) nil) | 12@@list("SC147" "MX_C0402_SMALL_T01" list(6528.000000 948.000000) nil) | 12@@list("SC148" "MX_C0402_SMALL_T01" list(6202.000000 1135.000000) nil) | 12@@list("SC149" "MX_C0402_SMALL_T01" list(5180.000000 1103.000000) nil) | 12@@list("SC152" "MX_C0402_SMALL_T01" list(710.000000 6617.000000) nil) | 12@@list("SC153" "MX_C0402_SMALL_T01" list(710.000000 6653.000000) nil) | 12@@list("SC154" "MX_C0402_SMALL_T01" list(2925.000000 2618.000000) nil) | 12@@list("SC155" "MX_C0402_SMALL_T01" list(2790.000000 2617.000000) nil) | 12@@list("SC156" "MX_C0402_SMALL_T01" list(2961.000000 2618.000000) nil) | 12@@list("SC157" "MX_C0402_SMALL_T01" list(2826.000000 2617.000000) nil) | 12@@list("SC158" "MX_C0402_SMALL_T01" list(2646.000000 1820.000000) nil) | 12@@list("SC159" "MX_C0402_SMALL_T01" list(2925.000000 1815.000000) nil) | 12@@list("SC160" "MX_C0402_SMALL_T01" list(2488.000000 1848.000000) nil) | 12@@list("SC161" "MX_C0402_SMALL_T01" list(2765.000000 1815.000000) nil) | 12@@list("SC162" "MX_C0402_SMALL_T01" list(2524.000000 1848.000000) nil) | 12@@list("SC163" "MX_C0402_SMALL_T01" list(2961.000000 1815.000000) nil) | 12@@list("SC164" "MX_C0402_SMALL_T01" list(2610.000000 1820.000000) nil) | 12@@list("SC165" "MX_C0402_SMALL_T01" list(2801.000000 1815.000000) nil) | 12@@list("SC166" "MX_C0402_SMALL_T01" list(8947.000000 4413.500000) nil) | 12@@list("SC167" "MX_C0402_SMALL_T01" list(8958.000000 3261.000000) nil) | 12@@list("SC168" "MX_C0603_SMALL_T01" list(5366.300000 2484.100000) nil) | 12@@list("SC170" "MX_C0402_SMALL_T01" list(977.000000 9024.000000) nil) | 12@@list("SC171" "MX_C0402_SMALL_T01" list(767.000000 9022.000000) nil) | 12@@list("SC172" "MX_C0603_SMALL_T01" list(654.000000 9163.220000) nil) | 12@@list("SC173" "MX_C0402_SMALL_T01" list(917.000000 9153.000000) nil) | 12@@list("SC175" "MX_C0402_SMALL_T01" list(6588.000000 1280.000000) nil) | 12@@list("SC32" "MX_C0402_SMALL_T01" list(2478.000000 2618.000000) nil) | 12@@list("SC52" "MX_C0402_SMALL_T01" list(8707.000000 865.000000) nil) | 12@@list("SC6" "MX_C0402_SMALL_T01" list(6039.000000 1264.000000) nil) | 12@@list("SC61" "MX_C0402_SMALL_T01" list(2442.000000 2618.000000) nil) | 12@@list("SC62" "MX_C0402_SMALL_T01" list(2619.000000 2617.000000) nil) | 12@@list("SC63" "MX_C0402_SMALL_T01" list(2655.000000 2617.000000) nil) | 12@@list("SC64" "MX_C0402_SMALL_T01" list(710.000000 6401.000000) nil) | 12@@list("SC65" "MX_C0402_SMALL_T01" list(710.000000 6437.000000) nil) | 12@@list("SC66" "MX_C0402_SMALL_T01" list(710.000000 6473.000000) nil) | 12@@list("SC67" "MX_C0402_SMALL_T01" list(710.000000 6509.000000) nil) | 12@@list("SC68" "MX_C0402_SMALL_T01" list(710.000000 6545.000000) nil) | 12@@list("SC69" "MX_C0402_SMALL_T01" list(710.000000 6581.000000) nil) | 12@@list("SC7" "MX_C0402_SMALL_T01" list(5990.000000 1166.000000) nil) | 12@@list("SC70" "MX_C0402_SMALL_T01" list(6485.000000 1080.000000) nil) | 12@@list("SC72" "MX_C0402_SMALL_T01" list(7420.000000 1565.000000) nil) | 12@@list("SC8" "MX_C0402_SMALL_T01" list(5958.000000 2489.000000) nil) | 12@@list("SC80" "MX_C0402_SMALL_T01" list(5965.000000 1395.000000) nil) | 12@@list("SC81" "MX_C0402_SMALL_T01" list(5825.000000 1395.000000) nil) | 12@@list("SC82" "MX_C0402_SMALL_T01" list(5965.000000 1358.000000) nil) | 12@@list("SC83" "MX_C0402_SMALL_T01" list(5885.000000 1440.000000) nil) | 12@@list("SC85" "MX_C0402_SMALL_T01" list(7420.000000 1524.500000) nil) | 12@@list("SC86" "MX_C0402_SMALL_T01" list(7420.000000 1447.000000) nil) | 12@@list("SC9" "MX_C0402_SMALL_T01" list(5993.000000 2425.000000) nil) | 12@@list("SC90" "MX_C0402_SMALL_T01" list(7420.000000 1488.500000) nil) | 12@@list("SCB1" "MX_C0603_SMALL_T02" list(7830.000000 2412.000000) nil) | 12@@list("SCB11" "MX_C0402_SMALL_T01" list(7406.000000 2195.200000) nil) | 12@@list("SCB119" "MX_C0402_SMALL_T01" list(8471.000000 874.000000) nil) | 12@@list("SCB12" "MX_C0603_SMALL_T02" list(7522.000000 2595.000000) nil) | 12@@list("SCB120" "MX_C0402_SMALL_T01" list(7408.000000 1635.000000) nil) | 12@@list("SCB121" "MX_C0402_SMALL_T01" list(7825.000000 420.000000) nil) | 12@@list("SCB122" "MX_C0402_SMALL_T01" list(7330.000000 1300.000000) nil) | 12@@list("SCB13" "MX_C0402_SMALL_T01" list(7475.000000 2604.880000) nil) | 12@@list("SCB14" "MX_C0603_SMALL_T02" list(5848.000000 2225.880000) nil) | 12@@list("SCB15" "MX_C0603_SMALL_T02" list(7575.000000 2635.000000) nil) | 12@@list("SCB16" "MX_C0603_SMALL_T02" list(7908.900000 2304.000000) nil) | 12@@list("SCB19" "MX_C0402_SMALL_T01" list(7290.000000 1300.000000) nil) | 12@@list("SCB2" "MX_C0603_SMALL_T02" list(7972.000000 2520.000000) nil) | 12@@list("SCB21" "MX_C0402_SMALL_T01" list(7480.000000 1635.000000) nil) | 12@@list("SCB25" "MX_C0402_SMALL_T01" list(6441.000000 1006.000000) nil) | 12@@list("SCB3" "MX_C0402_SMALL_T01" list(7444.000000 1635.000000) nil) | 12@@list("SCB30" "MX_C0402_SMALL_T01" list(6826.000000 1059.000000) nil) | 12@@list("SCB31" "MX_C0402_SMALL_T01" list(6836.000000 1293.000000) nil) | 12@@list("SCB32" "MX_C0402_SMALL_T01" list(6892.000000 1294.000000) nil) | 12@@list("SCB35" "MX_C0402_SMALL_T01" list(6748.000000 990.000000) nil) | 12@@list("SCB4" "MX_C0603_SMALL_T02" list(5923.000000 2225.880000) nil) | 12@@list("SCB5" "MX_C0402_SMALL_T01" list(5993.000000 2235.880000) nil) | 12@@list("SCB68" "MX_C0402_SMALL_T01" list(8543.000000 868.000000) nil) | 12@@list("SCB69" "MX_C0402_SMALL_T01" list(8235.000000 868.000000) nil) | 12@@list("SCB7" "MX_C0402_SMALL_T01" list(7530.000000 1875.000000) nil) | 12@@list("SCB70" "MX_C0402_SMALL_T01" list(8594.000000 804.000000) nil) | 12@@list("SCB75" "MX_C0402_SMALL_T01" list(8650.000000 1704.500000) nil) | 12@@list("SCB8" "MX_C0603_SMALL_T02" list(7440.000000 2370.000000) nil) | 12@@list("SCB9" "MX_C0402_SMALL_T01" list(7456.000000 2215.000000) nil) | 12@@list("SQ1" "MX_SOT23" list(7975.250000 2005.760000) nil) | 12@@list("SR1" "MX_R0402_SMALL_T01" list(5615.300000 1610.500000) nil) | 12@@list("SR100" "MX_R0402_SMALL_T01" list(5369.500000 2553.570000) nil) | 12@@list("SR101" "MX_R0402_SMALL_T01" list(6065.000000 1107.000000) nil) | 12@@list("SR102" "MX_R0402_SMALL_T01" list(6129.000000 1107.000000) nil) | 12@@list("SR115" "MX_R0402_SMALL_T01" list(6453.000000 1189.000000) nil) | 12@@list("SR119" "MX_R0402_SMALL_T01" list(6653.000000 1315.000000) nil) | 12@@list("SR12" "MX_R0603_SMALL_T01" list(7473.000000 2699.000000) nil) | 12@@list("SR129" "MX_R0402_SMALL_T01" list(7846.000000 2052.000000) nil) | 12@@list("SR13" "MX_R0402_SMALL_T01" list(7947.000000 1901.000000) nil) | 12@@list("SR139" "MX_R0402_SMALL_T01" list(5889.000000 1310.000000) nil) | 12@@list("SR14" "MX_R0402_SMALL_T01" list(7988.000000 2110.000000) nil) | 12@@list("SR15" "MX_R0402_SMALL_T01" list(7004.000000 1205.000000) nil) | 12@@list("SR153" "MX_R0402_SMALL_T01" list(3165.000000 4395.000000) nil) | 12@@list("SR154" "MX_R0402_SMALL_T01" list(3608.000000 4591.000000) nil) | 12@@list("SR160" "MX_R0402_SMALL_T01" list(5520.000000 1615.000000) nil) | 12@@list("SR162" "MX_R0402_SMALL_T01" list(3432.370000 4411.690000) nil) | 12@@list("SR164" "MX_R0402_SMALL_T01" list(3319.230000 4298.550000) nil) | 12@@list("SR165" "MX_R0402_SMALL_T01" list(3755.000000 3980.000000) nil) | 12@@list("SR166" "MX_R0402_SMALL_T01" list(3732.000000 3847.000000) nil) | 12@@list("SR17" "MX_R0805_SMALL_T02" list(380.000000 9380.000000) nil) | 12@@list("SR18" "MX_R0402_SMALL_T01" list(6648.000000 1063.000000) nil) | 12@@list("SR2" "MX_R0402_SMALL_T01" list(5945.000000 1890.000000) nil) | 12@@list("SR20" "MX_R0402_SMALL_T01" list(5615.300000 1647.900000) nil) | 12@@list("SR220" "MX_R0402_SMALL_T01" list(5686.800000 1867.300000) nil) | 12@@list("SR240" "MX_R0402_SMALL_T01" list(6030.000000 1475.000000) nil) | 12@@list("SR241" "MX_R0402_SMALL_T01" list(5965.000000 1457.000000) nil) | 12@@list("SR242" "MX_R0402_SMALL_T01" list(6030.000000 1358.000000) nil) | 12@@list("SR243" "MX_R0402_SMALL_T01" list(6030.000000 1439.000000) nil) | 12@@list("SR244" "MX_R0402_SMALL_T01" list(6030.000000 1395.000000) nil) | 12@@list("SR245" "MX_R0402_SMALL_T01" list(4878.000000 4721.000000) nil) | 12@@list("SR246" "MX_R0402_SMALL_T01" list(6027.000000 1749.000000) nil) | 12@@list("SR250" "MX_R0402_SMALL_T01" list(7558.000000 1578.000000) nil) | 12@@list("SR251" "MX_R0402_SMALL_T01" list(7558.000000 1544.000000) nil) | 12@@list("SR252" "MX_R0402_SMALL_T01" list(7558.000000 1473.000000) nil) | 12@@list("SR253" "MX_R0402_SMALL_T01" list(7558.000000 1439.000000) nil) | 12@@list("SR254" "MX_R0402_SMALL_T01" list(7558.000000 1613.000000) nil) | 12@@list("SR255" "MX_R0402_SMALL_T01" list(7558.000000 1511.000000) nil) | 12@@list("SR256" "MX_R0402_SMALL_T01" list(7693.000000 1532.000000) nil) | 12@@list("SR257" "MX_R0402_SMALL_T01" list(7693.000000 1498.000000) nil) | 12@@list("SR268" "MX_R0402_SMALL_T01" list(6786.010000 1308.500000) nil) | 12@@list("SR27" "MX_R0402_SMALL_T01" list(7013.000000 1300.000000) nil) | 12@@list("SR275" "MX_R0402_SMALL_T01" list(7490.400000 1722.400000) nil) | 12@@list("SR277" "MX_R0402_SMALL_T01" list(7562.000000 1663.000000) nil) | 12@@list("SR278" "MX_R0402_SMALL_T01" list(7625.000000 1663.000000) nil) | 12@@list("SR28" "MX_R0402_SMALL_T01" list(7049.000000 1300.000000) nil) | 12@@list("SR280" "MX_R0402_SMALL_T01" list(6030.000000 1550.000000) nil) | 12@@list("SR281" "MX_R0402_SMALL_T01" list(5725.000000 1802.000000) nil) | 12@@list("SR287" "MX_R0402_SMALL_T01" list(5958.000000 1650.000000) nil) | 12@@list("SR289" "MX_R0402_SMALL_T01" list(5825.000000 1638.000000) nil) | 12@@list("SR29" "MX_R0402_SMALL_T01" list(7121.000000 1300.000000) nil) | 12@@list("SR292" "MX_R0402_SMALL_T01" list(5861.000000 1638.000000) nil) | 12@@list("SR30" "MX_R0402_SMALL_T01" list(7085.000000 1300.000000) nil) | 12@@list("SR31" "MX_R0402_SMALL_T01" list(6976.000000 1300.000000) nil) | 12@@list("SR336" "MX_R0402_SMALL_T01" list(6202.000000 1171.000000) nil) | 12@@list("SR343" "MX_R0402_SMALL_T01" list(6590.000000 1187.000000) nil) | 12@@list("SR360" "MX_R0402_SMALL_T01" list(6270.000000 1110.000000) nil) | 12@@list("SR363" "MX_R0402_SMALL_T01" list(6270.000000 1146.000000) nil) | 12@@list("SR364" "MX_R0402_SMALL_T01" list(6150.000000 1157.000000) nil) | 12@@list("SR365" "MX_R0402_SMALL_T01" list(6266.000000 1182.000000) nil) | 12@@list("SR366" "MX_R0402_SMALL_T01" list(6986.000000 1054.000000) nil) | 12@@list("SR367" "MX_R0402_SMALL_T01" list(5920.000000 1830.000000) nil) | 12@@list("SR370" "MX_R0402_SMALL_T01" list(7383.000000 1279.000000) nil) | 12@@list("SR371" "MX_R0402_SMALL_T01" list(7383.000000 1315.000000) nil) | 12@@list("SR375" "MX_R0402_SMALL_T01" list(6270.000000 1074.000000) nil) | 12@@list("SR4" "MX_R0402_SMALL_T01" list(6477.000000 1006.000000) nil) | 12@@list("SR400" "MX_R0402_SMALL_T01" list(5773.000000 2544.000000) nil) | 12@@list("SR401" "MX_R0402_SMALL_T01" list(6394.000000 2588.000000) nil) | 12@@list("SR411" "MX_R0603_SMALL_T01" list(5770.000000 2231.000000) nil) | 12@@list("SR43" "MX_R0603_SMALL_T01" list(7672.700000 2382.900000) nil) | 12@@list("SR44" "MX_R0402_SMALL_T01" list(5991.000000 1230.000000) nil) | 12@@list("SR443" "MX_R0402_SMALL_T01" list(7475.000000 1774.000000) nil) | 12@@list("SR45" "MX_R0402_SMALL_T01" list(6030.000000 1207.000000) nil) | 12@@list("SR49" "MX_R0603_SMALL_T01" list(7524.500000 2698.900000) nil) | 12@@list("SR54" "MX_R0603_SMALL_T01" list(7586.000000 1866.000000) nil) | 12@@list("SR545" "MX_R0402_SMALL_T01" list(7683.000000 1929.000000) nil) | 12@@list("SR59" "MX_R0402_SMALL_T01" list(6027.000000 2458.000000) nil) | 12@@list("SR60" "MX_R0402_SMALL_T01" list(5855.000000 1890.000000) nil) | 12@@list("SR628" "MX_R0402_SMALL_T01" list(1034.000000 6705.000000) nil) | 12@@list("SR629" "MX_R0402_SMALL_T01" list(1034.000000 6669.000000) nil) | 12@@list("SR650" "MX_R0402_SMALL_T01" list(6935.000000 1201.000000) nil) | 12@@list("SR659" "MX_R0402_SMALL_T01" list(5194.000000 1192.000000) nil) | 12@@list("SR664" "MX_R0402_SMALL_T01" list(6030.000000 1511.700000) nil) | 12@@list("SR667" "MX_R0402_SMALL_T01" list(7697.000000 2171.000000) nil) | 12@@list("SR671" "MX_R0402_SMALL_T01" list(7625.000000 2171.000000) nil) | 12@@list("SR673" "MX_R0402_SMALL_T01" list(7796.000000 2171.000000) nil) | 12@@list("SR678" "MX_R0402_SMALL_T01" list(7213.000000 1231.000000) nil) | 12@@list("SR680" "MX_R0402_SMALL_T01" list(6743.000000 1199.000000) nil) | 12@@list("SR694" "MX_R0402_SMALL_T01" list(5785.000000 1890.000000) nil) | 12@@list("SR7" "MX_R0402_SMALL_T01" list(9130.980000 794.860000) nil) | 12@@list("SR70" "MX_R0402_SMALL_T01" list(6030.000000 1890.000000) nil) | 12@@list("SR711" "MX_R0402_SMALL_T01" list(7454.800000 2089.500000) nil) | 12@@list("SR712" "MX_R0402_SMALL_T01" list(7454.800000 2130.700000) nil) | 12@@list("SR713" "MX_R0402_SMALL_T01" list(2182.000000 4555.000000) nil) | 12@@list("SR714" "MX_R0402_SMALL_T01" list(2182.000000 4519.000000) nil) | 12@@list("SR738" "MX_R0402_SMALL_T01" list(6253.000000 895.000000) nil) | 12@@list("SR745" "MX_R0402_SMALL_T01" list(6528.000000 984.500000) nil) | 12@@list("SR746" "MX_R0402_SMALL_T01" list(6504.000000 1186.000000) nil) | 12@@list("SR747" "MX_R0402_SMALL_T01" list(5958.000000 2425.000000) nil) | 12@@list("SR749" "MX_R0402_SMALL_T01" list(6780.000000 1255.000000) nil) | 12@@list("SR75" "MX_R0402_SMALL_T01" list(5260.000000 4280.000000) nil) | 12@@list("SR7564" "MX_R0402_SMALL_T01" list(9021.000000 3947.000000) nil) | 12@@list("SR7565" "MX_R0402_SMALL_T01" list(8912.000000 4377.000000) nil) | 12@@list("SR758" "MX_R0402_SMALL_T01" list(5356.420000 2439.700000) nil) | 12@@list("SR759" "MX_R0402_SMALL_T01" list(5356.300000 2390.800000) nil) | 12@@list("SR7622" "MX_R0402_SMALL_T01" list(3685.000000 4668.000000) nil) | 12@@list("SR7627" "MX_R0402_SMALL_T01" list(7213.700000 1273.500000) nil) | 12@@list("SR7628" "MX_R0402_SMALL_T01" list(7213.700000 1309.500000) nil) | 12@@list("SR7629" "MX_R0402_SMALL_T01" list(6781.000000 1160.000000) nil) | 12@@list("SR7630" "MX_R0402_SMALL_T01" list(5770.000000 1542.000000) nil) | 12@@list("SR7634" "MX_R0402_SMALL_T01" list(3633.000000 4617.000000) nil) | 12@@list("SR7635" "MX_R0402_SMALL_T01" list(3290.000000 4474.000000) nil) | 12@@list("SR7637" "MX_R0402_SMALL_T01" list(5180.000000 1067.000000) nil) | 12@@list("SR7638" "MX_R0402_SMALL_T01" list(6421.000000 1080.000000) nil) | 12@@list("SR7642" "MX_R0402_SMALL_T01" list(3515.000000 4496.000000) nil) | 12@@list("SR7643" "MX_R0402_SMALL_T01" list(3490.000000 4470.000000) nil) | 12@@list("SR7646" "MX_R0402_SMALL_T01" list(6527.500000 1021.000000) nil) | 12@@list("SR7656" "MX_R0402_SMALL_T01" list(6506.000000 1253.000000) nil) | 12@@list("SR7658" "MX_R0402_SMALL_T01" list(5942.500000 1529.500000) nil) | 12@@list("SR7659" "MX_R0402_SMALL_T01" list(2281.000000 360.000000) nil) | 12@@list("SR7660" "MX_R0402_SMALL_T01" list(2201.000000 360.000000) nil) | 12@@list("SR7676" "MX_R0402_SMALL_T01" list(8787.000000 3981.310000) nil) | 12@@list("SR7677" "MX_R0402_SMALL_T01" list(2886.000000 365.000000) nil) | 12@@list("SR7678" "MX_R0402_SMALL_T01" list(2922.000000 365.000000) nil) | 12@@list("SR7682" "MX_R0402_SMALL_T01" list(1925.000000 1355.000000) nil) | 12@@list("SR7683" "MX_R0402_SMALL_T01" list(1975.000000 1355.000000) nil) | 12@@list("SR7684" "MX_R0402_SMALL_T01" list(1919.000000 2084.000000) nil) | 12@@list("SR7685" "MX_R0402_SMALL_T01" list(1955.000000 2084.000000) nil) | 12@@list("SR7686" "MX_R0402_SMALL_T01" list(1950.000000 549.000000) nil) | 12@@list("SR7687" "MX_R0402_SMALL_T01" list(1994.000000 549.000000) nil) | 12@@list("SR7688" "MX_R0402_SMALL_T01" list(1894.000000 2600.000000) nil) | 12@@list("SR7689" "MX_R0402_SMALL_T01" list(1959.000000 2600.000000) nil) | 12@@list("SR7690" "MX_R0402_SMALL_T01" list(5109.000000 1135.000000) nil) | 12@@list("SR7691" "MX_R0402_SMALL_T01" list(3769.000000 3880.000000) nil) | 12@@list("SR7696" "MX_R0402_SMALL_T01" list(7545.200000 2139.100000) nil) | 12@@list("SR7697" "MX_R0402_SMALL_T01" list(7545.200000 2088.000000) nil) | 12@@list("SR7698" "MX_R0402_SMALL_T01" list(7683.000000 1966.000000) nil) | 12@@list("SR7701" "MX_R0402_SMALL_T01" list(8787.000000 3944.000000) nil) | 12@@list("SR7702" "MX_R0402_SMALL_T01" list(7736.000000 1712.000000) nil) | 12@@list("SR7703" "MX_R0402_SMALL_T01" list(1013.000000 9024.000000) nil) | 12@@list("SR7704" "MX_R0402_SMALL_T01" list(767.000000 9087.000000) nil) | 12@@list("SR7705" "MX_R0402_SMALL_T01" list(714.000000 9103.500000) nil) | 12@@list("SR7706" "MX_R0402_SMALL_T01" list(698.000000 9173.100000) nil) | 12@@list("SR7707" "MX_R0805_SMALL_T02" list(919.000000 9228.000000) nil) | 12@@list("SR7713" "MX_R0402_SMALL_T01" list(6654.000000 1273.000000) nil) | 12@@list("SR7714" "MX_R0402_SMALL_T01" list(5211.000000 9246.000000) nil) | 12@@list("SR7717" "MX_R0402_SMALL_T01" list(3562.130000 4549.900000) nil) | 12@@list("SR7748" "MX_R0402_SMALL_T01" list(7653.000000 1809.000000) nil) | 12@@list("SR7767" "MX_R0402_SMALL_T01" list(2340.500000 380.400000) nil) | 12@@list("SR7768" "MX_R0402_SMALL_T01" list(3034.000000 365.000000) nil) | 12@@list("SR7769" "MX_R0402_SMALL_T01" list(7545.000000 2183.000000) nil) | 12@@list("SR7776" "MX_R0402_SMALL_T01" list(2303.230000 584.300000) nil) | 12@@list("SR7777" "MX_R0402_SMALL_T01" list(2339.230000 584.300000) nil) | 12@@list("SR7778" "MX_R0402_SMALL_T01" list(7651.000000 1758.000000) nil) | 12@@list("SR7779" "MX_R0402_SMALL_T01" list(7689.000000 1758.000000) nil) | 12@@list("SR7780" "MX_R0402_SMALL_T01" list(2393.000000 1368.000000) nil) | 12@@list("SR7781" "MX_R0402_SMALL_T01" list(6150.700000 478.600000) nil) | 12@@list("SR7784" "MX_R0402_SMALL_T01" list(7742.500000 2171.000000) nil) | 12@@list("SR8" "MX_R0402_SMALL_T01" list(9078.000000 719.000000) nil) | 12@@list("SR80" "MX_R0402_SMALL_T01" list(6654.000000 918.000000) nil) | 12@@list("SR81" "MX_R0402_SMALL_T01" list(6698.000000 918.000000) nil) | 12@@list("SR82" "MX_R0402_SMALL_T01" list(6608.000000 1086.000000) nil) | 12@@list("SR83" "MX_R0402_SMALL_T01" list(6304.500000 983.000000) nil) | 12@@list("SR839" "MX_R0402_SMALL_T01" list(8415.000000 880.000000) nil) | 12@@list("SR84" "MX_R0402_SMALL_T01" list(6255.000000 948.000000) nil) | 12@@list("SR85" "MX_R0402_SMALL_T01" list(6318.000000 895.000000) nil) | 12@@list("SR87" "MX_R0402_SMALL_T01" list(6485.000000 1116.000000) nil) | 12@@list("SR92" "MX_R0402_SMALL_T01" list(6463.000000 1239.000000) nil) | 12@@list("SR94" "MX_R0402_SMALL_T01" list(7559.800000 1932.600000) nil) | 12@@list("SS4" "MX_MINI_PCI_67P_20_4H_COLAY" list(8596.780000 621.170000) nil) | 12@@list("SW1" "MX_SW_4P_181X126" list(4763.000000 1122.000000) nil) | 12@@list("SW2" "MX_SW_4P_181X126" list(5009.000000 1218.000000) nil) | 12@@list("TC1" "MX_C0402_SMALL_T01" list(9125.000000 2556.000000) nil) | 12@@list("TC10" "MX_C0402_SMALL_T01" list(9129.000000 1874.000000) nil) | 12@@list("TC11" "MX_C0402_SMALL_T01" list(9129.000000 1765.000000) nil) | 12@@list("TC12" "MX_C0402_SMALL_T01" list(9129.000000 1729.000000) nil) | 12@@list("TC2" "MX_C0402_SMALL_T01" list(9125.000000 2520.000000) nil) | 12@@list("TC21" "MX_C0402_SMALL_T01" list(9110.000000 1249.000000) nil) | 12@@list("TC22" "MX_C0402_SMALL_T01" list(9110.180000 1213.000000) nil) | 12@@list("TC23" "MX_C0402_SMALL_T01" list(9111.180000 1172.000000) nil) | 12@@list("TC24" "MX_C0402_SMALL_T01" list(9111.000000 1135.000000) nil) | 12@@list("TC3" "MX_C0402_SMALL_T01" list(9125.000000 2436.000000) nil) | 12@@list("TC4" "MX_C0402_SMALL_T01" list(9125.000000 2400.000000) nil) | 12@@list("TC5" "MX_C0402_SMALL_T01" list(9128.000000 511.000000) nil) | 12@@list("TC6" "MX_C0402_SMALL_T01" list(9128.000000 475.000000) nil) | 12@@list("TC7" "MX_C0402_SMALL_T01" list(9123.000000 347.000000) nil) | 12@@list("TC8" "MX_C0402_SMALL_T01" list(9123.000000 311.000000) nil) | 12@@list("TC9" "MX_C0402_SMALL_T01" list(9129.000000 1910.000000) nil) | 12@@list("TUC21" "MX_C0603_SMALL_T01" list(449.000000 6063.000000) nil) | 12@@list("TUC22" "MX_C0402_SMALL_T01" list(342.100000 5784.100000) nil) | 12@@list("TUU2" "MX_SOT23_S5_H57" list(1605.000000 7881.000000) nil) | 12@@list("U15" "A_QFP_48P_20_283X283" list(4495.000000 1418.000000) nil) | 12@@list("U2FC1" "MX_C0805_SMALL_T02" list(3454.000000 516.000000) nil) | 12@@list("U2FC2" "MX_C0402_SMALL_T01" list(3510.000000 499.000000) nil) | 12@@list("UC1" "MX_C0402_SMALL_T01" list(1289.000000 5411.000000) nil) | 12@@list("UC10" "MX_C0603_SMALL_T02" list(9146.000000 4482.000000) nil) | 12@@list("UC11" "MX_C0603_SMALL_T02" list(9067.000000 3410.000000) nil) | 12@@list("UC12" "MX_C0402_SMALL_T01" list(9183.000000 4292.000000) nil) | 12@@list("UC16" "MX_C0402_SMALL_T01" list(9183.000000 4256.000000) nil) | 12@@list("UC2" "SOIC_8P_50_197X236" list(4047.000000 1291.000000) nil) | 12@@list("UC29" "MX_C0402_SMALL_T01" list(1172.090000 5213.920000) nil) | 12@@list("UC30" "MX_C0402_SMALL_T01" list(1146.640000 5188.460000) nil) | 12@@list("UC31" "MX_C0402_SMALL_T01" list(1058.510000 5509.000000) nil) | 12@@list("UC32" "MX_C0402_SMALL_T01" list(1094.520000 5509.000000) nil) | 12@@list("UC50" "MX_C0402_SMALL_T01" list(9117.000000 3815.000000) nil) | 12@@list("UC51" "MX_C0402_SMALL_T01" list(9081.000000 3815.000000) nil) | 12@@list("UC52" "MX_C0402_SMALL_T01" list(9160.000000 3728.000000) nil) | 12@@list("UC53" "MX_C0402_SMALL_T01" list(9196.000000 3728.000000) nil) | 12@@list("UC641" "MX_C0603_SMALL_T01" list(1416.000000 7098.000000) nil) | 12@@list("UC68" "MX_C0402_SMALL_T01" list(1665.000000 5761.000000) nil) | 12@@list("UC69" "MX_C0402_SMALL_T01" list(1656.000000 5466.000000) nil) | 12@@list("UC77" "MX_C0402_SMALL_T01" list(1209.000000 5820.000000) nil) | 12@@list("UC78" "MX_C0402_SMALL_T01" list(1165.900000 5657.900000) nil) | 12@@list("UC79" "MX_C0402_SMALL_T01" list(1417.940000 5434.000000) nil) | 12@@list("UC81" "MX_C0402_SMALL_T01" list(1217.000000 5748.000000) nil) | 12@@list("UC82" "MX_C0402_SMALL_T01" list(1593.000000 5442.300000) nil) | 12@@list("UC83" "MX_C0402_SMALL_T01" list(1503.000000 5415.000000) nil) | 12@@list("UC86" "MX_C0402_SMALL_T01" list(1389.000000 5320.000000) nil) | 12@@list("UC87" "MX_C0402_SMALL_T01" list(1425.000000 5320.000000) nil) | 12@@list("UC9" "MX_C0402_SMALL_T01" list(9006.000000 4062.000000) nil) | 12@@list("UC90" "MX_C0402_SMALL_T01" list(1202.000000 5502.000000) nil) | 12@@list("UC91" "MX_C0603_SMALL_T01" list(1781.380000 5516.720000) nil) | 12@@list("UC92" "MX_C0603_SMALL_T01" list(1535.200000 6111.600000) nil) | 12@@list("UC93" "MX_C0603_SMALL_T01" list(1694.720000 5149.620000) nil) | 12@@list("UC943" "MX_C0402_SMALL_T01" list(1461.000000 5349.000000) nil) | 12@@list("UC944" "MX_C0402_SMALL_T01" list(1497.000000 5349.000000) nil) | 12@@list("UC946" "MX_C0402_SMALL_T01" list(531.000000 5868.000000) nil) | 12@@list("UC947" "MX_C0402_SMALL_T01" list(531.000000 5832.000000) nil) | 12@@list("UC948" "MX_C0402_SMALL_T01" list(576.000000 5710.000000) nil) | 12@@list("UC949" "MX_C0402_SMALL_T01" list(612.000000 5710.000000) nil) | 12@@list("UC950" "MX_C0402_SMALL_T01" list(1307.000000 5943.000000) nil) | 12@@list("UC959" "MX_C0402_SMALL_T01" list(9146.000000 4854.000000) nil) | 12@@list("UC96" "MX_C0402_SMALL_T01" list(1251.000000 5057.000000) nil) | 12@@list("UC960" "MX_C0402_SMALL_T01" list(9067.000000 4939.000000) nil) | 12@@list("UC963" "MX_C0402_SMALL_T01" list(9103.000000 4939.000000) nil) | 12@@list("UC964" "MX_C0402_SMALL_T01" list(9182.000000 4854.000000) nil) | 12@@list("UC968" "MX_C0402_SMALL_T01" list(9171.000000 4569.000000) nil) | 12@@list("UC969" "MX_C0402_SMALL_T01" list(1632.000000 5906.000000) nil) | 12@@list("UC97" "MX_C0402_SMALL_T01" list(1251.000000 5021.000000) nil) | 12@@list("UC970" "MX_C0402_SMALL_T01" list(1209.000000 5859.000000) nil) | 12@@list("UC971" "MX_C0402_SMALL_T01" list(1537.000000 5991.000000) nil) | 12@@list("UC972" "MX_C0402_SMALL_T01" list(9130.000000 4569.000000) nil) | 12@@list("UC973" "MX_C0402_SMALL_T01" list(9239.000000 4472.000000) nil) | 12@@list("UC974" "MX_C0402_SMALL_T01" list(9290.000000 3483.000000) nil) | 12@@list("UC975" "MX_C0402_SMALL_T01" list(478.000000 5908.000000) nil) | 12@@list("UC976" "MX_C0402_SMALL_T01" list(478.000000 5944.000000) nil) | 12@@list("UC977" "MX_C0402_SMALL_T01" list(505.000000 5755.000000) nil) | 12@@list("UC978" "MX_C0402_SMALL_T01" list(505.000000 5791.000000) nil) | 12@@list("UC979" "MX_C0402_SMALL_T01" list(1058.800000 5330.800000) nil) | 12@@list("UC98" "MX_C0402_SMALL_T01" list(1213.390000 5131.150000) nil) | 12@@list("UC980" "MX_C0402_SMALL_T01" list(1058.800000 5294.400000) nil) | 12@@list("UC981" "MX_C0402_SMALL_T01" list(1019.000000 5072.000000) nil) | 12@@list("UC982" "MX_C0402_SMALL_T01" list(1019.000000 5036.000000) nil) | 12@@list("UC983" "MX_C0402_SMALL_T01" list(1119.000000 5015.000000) nil) | 12@@list("UC984" "MX_C0402_SMALL_T01" list(1119.000000 4979.000000) nil) | 12@@list("UC985" "MX_C0402_SMALL_T01" list(1054.000000 4957.000000) nil) | 12@@list("UC986" "MX_C0402_SMALL_T01" list(1054.000000 4921.000000) nil) | 12@@list("UC987" "MX_C0402_SMALL_T01" list(9061.000000 3645.220000) nil) | 12@@list("UC988" "MX_C0402_SMALL_T01" list(9097.190000 3645.220000) nil) | 12@@list("UC99" "MX_C0402_SMALL_T01" list(1213.390000 5095.150000) nil) | 12@@list("UC991" "MX_C0402_SMALL_T01" list(9102.180000 3538.190000) nil) | 12@@list("UC992" "MX_C0402_SMALL_T01" list(9102.180000 3502.190000) nil) | 12@@list("UC993" "MX_C0402_SMALL_T01" list(9073.600000 4814.800000) nil) | 12@@list("UC994" "MX_C0402_SMALL_T01" list(9073.600000 4778.800000) nil) | 12@@list("UC995" "MX_C0402_SMALL_T01" list(9102.000000 4689.400000) nil) | 12@@list("UC996" "MX_C0402_SMALL_T01" list(9102.000000 4726.400000) nil) | 12@@list("UCB1" "MX_C0603_SMALL_T02" list(357.150000 5543.380000) nil) | 12@@list("UCB2" "MX_C0603_SMALL_T02" list(943.840000 5479.380000) nil) | 12@@list("UCB27" "MX_C0402_SMALL_T01" list(2159.000000 360.000000) nil) | 12@@list("UCB28" "MX_C0402_SMALL_T01" list(2244.000000 360.000000) nil) | 12@@list("UCB3" "MX_C0603_SMALL_T02" list(1000.530000 5479.380000) nil) | 12@@list("UCB4" "MX_C0603_SMALL_T02" list(409.220000 5543.380000) nil) | 12@@list("UCB5" "MX_C0603_SMALL_T02" list(834.000000 8551.000000) nil) | 12@@list("UCB6" "MX_C0603_SMALL_T02" list(834.000000 8607.000000) nil) | 12@@list("UCC1" "C0402" list(4625.000000 1655.000000) nil) | 12@@list("UCC10" "MX_C0402_SMALL_T01" list(4385.000000 1672.000000) nil) | 12@@list("UCC12" "MX_C0402_SMALL_T01" list(4014.000000 1494.000000) nil) | 12@@list("UCC13" "MX_C0402_SMALL_T01" list(4241.000000 1283.000000) nil) | 12@@list("UCC14" "MX_C0402_SMALL_T01" list(4242.000000 1350.000000) nil) | 12@@list("UCC2" "C0402" list(4543.000000 1695.000000) nil) | 12@@list("UCC8" "MX_C0603_SMALL_T01" list(4764.000000 1553.000000) nil) | 12@@list("UCC9" "MX_C0603_SMALL_T01" list(4306.000000 1618.000000) nil) | 12@@list("UCR11" "MX_R0402_SMALL_T01" list(4524.300000 1123.900000) nil) | 12@@list("UCR12" "MX_R0402_SMALL_T01" list(4558.800000 1123.900000) nil) | 12@@list("UCR13" "MX_R0402_SMALL_T01" list(4215.000000 1416.000000) nil) | 12@@list("UCR14" "MX_R0402_SMALL_T01" list(4215.000000 1451.000000) nil) | 12@@list("UCR15" "MX_R0402_SMALL_T01" list(4115.000000 1488.000000) nil) | 12@@list("UCR19" "MX_R0402_SMALL_T01" list(4787.000000 1451.000000) nil) | 12@@list("UCR22" "MX_R0402_SMALL_T01" list(4436.000000 1704.000000) nil) | 12@@list("UCR23" "MX_R0402_SMALL_T01" list(4787.000000 1416.000000) nil) | 12@@list("UCR24" "MX_R0402_SMALL_T01" list(4115.000000 1523.000000) nil) | 12@@list("UCR25" "MX_R0402_SMALL_T01" list(4050.000000 1108.000000) nil) | 12@@list("UCR26" "MX_R0603_SMALL_T01" list(4764.000000 1602.000000) nil) | 12@@list("UCR27" "MX_R0603_SMALL_T01" list(4277.000000 1676.000000) nil) | 12@@list("UCR28" "MX_R0402_SMALL_T01" list(4772.000000 1288.000000) nil) | 12@@list("UCR29" "MX_R0402_SMALL_T01" list(4844.000000 1288.000000) nil) | 12@@list("UCR3" "MX_R0402_SMALL_T01" list(4392.000000 1737.000000) nil) | 12@@list("UCR30" "MX_R0402_SMALL_T01" list(4614.000000 1698.000000) nil) | 12@@list("UCR31" "MX_R0402_SMALL_T01" list(4354.000000 1108.000000) nil) | 12@@list("UCR34" "MX_R0402_SMALL_T01" list(4354.000000 1143.000000) nil) | 12@@list("UCR36" "MX_R0402_SMALL_T01" list(4409.000000 1093.000000) nil) | 12@@list("UCR39" "MX_R0402_SMALL_T01" list(4445.000000 1093.000000) nil) | 12@@list("UCR41" "MX_R0603_SMALL_T01" list(4848.000000 1527.000000) nil) | 12@@list("UCR43" "MX_R0402_SMALL_T01" list(5562.500000 495.500000) nil) | 12@@list("UCR44" "MX_R0402_SMALL_T01" list(5472.800000 435.400000) nil) | 12@@list("UCR45" "MX_R0402_SMALL_T01" list(4202.800000 1139.700000) nil) | 12@@list("UCR46" "MX_R0402_SMALL_T01" list(4629.600000 1113.300000) nil) | 12@@list("UCR47" "MX_R0402_SMALL_T01" list(4596.000000 1113.400000) nil) | 12@@list("UD8869" "MX_SOD123" list(1360.000000 7285.000000) nil) | 12@@list("UD8878" "MX_S0402_AMAZ_COLAY" list(1114.000000 8035.000000) nil) | 12@@list("UD8879" "MX_S0402_AMAZ_COLAY" list(1116.000000 7877.000000) nil) | 12@@list("UD8880" "MX_S0402_AMAZ_COLAY" list(1114.000000 8104.000000) nil) | 12@@list("UD8881" "MX_S0402_AMAZ_COLAY" list(1116.000000 7822.000000) nil) | 12@@list("UF5" "MX_POLYSWITCH_2P_0805_H30" list(2475.000000 450.000000) nil) | 12@@list("UF6" "MX_POLYSWITCH_2P_0805_H30" list(2585.000000 450.000000) nil) | 12@@list("UF7" "MX_POLYSWITCH_2P_0805_H30" list(2736.000000 447.000000) nil) | 12@@list("UL10" "MX_CHOKE_4P_49X39_TAI" list(847.040000 4613.000000) nil) | 12@@list("UL22" "MX_CHOKE_4P_49X39_TAI" list(9128.830000 4046.000000) nil) | 12@@list("UL62" "MX_CHOKE_4P_49X39_TAI" list(552.000000 4713.000000) nil) | 12@@list("UL64" "MX_CHOKE_4P_49X39_TAI" list(9092.000000 4252.000000) nil) | 12@@list("UL65" "MX_CHOKE_4P_49X39_TAI" list(1076.000000 7118.000000) nil) | 12@@list("UL66" "MX_CHOKE_4P_49X39_TAI" list(1076.000000 7177.000000) nil) | 12@@list("UL67" "MX_CHOKE_4P_49X39_TAI" list(1075.000000 7307.000000) nil) | 12@@list("UL68" "MX_CHOKE_4P_49X39_TAI" list(1075.100000 7246.500000) nil) | 12@@list("UL7" "MX_CHOKE_4P_49X39_TAI" list(1196.000000 7757.000000) nil) | 12@@list("UL70" "MX_CHOKE_4P_49X39_TAI" list(9147.000000 5186.000000) nil) | 12@@list("UL74" "MX_CHOKE_4P_49X39_TAI" list(9080.000000 5246.000000) nil) | 12@@list("UL75" "MX_CHOKE_4P_49X39_TAI" list(865.000000 4512.000000) nil) | 12@@list("UL76" "MX_CHOKE_4P_49X39_TAI" list(446.000000 6005.000000) nil) | 12@@list("UL77" "MX_CHOKE_4P_49X39_TAI" list(1075.570000 5425.600000) nil) | 12@@list("UL79" "MX_CHOKE_4P_49X39_TAI" list(1041.000000 5121.950000) nil) | 12@@list("UL8" "MX_CHOKE_4P_49X39_TAI" list(1196.000000 7697.000000) nil) | 12@@list("UL83" "MX_CHOKE_4P_49X39_TAI" list(1041.000000 5245.390000) nil) | 12@@list("UL84" "MX_CHOKE_4P_49X39_TAI" list(1041.000000 5183.750000) nil) | 12@@list("UL86" "MX_CHOKE_4P_49X39_TAI" list(499.170000 5680.000000) nil) | 12@@list("UL88" "MX_CHOKE_4P_49X39_TAI" list(448.000000 5848.000000) nil) | 12@@list("UL9" "MX_CHOKE_4P_49X39_TAI" list(552.040000 4654.000000) nil) | 12@@list("UL90" "MX_CHOKE_4P_49X39_TAI" list(9103.000000 3895.270000) nil) | 12@@list("UL91" "MX_CHOKE_4P_49X39_TAI" list(9178.000000 3809.630000) nil) | 12@@list("UL94" "MX_CHOKE_4P_49X39_TAI" list(9086.000000 5018.000000) nil) | 12@@list("UL95" "MX_CHOKE_4P_49X39_TAI" list(9163.000000 4934.000000) nil) | 12@@list("UR195" "MX_R0402_SMALL_T01" list(1423.000000 7350.000000) nil) | 12@@list("UR30" "MX_R0402_SMALL_T01" list(637.000000 5556.000000) nil) | 12@@list("UR5" "MX_R0402_SMALL_T01" list(8789.000000 4703.000000) nil) | 12@@list("UR6" "MX_R0402_SMALL_T01" list(8876.000000 4605.000000) nil) | 12@@list("UR69686" "MX_R0402_SMALL_T01" list(1557.000000 5440.800000) nil) | 12@@list("UR69692" "MX_R0402_SMALL_T01" list(1423.000000 7210.000000) nil) | 12@@list("UR69695" "MX_R0402_SMALL_T01" list(1723.000000 5466.000000) nil) | 12@@list("UR69703" "MX_R0402_SMALL_T01" list(1606.000000 7603.000000) nil) | 12@@list("UR69704" "MX_R0402_SMALL_T01" list(1642.000000 7603.000000) nil) | 12@@list("UR69705" "MX_R0402_SMALL_T01" list(1271.000000 5943.000000) nil) | 12@@list("UR69710" "MX_R0402_SMALL_T01" list(765.000000 5612.000000) nil) | 12@@list("UR69711" "MX_R0402_SMALL_T01" list(940.000000 8935.000000) nil) | 12@@list("UR69714" "MX_R0402_SMALL_T01" list(8965.500000 5491.000000) nil) | 12@@list("UR69715" "MX_R0402_SMALL_T01" list(8859.000000 4197.000000) nil) | 12@@list("UR69716" "MX_R0402_SMALL_T01" list(8957.000000 4150.000000) nil) | 12@@list("UR69717" "MX_R0402_SMALL_T01" list(8820.000000 5300.000000) nil) | 12@@list("UR69718" "MX_R0402_SMALL_T01" list(8820.000000 5337.000000) nil) | 12@@list("UR69719" "MX_R0402_SMALL_T01" list(815.000000 5597.000000) nil) | 12@@list("UR69720" "MX_R0402_SMALL_T01" list(868.000000 5568.000000) nil) | 12@@list("UR69721" "MX_R0402_SMALL_T01" list(513.000000 5494.000000) nil) | 12@@list("UR69722" "MX_R0402_SMALL_T01" list(513.000000 5458.000000) nil) | 12@@list("UR69723" "MX_R0402_SMALL_T01" list(1446.000000 7900.000000) nil) | 12@@list("UR69724" "MX_R0402_SMALL_T01" list(1482.000000 7900.000000) nil) | 12@@list("UR69725" "MX_R0402_SMALL_T01" list(908.000000 8806.000000) nil) | 12@@list("UR69726" "MX_R0402_SMALL_T01" list(948.000000 8806.000000) nil) | 12@@list("UR69729" "MX_R0402_SMALL_T01" list(8982.000000 5441.000000) nil) | 12@@list("UR69730" "MX_R0402_SMALL_T01" list(8980.500000 5181.190000) nil) | 12@@list("UR69741" "MX_R0402_SMALL_T01" list(8820.000000 4248.000000) nil) | 12@@list("UR69742" "MX_R0402_SMALL_T01" list(9022.000000 4271.000000) nil) | 12@@list("UR69743" "MX_R0402_SMALL_T01" list(8986.000000 4318.000000) nil) | 12@@list("UR69744" "MX_R0402_SMALL_T01" list(8859.500000 4706.000000) nil) | 12@@list("UR69745" "MX_R0402_SMALL_T01" list(8843.000000 4759.000000) nil) | 12@@list("UR69746" "MX_R0402_SMALL_T01" list(8795.170000 4931.000000) nil) | 12@@list("UR69747" "MX_R0402_SMALL_T01" list(9201.000000 5405.000000) nil) | 12@@list("UR69748" "MX_R0402_SMALL_T01" list(9382.000000 3503.000000) nil) | 12@@list("URN10" "MX_2R4P0402" list(847.040000 4613.000000) nil) | 12@@list("URN126" "MX_2R4P0402" list(1196.000000 7697.000000) nil) | 12@@list("URN130" "MX_2R4P0402" list(865.000000 4512.000000) nil) | 12@@list("URN131" "MX_2R4P0402" list(552.000000 4713.000000) nil) | 12@@list("URN134" "MX_2R4P0402" list(1196.000000 7757.000000) nil) | 12@@list("URN137" "MX_2R4P0402" list(1076.000000 7118.000000) nil) | 12@@list("URN138" "MX_2R4P0402" list(1076.000000 7177.000000) nil) | 12@@list("URN139" "MX_2R4P0402" list(1075.000000 7307.000000) nil) | 12@@list("URN140" "MX_2R4P0402" list(1075.100000 7246.500000) nil) | 12@@list("URN143" "MX_2R4P0402" list(9080.000000 5246.000000) nil) | 12@@list("URN144" "MX_2R4P0402" list(9147.000000 5186.000000) nil) | 12@@list("URN148" "MX_2R4P0402" list(446.000000 6005.000000) nil) | 12@@list("URN149" "MX_2R4P0402" list(1075.570000 5425.600000) nil) | 12@@list("URN151" "MX_2R4P0402" list(1041.000000 5121.950000) nil) | 12@@list("URN155" "MX_2R4P0402" list(1041.000000 5245.390000) nil) | 12@@list("URN156" "MX_2R4P0402" list(1041.000000 5183.750000) nil) | 12@@list("URN159" "MX_2R4P0402" list(499.170000 5680.000000) nil) | 12@@list("URN161" "MX_2R4P0402" list(448.000000 5848.000000) nil) | 12@@list("URN163" "MX_2R4P0402" list(9103.000000 3895.270000) nil) | 12@@list("URN164" "MX_2R4P0402" list(9178.000000 3809.630000) nil) | 12@@list("URN167" "MX_2R4P0402" list(9086.000000 5018.000000) nil) | 12@@list("URN168" "MX_2R4P0402" list(9163.000000 4934.000000) nil) | 12@@list("URN60" "MX_2R4P0402" list(9092.000000 4252.000000) nil) | 12@@list("URN62" "MX_2R4P0402" list(9128.830000 4046.000000) nil) | 12@@list("URN9" "MX_2R4P0402" list(552.040000 4654.000000) nil) | 12@@list("UU14" "MX_ESD_10P_20_98X39_NXP" list(950.000000 4943.000000) nil) | 12@@list("UU22" "MX_ESD_10P_20_98X39_NXP" list(9186.500000 3560.000000) nil) | 12@@list("UU26" "MX_ESD_10P_20_98X39_NXP" list(9185.000000 3930.000000) nil) | 12@@list("UU4" "MX_ESD_10P_20_98X39_NXP" list(9164.000000 4161.000000) nil) | 12@@list("UU40" "MX_ESD_10P_20_98X39_NXP" list(950.000000 5207.000000) nil) | 12@@list("UU43" "MX_ESD_10P_20_98X39_NXP" list(9186.500000 4745.000000) nil) | 12@@list("UU44" "MX_ESD_10P_20_98X39_NXP" list(9182.000000 5046.000000) nil) | 12@@list("UU45" "MX_SOT23_S5_H57" list(527.000000 5581.000000) nil) | 12@@list("UU47" "MX_SOT23_S5_H57" list(816.000000 8877.000000) nil) | 12@@list("UU5" "MX_ESD_10P_20_98X39_NXP" list(9171.000000 5301.000000) nil) | 12@@list("UU50" "MX_SOT23_S5_H57" list(747.000000 5510.000000) nil) | 12@@list("UU51" "MX_SOT23_S5_H57" list(8928.000000 5295.000000) nil) | 12@@list("UU52" "MX_ESD_10P_20_98X39_NXP" list(344.000000 6034.000000) nil) | 12@@list("UU53" "MX_ESD_10P_20_98X39_NXP" list(950.000000 5083.000000) nil) | 12@@list("UU54" "MX_SOT23_S5_2D4_122X67_H35" list(1405.000000 6395.000000) nil) | 12@@list("VCB155" "MX_C0402_SMALL_T01" list(1034.000000 6632.600000) nil) | 12@@list("X1" "MX_XTAL_4P_126X98_HELE_H31" list(1287.000000 5323.000000) nil) | 12@@list("XC1" "MX_C0402_SMALL_T01" list(2464.000000 3410.000000) nil) | 12@@list("XC10" "MX_C0402_SMALL_T01" list(3109.000000 3410.000000) nil) | 12@@list("XC11" "MX_C0402_SMALL_T01" list(3305.000000 3410.000000) nil) | 12@@list("XC112" "MX_C0402_SMALL_T01" list(2441.000000 1015.000000) nil) | 12@@list("XC113" "MX_C0402_SMALL_T01" list(2405.000000 1015.000000) nil) | 12@@list("XC114" "MX_C0402_SMALL_T01" list(2591.000000 1015.000000) nil) | 12@@list("XC115" "MX_C0402_SMALL_T01" list(2555.000000 1015.000000) nil) | 12@@list("XC116" "MX_C0402_SMALL_T01" list(2751.000000 1015.000000) nil) | 12@@list("XC117" "MX_C0402_SMALL_T01" list(2715.000000 1015.000000) nil) | 12@@list("XC118" "MX_C0402_SMALL_T01" list(2911.000000 1015.000000) nil) | 12@@list("XC119" "MX_C0402_SMALL_T01" list(2875.000000 1015.000000) nil) | 12@@list("XC12" "MX_C0402_SMALL_T01" list(3269.000000 3410.000000) nil) | 12@@list("XC120" "MX_C0402_SMALL_T01" list(3151.000000 1015.000000) nil) | 12@@list("XC121" "MX_C0402_SMALL_T01" list(3115.000000 1015.000000) nil) | 12@@list("XC122" "MX_C0402_SMALL_T01" list(3306.000000 1015.000000) nil) | 12@@list("XC123" "MX_C0402_SMALL_T01" list(3270.000000 1015.000000) nil) | 12@@list("XC124" "MX_C0402_SMALL_T01" list(3430.000000 1015.000000) nil) | 12@@list("XC125" "MX_C0402_SMALL_T01" list(3466.000000 1015.000000) nil) | 12@@list("XC126" "MX_C0402_SMALL_T01" list(3615.000000 1015.000000) nil) | 12@@list("XC127" "MX_C0402_SMALL_T01" list(3579.000000 1015.000000) nil) | 12@@list("XC128" "MX_C0402_SMALL_T01" list(2353.500000 1864.500000) nil) | 12@@list("XC129" "MX_C0402_SMALL_T01" list(2770.000000 3785.000000) nil) | 12@@list("XC13" "MX_C0402_SMALL_T01" list(3460.000000 3410.000000) nil) | 12@@list("XC130" "MX_C0402_SMALL_T01" list(2770.000000 3745.000000) nil) | 12@@list("XC131" "MX_C0402_SMALL_T01" list(2232.000000 3018.000000) nil) | 12@@list("XC14" "MX_C0402_SMALL_T01" list(3424.000000 3410.000000) nil) | 12@@list("XC15" "MX_C0402_SMALL_T01" list(3620.000000 3410.000000) nil) | 12@@list("XC16" "MX_C0402_SMALL_T01" list(3584.000000 3410.000000) nil) | 12@@list("XC2" "MX_C0402_SMALL_T01" list(2428.000000 3410.000000) nil) | 12@@list("XC3" "MX_C0402_SMALL_T01" list(2595.000000 3410.000000) nil) | 12@@list("XC33" "MX_C0402_SMALL_T01" list(2198.000000 2605.000000) nil) | 12@@list("XC35" "MX_C0402_SMALL_T01" list(2295.000000 3395.000000) nil) | 12@@list("XC4" "MX_C0402_SMALL_T01" list(2559.000000 3410.000000) nil) | 12@@list("XC5" "MX_C0402_SMALL_T01" list(2750.000000 3410.000000) nil) | 12@@list("XC6" "MX_C0402_SMALL_T01" list(2714.000000 3410.000000) nil) | 12@@list("XC7" "MX_C0402_SMALL_T01" list(2910.000000 3410.000000) nil) | 12@@list("XC8" "MX_C0402_SMALL_T01" list(2874.000000 3410.000000) nil) | 12@@list("XC9" "MX_C0402_SMALL_T01" list(3145.000000 3410.000000) nil) | 12@@list("XC92" "MX_C0402_SMALL_T01" list(2236.000000 1032.000000) nil) | 12@@list("XC95" "MX_C0402_SMALL_T01" list(1670.000000 1000.000000) nil) | 12@@list("XCE14" "MX_C0402_SMALL_T01" list(2770.000000 3680.000000) nil) | 12@@list("XDP2" "BTOB_60P_20_F_SAMT" list(3692.940000 4195.040000) nil) | 12@@list("XR1" "MX_R0402_SMALL_T01" list(2064.000000 2620.000000) nil) | 12@@list("XR10" "MX_R0402_SMALL_T01" list(1887.000000 3016.000000) nil) | 12@@list("XR11" "MX_R0402_SMALL_T01" list(1773.000000 3399.000000) nil) | 12@@list("XR12" "MX_R0402_SMALL_T01" list(2055.000000 1020.000000) nil) | 12@@list("XR13" "MX_R0402_SMALL_T01" list(2114.000000 553.000000) nil) | 12@@list("XR14" "MX_R0402_SMALL_T01" list(1945.000000 1005.000000) nil) | 12@@list("XR15" "MX_R0402_SMALL_T01" list(1805.000000 1005.000000) nil) | 12@@list("XR16" "MX_R0402_SMALL_T01" list(2000.000000 1020.000000) nil) | 12@@list("XR17" "MX_R0402_SMALL_T01" list(2012.000000 1821.000000) nil) | 12@@list("XR18" "MX_R0402_SMALL_T01" list(1976.000000 1821.000000) nil) | 12@@list("XR19" "MX_R0402_SMALL_T01" list(2255.000000 1370.000000) nil) | 12@@list("XR2" "MX_R0402_SMALL_T01" list(2100.000000 2620.000000) nil) | 12@@list("XR20" "MX_R0402_SMALL_T01" list(1940.000000 1821.000000) nil) | 12@@list("XR3" "MX_R0402_SMALL_T01" list(2238.000000 2180.000000) nil) | 12@@list("XR4" "MX_R0402_SMALL_T01" list(2024.000000 2620.000000) nil) | 12@@list("XR5" "MX_R0402_SMALL_T01" list(2155.000000 3020.000000) nil) | 12@@list("XR8" "MX_R0402_SMALL_T01" list(2040.000000 3401.000000) nil) | 12@@list("XR9" "MX_R0402_SMALL_T01" list(2106.000000 3401.000000) nil) | 12@@list("XU1" "MX_SOCKET1151_FOXN_7HD" list(4939.170000 6356.660000) nil) | 12@@list("Y10" "MX_XTAL_4P_126X98_HOSON_H35" list(1223.000000 8853.000000) nil) | 12@@list("Y18" "MX_XTAL_4P_126X98_HELE" list(5870.000000 2458.000000) nil) | 12@@list("Y19" "MX_XTAL_4P_126X98_HELE" list(4591.000000 1788.000000) nil) | 12@@list("Y5" "MX_XTAL_4P_272X55" list(5796.000000 1181.000000) nil) | 13@@list("AC1" "MX_C0201" list(895.000000 762.000000) nil) | 13@@list("AC14" "MX_C0201" list(908.000000 685.000000) nil) | 13@@list("AC17" "MX_C0201" list(540.000000 330.000000) nil) | 13@@list("AC187" "MX_C0201" list(555.000000 8920.000000) nil) | 13@@list("AC19" "MX_C0201" list(355.000000 745.000000) nil) | 13@@list("AC2" "MX_C0201" list(895.000000 798.000000) nil) | 13@@list("AC21" "MX_C0201" list(875.000000 475.000000) nil) | 13@@list("AC39" "MX_C0201" list(8507.000000 868.000000) nil) | 13@@list("AC4" "MX_C0201" list(375.000000 580.000000) nil) | 13@@list("C93" "MX_C0201" list(5425.920000 596.400000) nil) | 13@@list("C9357" "MX_C0201" list(8796.000000 4041.000000) nil) | 13@@list("C941399" "MX_C0201" list(8723.000000 4600.000000) nil) | 13@@list("C941400" "MX_C0201" list(9042.000000 4097.000000) nil) | 13@@list("C941401" "MX_C0201" list(9067.000000 4558.000000) nil) | 13@@list("CB4107" "MX_C0201" list(618.000000 5494.000000) nil) | 13@@list("CB4112" "MX_C0201" list(638.000000 5630.000000) nil) | 13@@list("CB4113" "MX_C0201" list(729.000000 5614.000000) nil) | 13@@list("CB4114" "MX_C0201" list(618.000000 5458.000000) nil) | 13@@list("CB4115" "MX_C0201" list(904.000000 8935.000000) nil) | 13@@list("CB4116" "MX_C0201" list(726.000000 8968.000000) nil) | 13@@list("CB4117" "MX_C0201" list(585.000000 8520.000000) nil) | 13@@list("CB4123" "MX_C0201" list(8868.000000 5406.000000) nil) | 13@@list("CB4124" "MX_C0201" list(9207.000000 4567.000000) nil) | 13@@list("CB4125" "MX_C0201" list(1706.000000 8130.000000) nil) | 13@@list("CB4126" "MX_C0201" list(1515.000000 6415.000000) nil) | 13@@list("CB4127" "MX_C0201" list(944.000000 5643.000000) nil) | 13@@list("D4C12" "MX_C0201" list(8145.000000 4235.000000) nil) | 13@@list("D4C13" "MX_C0201" list(8145.000000 9055.000000) nil) | 13@@list("D4C17" "MX_C0201" list(8181.000000 4235.000000) nil) | 13@@list("D4C18" "MX_C0201" list(8195.000000 9040.000000) nil) | 13@@list("D4C2" "MX_C0201" list(6875.000000 4195.000000) nil) | 13@@list("D4C3" "MX_C0201" list(6830.000000 9050.000000) nil) | 13@@list("D4C7" "MX_C0201" list(7505.000000 4200.000000) nil) | 13@@list("D4C8" "MX_C0201" list(7505.000000 9080.000000) nil) | 13@@list("D4CB10" "MX_C0201" list(7513.000000 6535.000000) nil) | 13@@list("D4CB11" "MX_C0201" list(8181.000000 4165.000000) nil) | 13@@list("D4CB12" "MX_C0201" list(8145.000000 4165.000000) nil) | 13@@list("D4CB14" "MX_C0201" list(8146.000000 6480.000000) nil) | 13@@list("D4CB15" "MX_C0201" list(8265.000000 4325.000000) nil) | 13@@list("D4CB16" "MX_C0201" list(8367.000000 4394.000000) nil) | 13@@list("D4CB2" "MX_C0201" list(6872.000000 6490.000000) nil) | 13@@list("D4CB25" "MX_C0201" list(8217.000000 6330.000000) nil) | 13@@list("D4CB3" "MX_C0201" list(6789.000000 3987.000000) nil) | 13@@list("D4CB4" "MX_C0201" list(6833.000000 3987.000000) nil) | 13@@list("D4CB57" "MX_C0201" list(8181.000000 6330.000000) nil) | 13@@list("D4CB58" "MX_C0201" list(7511.000000 7375.000000) nil) | 13@@list("D4CB59" "MX_C0201" list(8289.000000 6330.000000) nil) | 13@@list("D4CB6" "MX_C0201" list(8176.000000 6180.000000) nil) | 13@@list("D4CB60" "MX_C0201" list(7510.000000 5780.000000) nil) | 13@@list("D4CB61" "MX_C0201" list(8220.000000 6480.000000) nil) | 13@@list("D4CB62" "MX_C0201" list(7513.000000 7108.000000) nil) | 13@@list("D4CB64" "MX_C0201" list(6717.000000 7145.000000) nil) | 13@@list("D4CB65" "MX_C0201" list(8253.000000 6330.000000) nil) | 13@@list("D4CB69" "MX_C0201" list(8156.000000 6628.000000) nil) | 13@@list("D4CB7" "MX_C0201" list(7511.000000 4070.000000) nil) | 13@@list("D4CB70" "MX_C0201" list(7510.000000 5860.000000) nil) | 13@@list("D4CB72" "MX_C0201" list(7511.000000 5180.000000) nil) | 13@@list("D4CB73" "MX_C0201" list(7510.000000 5590.000000) nil) | 13@@list("D4CB74" "MX_C0201" list(7510.000000 6942.000000) nil) | 13@@list("D4CB75" "MX_C0201" list(8170.000000 6841.000000) nil) | 13@@list("D4CB76" "MX_C0201" list(7510.000000 8839.000000) nil) | 13@@list("D4CB77" "MX_C0201" list(7509.000000 5933.000000) nil) | 13@@list("D4CB78" "MX_C0201" list(6850.000000 6660.000000) nil) | 13@@list("D4CB8" "MX_C0201" list(7510.000000 3985.000000) nil) | 13@@list("EC22" "MX_C0201" list(9065.000000 6755.000000) nil) | 13@@list("F3CB4" "MX_C0201" list(6985.000000 435.000000) nil) | 13@@list("LCB10" "MX_C0201" list(1602.000000 8432.000000) nil) | 13@@list("LCB12" "MX_C0201" list(1315.000000 8275.000000) nil) | 13@@list("LCB14" "MX_C0201" list(1210.000000 8395.000000) nil) | 13@@list("LCB17" "MX_C0201" list(1574.000000 8676.000000) nil) | 13@@list("LCB20" "MX_C0201" list(1315.000000 8315.000000) nil) | 13@@list("LCB21" "MX_C0201" list(1556.000000 8561.000000) nil) | 13@@list("LCB4" "MX_C0201" list(1223.000000 8485.000000) nil) | 13@@list("LCB6" "MX_C0201" list(1515.000000 8336.000000) nil) | 13@@list("LCB7" "MX_C0201" list(1374.000000 8680.000000) nil) | 13@@list("LCB9" "MX_C0201" list(1515.000000 8300.000000) nil) | 13@@list("M1C1" "MX_C0201" list(513.000000 6907.000000) nil) | 13@@list("M1C35" "MX_C0201" list(770.000000 6690.000000) nil) | 13@@list("M2C14" "MX_C0201" list(8816.000000 784.210000) nil) | 13@@list("M2C17" "MX_C0201" list(8921.790000 783.960000) nil) | 13@@list("M2C2" "MX_C0201" list(982.000000 4598.000000) nil) | 13@@list("M2C20" "MX_C0201" list(8112.000000 695.000000) nil) | 13@@list("M2C5" "MX_C0201" list(1922.000000 4598.000000) nil) | 13@@list("O2CB1" "MX_C0201" list(8040.000000 1167.000000) nil) | 13@@list("O2CB10" "MX_C0201" list(8671.000000 865.000000) nil) | 13@@list("O2CB11" "MX_C0201" list(8635.000000 870.000000) nil) | 13@@list("O2CB16" "MX_C0201" list(8834.000000 870.000000) nil) | 13@@list("O2CB17" "MX_C0201" list(8540.000000 1705.000000) nil) | 13@@list("O2CB19" "MX_C0201" list(8950.000000 1283.000000) nil) | 13@@list("O2CB2" "MX_C0201" list(8870.000000 870.000000) nil) | 13@@list("O2CB20" "MX_C0201" list(8889.000000 1235.000000) nil) | 13@@list("O2CB3" "MX_C0201" list(8764.000000 1655.000000) nil) | 13@@list("O2CB4" "MX_C0201" list(8853.000000 1235.000000) nil) | 13@@list("O2CB5" "MX_C0201" list(8877.140000 1458.730000) nil) | 13@@list("O2CB6" "MX_C0201" list(8877.140000 1494.730000) nil) | 13@@list("O2CB7" "MX_C0201" list(8580.000000 870.000000) nil) | 13@@list("O2CB8" "MX_C0201" list(8181.000000 868.000000) nil) | 13@@list("P1CB2" "MX_C0201" list(9029.000000 7335.000000) nil) | 13@@list("P1CB3" "MX_C0201" list(9050.000000 7915.000000) nil) | 13@@list("P1CB4" "MX_C0201" list(9042.000000 5954.000000) nil) | 13@@list("PC13" "MX_C0201" list(2178.000000 4790.000000) nil) | 13@@list("PC231" "MX_C0201" list(9062.000000 6320.000000) nil) | 13@@list("PC234" "MX_C0201" list(8905.000000 7700.000000) nil) | 13@@list("PC238" "MX_C0201" list(9065.000000 7335.000000) nil) | 13@@list("PC569" "MX_C0201" list(4579.000000 2210.000000) nil) | 13@@list("PC570" "MX_C0201" list(4616.000000 2210.000000) nil) | 13@@list("PC5801" "MX_C0201" list(2860.000000 8240.000000) nil) | 13@@list("PC5804" "MX_C0201" list(2995.000000 8215.000000) nil) | 13@@list("PC5806" "MX_C0201" list(2788.000000 8405.000000) nil) | 13@@list("PC5808" "MX_C0201" list(2988.000000 9005.000000) nil) | 13@@list("PC5810" "MX_C0201" list(3096.000000 9005.000000) nil) | 13@@list("PC5812" "MX_C0201" list(3036.000000 8217.000000) nil) | 13@@list("PC5814" "MX_C0201" list(3559.000000 8755.000000) nil) | 13@@list("PC5825" "C0201" list(2793.000000 8550.000000) nil) | 13@@list("PC5826" "C0201" list(2865.000000 8940.000000) nil) | 13@@list("PC640681" "MX_C0201" list(2020.000000 5158.000000) nil) | 13@@list("PU10" "MX_DFN_10P_20_S118_PAD_R_4V" list(2725.000000 4790.000000) nil) | 13@@list("PU591" "MX_DFN_8P_20_79X79_PAD_RIC" list(2782.420000 7344.710000) nil) | 13@@list("PU592" "MX_DFN_8P_20_79X79_PAD_RIC" list(2638.100000 8073.710000) nil) | 13@@list("PU601" "MX_DFN_8P_20_79X79_PAD_RIC" list(2777.180000 6661.710000) nil) | 13@@list("PU602" "MX_DFN_8P_20_79X79_PAD_RIC" list(2806.860000 5989.710000) nil) | 13@@list("PU611" "MX_DFN_8P_20_79X79_PAD_RIC" list(3758.000000 8955.000000) nil) | 13@@list("PU612" "MX_DFN_8P_20_79X79_PAD_RIC" list(5816.340000 8998.710000) nil) | 13@@list("PU651" "MX_DFN_10P_20_S118_PAD_R_4V" list(8400.000000 8700.000000) nil) | 13@@list("PU7" "MX_DFN_10P_20_S118_PAD_R_4V" list(8340.000000 4940.000000) nil) | 13@@list("PU9" "MX_DFN_10P_20_S118_PAD_R_4V" list(7583.000000 3596.000000) nil) | 13@@list("SC100" "MX_C0201" list(5302.800000 2430.100000) nil) | 13@@list("SC174" "MX_C0201" list(6285.000000 1235.000000) nil) | 13@@list("SCB10" "MX_C0201" list(6185.600000 1317.080000) nil) | 13@@list("SCB118" "MX_C0201" list(6368.500000 966.000000) nil) | 13@@list("SCB28" "MX_C0201" list(6013.000000 1065.000000) nil) | 13@@list("SCB29" "MX_C0201" list(6748.000000 954.000000) nil) | 13@@list("SCB36" "MX_C0201" list(6968.660000 1192.940000) nil) | 13@@list("SR653" "MX_C0201" list(6030.000000 1320.000000) nil) | 13@@list("U10" "A_QFN_40P_16_201X201_PA" list(1377.000000 8489.000000) nil) | 13@@list("U4" "MX_QFN_64P_20_S354_P_MA_12V" list(1447.470000 5684.090000) nil) | 13@@list("U51" "MX_QFN_16P_20_S118_PAD_RIC" list(8910.810000 4009.840000) nil) | 13@@list("U942691" "MX_QFN_16P_20_S118_PAD_RIC" list(8836.810000 4477.520000) nil) | 13@@list("UC72" "MX_C0201" list(1520.000000 5941.000000) nil) | 13@@list("UC74" "MX_C0201" list(1664.000000 5557.000000) nil) | 13@@list("UC75" "MX_C0201" list(1431.000000 5959.000000) nil) | 13@@list("UC94" "MX_C0201" list(1500.000000 7504.000000) nil) | 13@@list("UC965" "MX_C0201" list(905.000000 5825.000000) nil) | 13@@list("UCB18" "MX_C0201" list(2435.000000 355.000000) nil) | 13@@list("UCB19" "MX_C0201" list(2595.000000 355.000000) nil) | 13@@list("UCB23" "MX_C0201" list(326.000000 5467.000000) nil) | 13@@list("UCB24" "MX_C0201" list(899.000000 5470.000000) nil) | 13@@list("UCB25" "MX_C0201" list(1017.000000 7624.000000) nil) | 13@@list("UCB26" "MX_C0201" list(2733.000000 355.000000) nil) | 13@@list("UCB9" "MX_C0201" list(977.000000 7624.000000) nil) | 13@@list("UCC11" "MX_C0201" list(3978.000000 1490.000000) nil) | 13@@list("UCC3" "MX_C0201" list(4468.600000 1658.000000) nil) | 13@@list("UCC4" "MX_C0201" list(4238.000000 1224.000000) nil) | 13@@list("UCC5" "MX_C0201" list(4610.700000 1173.800000) nil) | 13@@list("UCC6" "MX_C0201" list(4744.000000 1508.000000) nil) | 13@@list("UCC7" "MX_C0201" list(4685.000000 1640.000000) nil) | 13@@list("UU10" "A_DFN_10P_20_98X39_ONSEM" list(350.000000 5907.000000) nil) | 13@@list("UU34" "A_DFN_10P_20_98X39_ONSEM" list(410.000000 5708.000000) nil) | 13@@list("UU39" "A_DFN_10P_20_98X39_ONSEM" list(951.000000 5330.000000) nil) | 13@@list("XC89" "MX_C0201" list(2255.000000 2979.000000) nil) | 13@@list("XC90" "MX_C0201" list(1670.000000 3025.000000) nil) | 13@@list("XC91" "MX_C0201" list(2089.000000 3020.000000) nil) | 13@@list("XC93" "MX_C0201" list(2151.000000 553.000000) nil) | 13@@list("XC94" "MX_C0201" list(2077.000000 554.000000) nil) | 13@@list("XCB5" "MX_C0201" list(1963.000000 2168.000000) nil) | 13@@list("XCB6" "MX_C0201" list(2165.000000 1375.000000) nil) | 14@@list("PU581" "MX_QFN_56P_16_S236_PAD_4V" list(3096.040000 8611.280000) nil) | 14@@list("U104" "MX_QFP_128P_16_S630_H47" list(8470.040000 1285.120000) nil) | 14@@list("U5" "MX_QFN_32P_16_S161_PD_8V" list(740.000000 5825.000000) nil) | 15@@list("" "INDEXB_CROSS" list(1006.000000 9188.000000) t) | 15@@list("" "INDEXB_CROSS" list(8465.000000 395.000000) t) | 15@@list("" "INDEXB_CROSS" list(8950.000000 9369.000000) t) | 15@@list("H1" "MX_HOLE_160_T_U_HP" list(1299.980000 9350.000000) nil) | 15@@list("H2" "MX_HOLE_160_T_R_HP" list(9350.000000 3150.000000) nil) | 15@@list("H3" "MX_HOLE_160_T_U_HP" list(6500.000000 9350.000000) nil) | 15@@list("H4" "MX_HOLE_160_T_HP" list(6500.000000 3150.000000) nil) | 15@@list("H5" "MX_HOLE_160_T_HP" list(6500.000000 550.000000) nil) | 15@@list("H6" "MX_H_C315D189N_M2_P2_V8" list(9350.000000 9350.000000) nil) | 15@@list("H7" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 1350.000000) nil) | 15@@list("H8" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 3150.000000) nil) | 15@@list("HT34" "MX_TPC26T_S4_68" list(5300.000000 8194.000000) t) | 15@@list("HT45" "MX_TPC26T_S4_68" list(2995.000000 4415.000000) t) | 15@@list("HT46" "MX_TPC26T_S4_68" list(3102.000000 4426.000000) t) | 15@@list("HT47" "MX_TPC26T_S4_68" list(3057.000000 4366.000000) t) | 15@@list("HT48" "MX_TPC26T_S4_68" list(2998.000000 4326.000000) t) | 15@@list("HT49" "MX_TPC26T_S4_68" list(3075.000000 4260.000000) t) | 15@@list("HT50" "MX_TPC26T_S4_68" list(2928.000000 4313.000000) t) | 15@@list("HT51" "MX_TPC26T_S4_68" list(2889.800000 4389.000000) t) | 15@@list("HT56" "MX_TPC26T_S4_68" list(4603.400000 5869.100000) t) | 15@@list("PC1" "MX_C0603_SMALL_T02" list(4900.000000 6320.000000) t) | 15@@list("PC11" "MX_C0603_SMALL_T02" list(4939.520000 6735.000000) t) | 15@@list("PC12" "MX_C0603_SMALL_T02" list(4834.760000 6680.000000) t) | 15@@list("PC2" "MX_C0603_SMALL_T02" list(4780.000000 6321.000000) t) | 15@@list("PC3" "MX_C0603_SMALL_T02" list(4713.000000 6174.000000) t) | 15@@list("PC332" "MX_C0603_SMALL_T02" list(4909.000000 6086.000000) t) | 15@@list("PC333" "MX_C0603_SMALL_T02" list(4909.000000 6141.000000) t) | 15@@list("PC334" "MX_C0603_SMALL_T02" list(5050.000000 6115.000000) t) | 15@@list("PC335" "MX_C0603_SMALL_T02" list(5047.000000 6020.000000) t) | 15@@list("PC5" "MX_C0603_SMALL_T02" list(4990.000000 6320.000000) t) | 15@@list("PC6" "MX_C0603_SMALL_T02" list(4765.000000 6174.000000) t) | 15@@list("PC7" "MX_C0603_SMALL_T02" list(4939.520000 6626.000000) t) | 15@@list("PC8" "MX_C0603_SMALL_T02" list(4939.520000 6680.000000) t) | 15@@list("PC9" "MX_C0603_SMALL_T02" list(4834.760000 6735.000000) t) | 15@@list("PT1" "MX_TPC26T_S4_68" list(9170.000000 8005.000000) t) | 15@@list("PT10" "MX_TPC26T_S4_68" list(9132.000000 8323.000000) t) | 15@@list("PT11" "MX_TPC26T_S4_68" list(9385.000000 8159.000000) t) | 15@@list("PT12" "MX_TPC26T_S4_68" list(9385.000000 8231.000000) t) | 15@@list("PT13" "MX_TPC26T_S4_68" list(8819.000000 7616.000000) t) | 15@@list("PT14" "MX_TPC26T_S4_68" list(8759.780000 6847.220000) t) | 15@@list("PT15" "MX_TPC26T_S4_68" list(9375.000000 8085.000000) t) | 15@@list("PT2" "MX_TPC26T_S4_68" list(9176.000000 8156.000000) t) | 15@@list("PT21" "MX_TPC26T_S4_68" list(6203.700000 790.800000) t) | 15@@list("PT22" "MX_TPC26T_S4_68" list(7205.000000 1273.500000) t) | 15@@list("PT23" "MX_TPC26T_S4_68" list(5213.000000 552.000000) t) | 15@@list("PT24" "MX_TPC26T_S4_68" list(7327.000000 1310.000000) t) | 15@@list("PT25" "MX_TPC26T_S4_68" list(7402.000000 1310.000000) t) | 15@@list("PT26" "MX_TPC26T_S4_68" list(8232.400000 7530.900000) t) | 15@@list("PT265" "MX_TPC26T_S4_68" list(2457.000000 3676.000000) t) | 15@@list("PT266" "MX_TPC26T_S4_68" list(2692.000000 3745.000000) t) | 15@@list("PT267" "MX_TPC26T_S4_68" list(2614.000000 3736.000000) t) | 15@@list("PT268" "MX_TPC26T_S4_68" list(2516.000000 3728.000000) t) | 15@@list("PT269" "MX_TPC26T_S4_68" list(2742.000000 3802.000000) t) | 15@@list("PT27" "MX_TPC26T_S4_68" list(8237.000000 8078.300000) t) | 15@@list("PT270" "MX_TPC26T_S4_68" list(2638.000000 3812.000000) t) | 15@@list("PT271" "MX_TPC26T_S4_68" list(2469.000000 3805.000000) t) | 15@@list("PT272" "MX_TPC26T_S4_68" list(2432.000000 3741.000000) t) | 15@@list("PT273" "MX_TPC26T_S4_68" list(2397.000000 3801.000000) t) | 15@@list("PT274" "MX_TPC26T_S4_68" list(2545.000000 3802.000000) t) | 15@@list("PT28" "MX_TPC26T_S4_68" list(8225.000000 7945.000000) t) | 15@@list("PT29" "MX_TPC26T_S4_68" list(8223.900000 7664.600000) t) | 15@@list("PT3" "MX_TPC26T_S4_68" list(9173.000000 8085.000000) t) | 15@@list("PT30" "MX_TPC26T_S4_68" list(8248.000000 7396.000000) t) | 15@@list("PT31" "MX_TPC26T_S4_68" list(2314.000000 6114.000000) t) | 15@@list("PT32" "MX_TPC26T_S4_68" list(2332.000000 5440.000000) t) | 15@@list("PT33" "MX_TPC26T_S4_68" list(2571.000000 7496.000000) t) | 15@@list("PT34" "MX_TPC26T_S4_68" list(2217.000000 7578.000000) t) | 15@@list("PT35" "MX_TPC26T_S4_68" list(2534.000000 5493.000000) t) | 15@@list("PT36" "MX_TPC26T_S4_68" list(2585.000000 5403.000000) t) | 15@@list("PT37" "MX_TPC26T_S4_68" list(2455.000000 6885.000000) t) | 15@@list("PT38" "MX_TPC26T_S4_68" list(2577.000000 6798.000000) t) | 15@@list("PT39" "MX_TPC26T_S4_68" list(2360.000000 6815.000000) t) | 15@@list("PT4" "MX_TPC26T_S4_68" list(1790.000000 8782.000000) t) | 15@@list("PT40" "MX_TPC26T_S4_68" list(2528.000000 6102.000000) t) | 15@@list("PT41" "MX_TPC26T_S4_68" list(3305.000000 6020.000000) t) | 15@@list("PT42" "MX_TPC26T_S4_68" list(3320.000000 6675.000000) t) | 15@@list("PT43" "MX_TPC26T_S4_68" list(3375.000000 6515.000000) t) | 15@@list("PT44" "MX_TPC26T_S4_68" list(3405.000000 6670.000000) t) | 15@@list("PT45" "MX_TPC26T_S4_68" list(3400.000000 6760.000000) t) | 15@@list("PT46" "MX_TPC26T_S4_68" list(3434.000000 6985.000000) t) | 15@@list("PT47" "MX_TPC26T_S4_68" list(3395.000000 5980.000000) t) | 15@@list("PT48" "MX_TPC26T_S4_68" list(3510.000000 6010.000000) t) | 15@@list("PT49" "MX_TPC26T_S4_68" list(3407.000000 6354.000000) t) | 15@@list("PT5" "MX_TPC26T_S4_68" list(1805.000000 9006.000000) t) | 15@@list("PT50" "MX_TPC26T_S4_68" list(3235.000000 5815.000000) t) | 15@@list("PT51" "MX_TPC26T_S4_68" list(2373.000000 8638.000000) t) | 15@@list("PT52" "MX_TPC26T_S4_68" list(2044.000000 8079.000000) t) | 15@@list("PT53" "MX_TPC26T_S4_68" list(2088.000000 6184.000000) t) | 15@@list("PT54" "MX_TPC26T_S4_68" list(1975.000000 7208.000000) t) | 15@@list("PT55" "MX_TPC26T_S4_68" list(2034.000000 5957.000000) t) | 15@@list("PT56" "MX_TPC26T_S4_68" list(2136.000000 5368.000000) t) | 15@@list("PT57" "MX_TPC26T_S4_68" list(1984.000000 6376.000000) t) | 15@@list("PT58" "MX_TPC26T_S4_68" list(2016.000000 5560.000000) t) | 15@@list("PT59" "MX_TPC26T_S4_68" list(1958.000000 6631.000000) t) | 15@@list("PT6" "MX_TPC26T_S4_68" list(9145.000000 5630.000000) t) | 15@@list("PT60" "MX_TPC26T_S4_68" list(1979.000000 7542.000000) t) | 15@@list("PT7" "MX_TPC26T_S4_68" list(9145.000000 5553.000000) t) | 15@@list("PT8" "MX_TPC26T_S4_68" list(9145.000000 5704.000000) t) | 15@@list("PT9" "MX_TPC26T_S4_68" list(8734.000000 5716.000000) t) | 15@@list("ST1" "MX_TPC26T_S4_68" list(6476.000000 1700.000000) t) | 15@@list("ST106" "MX_TPC26T_S4_68" list(6372.100000 1443.600000) t) | 15@@list("ST128" "MX_TPC26T_S4_68" list(6248.000000 1443.000000) t) | 15@@list("ST147" "MX_TPC26T_S4_68" list(6592.500000 1364.000000) t) | 15@@list("ST154" "MX_TPC26T_S4_68" list(6447.000000 1293.000000) t) | 15@@list("ST156" "MX_TPC26T_S4_68" list(6709.000000 1357.000000) t) | 15@@list("ST36" "MX_TPC26T_S4_68" list(6600.000000 1808.000000) t) | 15@@list("ST37" "MX_TPC26T_S4_68" list(6687.000000 1723.000000) t) | 15@@list("ST76" "MX_TPC26T_S4_68" list(1539.000000 5809.000000) t) | 15@@list("ST77" "MX_TPC26T_S4_68" list(1479.000000 5842.000000) t) | 18@@list("PD1" "MX_SMA" list(2010.000000 9245.000000) nil) | 18@@list("PD2" "MX_SMA" list(2010.000000 9380.000000) nil) | 18@@list("PD3" "MX_SMA" list(3553.260000 3828.040000) nil) | 18@@list("XU1" "MX_SOCKET1151_FOXN_7HD" list(4939.170000 6356.660000) nil) | 1@@list("" "INDEXB_CROSS" list(1273.000000 661.000000) nil) | 1@@list("" "INDEXB_CROSS" list(704.000000 9363.000000) nil) | 1@@list("" "INDEXB_CROSS" list(9035.000000 1014.000000) nil) | 1@@list("AD1" "MX_SOT23_2D4_H43" list(923.000000 222.000000) nil) | 1@@list("AMB_Q1" "MX_SOT23" list(8964.000000 3027.000000) nil) | 1@@list("AQ1" "MX_SOT363_PHILIPS" list(615.000000 2475.000000) nil) | 1@@list("AQ11" "MX_SOT23" list(898.500000 990.000000) nil) | 1@@list("AQ13" "MX_SOT23" list(1024.500000 990.000000) nil) | 1@@list("AQ14" "MX_SOT23" list(1005.000000 1143.000000) nil) | 1@@list("AQ16" "MX_SOT363_PHILIPS" list(245.000000 2475.000000) nil) | 1@@list("AQ17" "MX_SOT363_PHILIPS" list(235.000000 2300.000000) nil) | 1@@list("AQ18" "MX_SOT363_PHILIPS" list(516.000000 2302.360000) nil) | 1@@list("AQ2" "MX_SOT363_PHILIPS" list(430.000000 2475.000000) nil) | 1@@list("AQ23" "MX_SOT23" list(1160.000000 602.000000) nil) | 1@@list("CR2" "MX_LED_2P_63X31_H16" list(3746.000000 329.000000) nil) | 1@@list("CR25" "MX_LED_2P_63X31_H16" list(3931.000000 329.000000) nil) | 1@@list("CR26" "MX_LED_2P_63X31_H16" list(3871.000000 329.000000) nil) | 1@@list("CR27" "MX_LED_2P_63X31_H16" list(3807.000000 329.000000) nil) | 1@@list("CR7" "MX_LED_2P_63X31_H16" list(3989.000000 329.000000) nil) | 1@@list("CR9" "MX_LED_2P_63X31_EVER" list(4051.000000 329.000000) nil) | 1@@list("D20" "MX_SOT323" list(5253.750000 2516.750000) nil) | 1@@list("ECQ12" "MX_SOT23" list(4990.000000 3665.000000) nil) | 1@@list("ECQ13" "MX_SOT23" list(5232.000000 3684.000000) nil) | 1@@list("F3U1" "MX_SOIC_8P_50_213X311" list(7169.310000 587.520000) nil) | 1@@list("F3U2" "MX_SOIC_8P_50_197X236" list(1560.000000 7330.000000) nil) | 1@@list("FD1" "MX_SOT323" list(5045.000000 9215.000000) nil) | 1@@list("FD10" "MX_SOT323" list(5970.000000 9213.000000) nil) | 1@@list("FD3" "MX_SOT323" list(4910.000000 9215.000000) nil) | 1@@list("FD7" "MX_SOT323" list(5722.000000 9166.000000) nil) | 1@@list("FD8" "MX_SOT323" list(9139.750000 9006.250000) nil) | 1@@list("FD9" "MX_SOT323" list(9121.750000 8857.750000) nil) | 1@@list("GFX_Q1" "MX_SOT23" list(2632.000000 2907.000000) nil) | 1@@list("H1" "MX_HOLE_160_T_U_HP" list(1299.980000 9350.000000) nil) | 1@@list("H2" "MX_HOLE_160_T_R_HP" list(9350.000000 3150.000000) nil) | 1@@list("H3" "MX_HOLE_160_T_U_HP" list(6500.000000 9350.000000) nil) | 1@@list("H6" "MX_H_C315D189N_M2_P2_V8" list(9350.000000 9350.000000) nil) | 1@@list("H7" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 1350.000000) nil) | 1@@list("H8" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 3150.000000) nil) | 1@@list("J60" "MX_MINI_PCI_67P_4HD_COLAY" list(1443.730000 4652.000000) nil) | 1@@list("J_TYPEC" "A_USB_CON_2X12P_8HOLD_ACON" list(222.430000 5765.000000) nil) | 1@@list("MQ10" "MX_SOT363" list(1300.000000 6895.000000) nil) | 1@@list("MQ12" "MX_SOT363" list(1035.000000 6880.000000) nil) | 1@@list("MQ15" "MX_SOT23_H43" list(619.000000 6808.000000) nil) | 1@@list("MQ18" "MX_SOT23_H43" list(1440.000000 8100.000000) nil) | 1@@list("MQ19" "MX_SOT363" list(8978.620000 3176.900000) nil) | 1@@list("MQ20" "MX_SOT363" list(8740.000000 4259.000000) nil) | 1@@list("MQ21" "MX_SOT363" list(5138.100000 4356.620000) nil) | 1@@list("MQ22" "MX_SOT23_H43" list(870.000000 9056.000000) nil) | 1@@list("MQ23" "MX_SOT23_2D4_H43" list(800.000000 9194.000000) nil) | 1@@list("MQ24" "MX_SOT363" list(8240.000000 8490.000000) nil) | 1@@list("MQ25" "MX_SOT363" list(8996.000000 6048.000000) nil) | 1@@list("MQ26" "MX_SOT363" list(8950.000000 7870.000000) nil) | 1@@list("MQ28" "MX_SOT363" list(8110.000000 1905.000000) nil) | 1@@list("MQ29" "MX_SOT363" list(5425.000000 3715.000000) nil) | 1@@list("MQ34" "MX_SOT363" list(8903.000000 4268.000000) nil) | 1@@list("MQ35" "MX_SOT363" list(8304.640000 1999.100000) nil) | 1@@list("MQ36" "MX_SOT363" list(8837.260000 4843.790000) nil) | 1@@list("MQ4" "MX_SOT23_2D4_H44" list(913.000000 6611.000000) nil) | 1@@list("MQ8" "MX_SOT363" list(1540.000000 6960.000000) nil) | 1@@list("O2Q6" "MX_SOT363_PHILIPS" list(8645.000000 1815.000000) nil) | 1@@list("P118" "MX_FPC_12P_20_2HD_ACES_B" list(7695.000000 250.000000) nil) | 1@@list("PC483" "MX_C0603_SMALL" list(8380.000000 6148.000000) nil) | 1@@list("PCH" "BGA_885P_909X949_N" list(6725.000000 1995.000000) nil) | 1@@list("PD1" "MX_SMA" list(2010.000000 9245.000000) nil) | 1@@list("PD2" "MX_SMA" list(2010.000000 9380.000000) nil) | 1@@list("PD3" "MX_SMA" list(3553.260000 3828.040000) nil) | 1@@list("PL1" "MX_INDUCTOR_2P_287X260" list(8753.000000 8284.000000) nil) | 1@@list("PL13" "MX_INDUCTOR_2P_287X260" list(7720.000000 3260.000000) nil) | 1@@list("PL631" "MX_INDUCTOR_2P_287X260" list(3028.000000 5131.000000) nil) | 1@@list("PL661" "MX_INDUCTOR_2P_287X260" list(8363.430000 4636.660000) nil) | 1@@list("PQ10" "MX_SOT23_H43" list(8255.000000 8690.000000) nil) | 1@@list("PQ11" "MX_SOT363" list(9060.820000 819.350000) nil) | 1@@list("PQ115" "MX_SOT23" list(8432.000000 5938.000000) nil) | 1@@list("PQ19" "MX_SO_8FL_COLAY_9VI" list(5099.000000 4118.000000) nil) | 1@@list("PQ2" "MX_SOT23_H43" list(2597.000000 8484.000000) nil) | 1@@list("PQ23" "MX_SOT23_H43" list(2075.000000 4789.000000) nil) | 1@@list("PQ28" "MX_SOT1220_NXP" list(2705.000000 5130.000000) nil) | 1@@list("PQ29" "MX_SOT1220_NXP" list(2970.580000 5336.000000) nil) | 1@@list("PQ30" "MX_SOT1220_NXP" list(2803.000000 5339.000000) nil) | 1@@list("PQ31" "MX_SOT23_2D4_H51" list(8945.000000 7600.000000) nil) | 1@@list("PQ33" "MX_TO252_LF3" list(8934.500000 7050.000000) nil) | 1@@list("PQ34" "MX_SO_8FL_COLAY" list(9140.000000 8213.000000) nil) | 1@@list("PQ37" "MX_SOT23_2D4_H43" list(9365.000000 8233.000000) nil) | 1@@list("PQ40" "MX_POWERPAIR_8P_2PAD_VISHAY" list(8035.000000 3480.000000) nil) | 1@@list("PQ46" "MX_SOT323_S5" list(5366.000000 4431.000000) nil) | 1@@list("PQ54" "MX_SOT23_2D4_H43" list(8560.000000 5252.000000) nil) | 1@@list("PQ56" "MX_SO_8FL_COLAY" list(8661.000000 5546.000000) nil) | 1@@list("PQ591" "MX_SO_8FL_COLAY_9VI" list(2373.010000 7323.230000) nil) | 1@@list("PQ592" "MX_SO_8FL_COLAY_9VI" list(2480.000000 7018.230000) nil) | 1@@list("PQ593" "MX_SO_8FL_COLAY_9VI" list(2235.010000 7018.230000) nil) | 1@@list("PQ594" "MX_SO_8FL_COLAY_9VI" list(2373.010000 8019.230000) nil) | 1@@list("PQ595" "MX_SO_8FL_COLAY_9VI" list(2480.000000 7713.230000) nil) | 1@@list("PQ596" "MX_SO_8FL_COLAY_9VI" list(2235.010000 7713.230000) nil) | 1@@list("PQ60" "MX_SOT23_2D4_H44" list(5009.000000 4495.000000) nil) | 1@@list("PQ601" "MX_SO_8FL_COLAY_9VI" list(2375.530000 6638.230000) nil) | 1@@list("PQ602" "MX_SO_8FL_COLAY_9VI" list(2234.530000 6329.230000) nil) | 1@@list("PQ603" "MX_SO_8FL_COLAY_9VI" list(2482.000000 6329.430000) nil) | 1@@list("PQ604" "MX_SO_8FL_COLAY_9VI" list(2375.530000 5935.230000) nil) | 1@@list("PQ605" "MX_SO_8FL_COLAY_9VI" list(2234.530000 5630.230000) nil) | 1@@list("PQ606" "MX_SO_8FL_COLAY_9VI" list(2482.000000 5630.450000) nil) | 1@@list("PQ611" "MX_SO_8FL_COLAY_9VI" list(4679.000000 8772.230000) nil) | 1@@list("PQ612" "MX_SO_8FL_COLAY_9VI" list(4094.990000 8767.770000) nil) | 1@@list("PQ613" "MX_SO_8FL_COLAY_9VI" list(4338.990000 8767.770000) nil) | 1@@list("PQ614" "MX_SO_8FL_COLAY_9VI" list(5525.010000 8772.230000) nil) | 1@@list("PQ615" "MX_SO_8FL_COLAY_9VI" list(5180.000000 8767.770000) nil) | 1@@list("PQ616" "MX_SO_8FL_COLAY_9VI" list(4930.000000 8767.770000) nil) | 1@@list("PQ651" "MX_SO_8FL_COLAY_9VI" list(8530.010000 7984.230000) nil) | 1@@list("PQ652" "MX_SO_8FL_COLAY_9VI" list(8467.230000 7705.990000) nil) | 1@@list("PQ653" "MX_SO_8FL_COLAY_9VI" list(8467.230000 7456.000000) nil) | 1@@list("PQ691" "MX_SOT23_2D4_H43" list(8975.000000 6335.000000) nil) | 1@@list("PQ80" "MX_SOT23_H43_COLAY" list(8579.000000 6085.000000) nil) | 1@@list("PQ9777" "MX_SOT23_H43" list(8125.000000 2035.000000) nil) | 1@@list("PQ9779" "MX_SOT23_H61" list(8034.000000 1736.000000) nil) | 1@@list("PQ9784" "MX_SOT23_2D4_H55" list(1535.000000 8975.000000) nil) | 1@@list("PQ9786" "MX_SOT23_2D4_H43" list(2070.000000 5056.000000) nil) | 1@@list("PQ9787" "MX_SOT23_H43" list(5456.900000 516.400000) nil) | 1@@list("PU12" "MX_SOIC_8P_26_118X110_MAXIM" list(4642.000000 2072.000000) nil) | 1@@list("PU5" "MX_SOT23_S6_FITI" list(4990.000000 3802.000000) nil) | 1@@list("PU681" "MX_SOIC_8P_50_201X236_P_NIK" list(1737.000000 9144.000000) nil) | 1@@list("PU80" "MX_SOIC_8P_50_201X236_PAD" list(8250.000000 5906.000000) nil) | 1@@list("P_HDDFAN" "MX_WTOB_4P_49_2H_XINA" list(3488.000000 287.000000) nil) | 1@@list("Q3" "MX_SOT363" list(3820.000000 485.000000) nil) | 1@@list("Q35" "MX_SOT363" list(9047.000000 8510.000000) nil) | 1@@list("Q4" "MX_SOT23" list(4151.000000 307.000000) nil) | 1@@list("Q5" "MX_SOT363" list(4120.000000 485.000000) nil) | 1@@list("Q53" "MX_SOT363" list(8485.000000 5485.000000) nil) | 1@@list("Q9" "MX_SOT23" list(1112.000000 1610.000000) nil) | 1@@list("SQ1" "MX_SOT23" list(7975.250000 2005.760000) nil) | 1@@list("SS4" "MX_MINI_PCI_67P_20_4H_COLAY" list(8596.780000 621.170000) nil) | 1@@list("SW1" "MX_SW_4P_181X126" list(4763.000000 1122.000000) nil) | 1@@list("SW2" "MX_SW_4P_181X126" list(5009.000000 1218.000000) nil) | 1@@list("TUU2" "MX_SOT23_S5_H57" list(1605.000000 7881.000000) nil) | 1@@list("UC2" "SOIC_8P_50_197X236" list(4047.000000 1291.000000) nil) | 1@@list("UL10" "MX_CHOKE_4P_49X39_TAI" list(847.040000 4613.000000) nil) | 1@@list("UL22" "MX_CHOKE_4P_49X39_TAI" list(9128.830000 4046.000000) nil) | 1@@list("UL62" "MX_CHOKE_4P_49X39_TAI" list(552.000000 4713.000000) nil) | 1@@list("UL64" "MX_CHOKE_4P_49X39_TAI" list(9092.000000 4252.000000) nil) | 1@@list("UL65" "MX_CHOKE_4P_49X39_TAI" list(1076.000000 7118.000000) nil) | 1@@list("UL66" "MX_CHOKE_4P_49X39_TAI" list(1076.000000 7177.000000) nil) | 1@@list("UL67" "MX_CHOKE_4P_49X39_TAI" list(1075.000000 7307.000000) nil) | 1@@list("UL68" "MX_CHOKE_4P_49X39_TAI" list(1075.100000 7246.500000) nil) | 1@@list("UL7" "MX_CHOKE_4P_49X39_TAI" list(1196.000000 7757.000000) nil) | 1@@list("UL70" "MX_CHOKE_4P_49X39_TAI" list(9147.000000 5186.000000) nil) | 1@@list("UL74" "MX_CHOKE_4P_49X39_TAI" list(9080.000000 5246.000000) nil) | 1@@list("UL75" "MX_CHOKE_4P_49X39_TAI" list(865.000000 4512.000000) nil) | 1@@list("UL76" "MX_CHOKE_4P_49X39_TAI" list(446.000000 6005.000000) nil) | 1@@list("UL77" "MX_CHOKE_4P_49X39_TAI" list(1075.570000 5425.600000) nil) | 1@@list("UL79" "MX_CHOKE_4P_49X39_TAI" list(1041.000000 5121.950000) nil) | 1@@list("UL8" "MX_CHOKE_4P_49X39_TAI" list(1196.000000 7697.000000) nil) | 1@@list("UL83" "MX_CHOKE_4P_49X39_TAI" list(1041.000000 5245.390000) nil) | 1@@list("UL84" "MX_CHOKE_4P_49X39_TAI" list(1041.000000 5183.750000) nil) | 1@@list("UL86" "MX_CHOKE_4P_49X39_TAI" list(499.170000 5680.000000) nil) | 1@@list("UL88" "MX_CHOKE_4P_49X39_TAI" list(448.000000 5848.000000) nil) | 1@@list("UL9" "MX_CHOKE_4P_49X39_TAI" list(552.040000 4654.000000) nil) | 1@@list("UL90" "MX_CHOKE_4P_49X39_TAI" list(9103.000000 3895.270000) nil) | 1@@list("UL91" "MX_CHOKE_4P_49X39_TAI" list(9178.000000 3809.630000) nil) | 1@@list("UL94" "MX_CHOKE_4P_49X39_TAI" list(9086.000000 5018.000000) nil) | 1@@list("UL95" "MX_CHOKE_4P_49X39_TAI" list(9163.000000 4934.000000) nil) | 1@@list("UU45" "MX_SOT23_S5_H57" list(527.000000 5581.000000) nil) | 1@@list("UU47" "MX_SOT23_S5_H57" list(816.000000 8877.000000) nil) | 1@@list("UU50" "MX_SOT23_S5_H57" list(747.000000 5510.000000) nil) | 1@@list("UU51" "MX_SOT23_S5_H57" list(8928.000000 5295.000000) nil) | 1@@list("Y5" "MX_XTAL_4P_272X55" list(5796.000000 1181.000000) nil) | 2@@list("XU1" "MX_SOCKET1151_FOXN_7HD" list(4939.170000 6356.660000) nil) | 3@@list("H4" "MX_HOLE_160_T_HP" list(6500.000000 3150.000000) nil) | 3@@list("H5" "MX_HOLE_160_T_HP" list(6500.000000 550.000000) nil) | 3@@list("HT34" "MX_TPC26T_S4_68" list(5300.000000 8194.000000) t) | 3@@list("HT45" "MX_TPC26T_S4_68" list(2995.000000 4415.000000) t) | 3@@list("HT46" "MX_TPC26T_S4_68" list(3102.000000 4426.000000) t) | 3@@list("HT47" "MX_TPC26T_S4_68" list(3057.000000 4366.000000) t) | 3@@list("HT48" "MX_TPC26T_S4_68" list(2998.000000 4326.000000) t) | 3@@list("HT49" "MX_TPC26T_S4_68" list(3075.000000 4260.000000) t) | 3@@list("HT50" "MX_TPC26T_S4_68" list(2928.000000 4313.000000) t) | 3@@list("HT51" "MX_TPC26T_S4_68" list(2889.800000 4389.000000) t) | 3@@list("HT56" "MX_TPC26T_S4_68" list(4603.400000 5869.100000) t) | 3@@list("PC1" "MX_C0603_SMALL_T02" list(4900.000000 6320.000000) t) | 3@@list("PC11" "MX_C0603_SMALL_T02" list(4939.520000 6735.000000) t) | 3@@list("PC12" "MX_C0603_SMALL_T02" list(4834.760000 6680.000000) t) | 3@@list("PC2" "MX_C0603_SMALL_T02" list(4780.000000 6321.000000) t) | 3@@list("PC3" "MX_C0603_SMALL_T02" list(4713.000000 6174.000000) t) | 3@@list("PC332" "MX_C0603_SMALL_T02" list(4909.000000 6086.000000) t) | 3@@list("PC333" "MX_C0603_SMALL_T02" list(4909.000000 6141.000000) t) | 3@@list("PC334" "MX_C0603_SMALL_T02" list(5050.000000 6115.000000) t) | 3@@list("PC335" "MX_C0603_SMALL_T02" list(5047.000000 6020.000000) t) | 3@@list("PC5" "MX_C0603_SMALL_T02" list(4990.000000 6320.000000) t) | 3@@list("PC6" "MX_C0603_SMALL_T02" list(4765.000000 6174.000000) t) | 3@@list("PC7" "MX_C0603_SMALL_T02" list(4939.520000 6626.000000) t) | 3@@list("PC8" "MX_C0603_SMALL_T02" list(4939.520000 6680.000000) t) | 3@@list("PC9" "MX_C0603_SMALL_T02" list(4834.760000 6735.000000) t) | 3@@list("PT1" "MX_TPC26T_S4_68" list(9170.000000 8005.000000) t) | 3@@list("PT10" "MX_TPC26T_S4_68" list(9132.000000 8323.000000) t) | 3@@list("PT11" "MX_TPC26T_S4_68" list(9385.000000 8159.000000) t) | 3@@list("PT12" "MX_TPC26T_S4_68" list(9385.000000 8231.000000) t) | 3@@list("PT13" "MX_TPC26T_S4_68" list(8819.000000 7616.000000) t) | 3@@list("PT14" "MX_TPC26T_S4_68" list(8759.780000 6847.220000) t) | 3@@list("PT15" "MX_TPC26T_S4_68" list(9375.000000 8085.000000) t) | 3@@list("PT2" "MX_TPC26T_S4_68" list(9176.000000 8156.000000) t) | 3@@list("PT21" "MX_TPC26T_S4_68" list(6203.700000 790.800000) t) | 3@@list("PT22" "MX_TPC26T_S4_68" list(7205.000000 1273.500000) t) | 3@@list("PT23" "MX_TPC26T_S4_68" list(5213.000000 552.000000) t) | 3@@list("PT24" "MX_TPC26T_S4_68" list(7327.000000 1310.000000) t) | 3@@list("PT25" "MX_TPC26T_S4_68" list(7402.000000 1310.000000) t) | 3@@list("PT26" "MX_TPC26T_S4_68" list(8232.400000 7530.900000) t) | 3@@list("PT265" "MX_TPC26T_S4_68" list(2457.000000 3676.000000) t) | 3@@list("PT266" "MX_TPC26T_S4_68" list(2692.000000 3745.000000) t) | 3@@list("PT267" "MX_TPC26T_S4_68" list(2614.000000 3736.000000) t) | 3@@list("PT268" "MX_TPC26T_S4_68" list(2516.000000 3728.000000) t) | 3@@list("PT269" "MX_TPC26T_S4_68" list(2742.000000 3802.000000) t) | 3@@list("PT27" "MX_TPC26T_S4_68" list(8237.000000 8078.300000) t) | 3@@list("PT270" "MX_TPC26T_S4_68" list(2638.000000 3812.000000) t) | 3@@list("PT271" "MX_TPC26T_S4_68" list(2469.000000 3805.000000) t) | 3@@list("PT272" "MX_TPC26T_S4_68" list(2432.000000 3741.000000) t) | 3@@list("PT273" "MX_TPC26T_S4_68" list(2397.000000 3801.000000) t) | 3@@list("PT274" "MX_TPC26T_S4_68" list(2545.000000 3802.000000) t) | 3@@list("PT28" "MX_TPC26T_S4_68" list(8225.000000 7945.000000) t) | 3@@list("PT29" "MX_TPC26T_S4_68" list(8223.900000 7664.600000) t) | 3@@list("PT3" "MX_TPC26T_S4_68" list(9173.000000 8085.000000) t) | 3@@list("PT30" "MX_TPC26T_S4_68" list(8248.000000 7396.000000) t) | 3@@list("PT31" "MX_TPC26T_S4_68" list(2314.000000 6114.000000) t) | 3@@list("PT32" "MX_TPC26T_S4_68" list(2332.000000 5440.000000) t) | 3@@list("PT33" "MX_TPC26T_S4_68" list(2571.000000 7496.000000) t) | 3@@list("PT34" "MX_TPC26T_S4_68" list(2217.000000 7578.000000) t) | 3@@list("PT35" "MX_TPC26T_S4_68" list(2534.000000 5493.000000) t) | 3@@list("PT36" "MX_TPC26T_S4_68" list(2585.000000 5403.000000) t) | 3@@list("PT37" "MX_TPC26T_S4_68" list(2455.000000 6885.000000) t) | 3@@list("PT38" "MX_TPC26T_S4_68" list(2577.000000 6798.000000) t) | 3@@list("PT39" "MX_TPC26T_S4_68" list(2360.000000 6815.000000) t) | 3@@list("PT4" "MX_TPC26T_S4_68" list(1790.000000 8782.000000) t) | 3@@list("PT40" "MX_TPC26T_S4_68" list(2528.000000 6102.000000) t) | 3@@list("PT41" "MX_TPC26T_S4_68" list(3305.000000 6020.000000) t) | 3@@list("PT42" "MX_TPC26T_S4_68" list(3320.000000 6675.000000) t) | 3@@list("PT43" "MX_TPC26T_S4_68" list(3375.000000 6515.000000) t) | 3@@list("PT44" "MX_TPC26T_S4_68" list(3405.000000 6670.000000) t) | 3@@list("PT45" "MX_TPC26T_S4_68" list(3400.000000 6760.000000) t) | 3@@list("PT46" "MX_TPC26T_S4_68" list(3434.000000 6985.000000) t) | 3@@list("PT47" "MX_TPC26T_S4_68" list(3395.000000 5980.000000) t) | 3@@list("PT48" "MX_TPC26T_S4_68" list(3510.000000 6010.000000) t) | 3@@list("PT49" "MX_TPC26T_S4_68" list(3407.000000 6354.000000) t) | 3@@list("PT5" "MX_TPC26T_S4_68" list(1805.000000 9006.000000) t) | 3@@list("PT50" "MX_TPC26T_S4_68" list(3235.000000 5815.000000) t) | 3@@list("PT51" "MX_TPC26T_S4_68" list(2373.000000 8638.000000) t) | 3@@list("PT52" "MX_TPC26T_S4_68" list(2044.000000 8079.000000) t) | 3@@list("PT53" "MX_TPC26T_S4_68" list(2088.000000 6184.000000) t) | 3@@list("PT54" "MX_TPC26T_S4_68" list(1975.000000 7208.000000) t) | 3@@list("PT55" "MX_TPC26T_S4_68" list(2034.000000 5957.000000) t) | 3@@list("PT56" "MX_TPC26T_S4_68" list(2136.000000 5368.000000) t) | 3@@list("PT57" "MX_TPC26T_S4_68" list(1984.000000 6376.000000) t) | 3@@list("PT58" "MX_TPC26T_S4_68" list(2016.000000 5560.000000) t) | 3@@list("PT59" "MX_TPC26T_S4_68" list(1958.000000 6631.000000) t) | 3@@list("PT6" "MX_TPC26T_S4_68" list(9145.000000 5630.000000) t) | 3@@list("PT60" "MX_TPC26T_S4_68" list(1979.000000 7542.000000) t) | 3@@list("PT7" "MX_TPC26T_S4_68" list(9145.000000 5553.000000) t) | 3@@list("PT8" "MX_TPC26T_S4_68" list(9145.000000 5704.000000) t) | 3@@list("PT9" "MX_TPC26T_S4_68" list(8734.000000 5716.000000) t) | 3@@list("ST1" "MX_TPC26T_S4_68" list(6476.000000 1700.000000) t) | 3@@list("ST106" "MX_TPC26T_S4_68" list(6372.100000 1443.600000) t) | 3@@list("ST128" "MX_TPC26T_S4_68" list(6248.000000 1443.000000) t) | 3@@list("ST147" "MX_TPC26T_S4_68" list(6592.500000 1364.000000) t) | 3@@list("ST154" "MX_TPC26T_S4_68" list(6447.000000 1293.000000) t) | 3@@list("ST156" "MX_TPC26T_S4_68" list(6709.000000 1357.000000) t) | 3@@list("ST36" "MX_TPC26T_S4_68" list(6600.000000 1808.000000) t) | 3@@list("ST37" "MX_TPC26T_S4_68" list(6687.000000 1723.000000) t) | 3@@list("ST76" "MX_TPC26T_S4_68" list(1539.000000 5809.000000) t) | 3@@list("ST77" "MX_TPC26T_S4_68" list(1479.000000 5842.000000) t) | 4@@list("" "INDEXB_CROSS" list(1006.000000 9188.000000) t) | 4@@list("" "INDEXB_CROSS" list(8465.000000 395.000000) t) | 4@@list("" "INDEXB_CROSS" list(8950.000000 9369.000000) t) | 4@@list("H1" "MX_HOLE_160_T_U_HP" list(1299.980000 9350.000000) nil) | 4@@list("H2" "MX_HOLE_160_T_R_HP" list(9350.000000 3150.000000) nil) | 4@@list("H3" "MX_HOLE_160_T_U_HP" list(6500.000000 9350.000000) nil) | 4@@list("H6" "MX_H_C315D189N_M2_P2_V8" list(9350.000000 9350.000000) nil) | 4@@list("H7" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 1350.000000) nil) | 4@@list("H8" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 3150.000000) nil) | 6@@list("" "INDEXB_CROSS" list(1273.000000 661.000000) nil) | 6@@list("" "INDEXB_CROSS" list(704.000000 9363.000000) nil) | 6@@list("" "INDEXB_CROSS" list(9035.000000 1014.000000) nil) | 6@@list("AC1" "MX_C0201" list(895.000000 762.000000) nil) | 6@@list("AC129" "MX_C0402_SMALL_T01" list(1580.000000 330.000000) nil) | 6@@list("AC130" "MX_C0402_SMALL_T01" list(735.000000 3255.000000) nil) | 6@@list("AC136" "MX_C0402_SMALL_T01" list(549.000000 6907.000000) nil) | 6@@list("AC14" "MX_C0201" list(908.000000 685.000000) nil) | 6@@list("AC15" "MX_C0603_SMALL_T01" list(987.080000 687.000000) nil) | 6@@list("AC16" "MX_C0603_SMALL_T01" list(300.000000 695.080000) nil) | 6@@list("AC161" "C1206_H75" list(595.000000 950.000000) nil) | 6@@list("AC162" "C1206_H75" list(695.000000 950.000000) nil) | 6@@list("AC163" "C1206_H75" list(490.000000 950.000000) nil) | 6@@list("AC164" "C1206_H75" list(390.000000 950.000000) nil) | 6@@list("AC17" "MX_C0201" list(540.000000 330.000000) nil) | 6@@list("AC173" "MX_C0402_SMALL_T01" list(298.000000 2700.000000) nil) | 6@@list("AC174" "MX_C0402_SMALL_T01" list(207.000000 2700.000000) nil) | 6@@list("AC175" "MX_C0402_SMALL_T01" list(389.000000 2700.000000) nil) | 6@@list("AC176" "MX_C0402_SMALL_T01" list(480.000000 2700.000000) nil) | 6@@list("AC177" "MX_C0402_SMALL_T01" list(662.000000 2700.000000) nil) | 6@@list("AC178" "MX_C0402_SMALL_T01" list(571.000000 2700.000000) nil) | 6@@list("AC179" "MX_C0402_SMALL_T01" list(682.000000 3504.000000) nil) | 6@@list("AC18" "MX_C0603_SMALL_T01" list(465.000000 335.080000) nil) | 6@@list("AC180" "MX_C0402_SMALL_T01" list(770.000000 3502.000000) nil) | 6@@list("AC181" "MX_C0402_SMALL_T01" list(470.000000 3470.000000) nil) | 6@@list("AC182" "MX_C0402_SMALL_T01" list(398.000000 3530.000000) nil) | 6@@list("AC183" "MX_C0402_SMALL_T01" list(261.500000 3475.000000) nil) | 6@@list("AC184" "MX_C0402_SMALL_T01" list(215.000000 2830.000000) nil) | 6@@list("AC185" "MX_C0402_SMALL_T01" list(575.000000 8755.000000) nil) | 6@@list("AC186" "MX_C0402_SMALL_T01" list(630.000000 8920.000000) nil) | 6@@list("AC187" "MX_C0201" list(555.000000 8920.000000) nil) | 6@@list("AC188" "MX_C0603_SMALL_T01" list(940.000000 539.920000) nil) | 6@@list("AC19" "MX_C0201" list(355.000000 745.000000) nil) | 6@@list("AC193" "MX_C0402_SMALL_T01" list(2340.500000 345.500000) nil) | 6@@list("AC194" "MX_C0402_SMALL_T01" list(2850.000000 365.000000) nil) | 6@@list("AC195" "MX_C0402_SMALL_T01" list(2958.000000 365.000000) nil) | 6@@list("AC196" "MX_C0402_SMALL_T01" list(3069.000000 365.000000) nil) | 6@@list("AC197" "MX_C0402_SMALL_T01" list(2357.000000 453.000000) nil) | 6@@list("AC198" "MX_C0402_SMALL_T01" list(1130.000000 1178.000000) nil) | 6@@list("AC2" "MX_C0201" list(895.000000 798.000000) nil) | 6@@list("AC20" "MX_C0603_SMALL_T01" list(1049.000000 541.000000) nil) | 6@@list("AC21" "MX_C0201" list(875.000000 475.000000) nil) | 6@@list("AC22" "MX_C0402_SMALL_T01" list(930.000000 585.000000) nil) | 6@@list("AC23" "MX_C0603_SMALL_T01" list(300.000000 640.080000) nil) | 6@@list("AC24" "MX_C0402_SMALL_T01" list(1170.000000 445.000000) nil) | 6@@list("AC25" "MX_C0402_SMALL_T01" list(1235.000000 445.000000) nil) | 6@@list("AC26" "MX_C0402_SMALL_T01" list(715.000000 2795.000000) nil) | 6@@list("AC27" "MX_C0402_SMALL_T01" list(765.000000 1370.000000) nil) | 6@@list("AC3" "MX_C0603_SMALL_T01" list(271.000000 585.080000) nil) | 6@@list("AC39" "MX_C0201" list(8507.000000 868.000000) nil) | 6@@list("AC4" "MX_C0201" list(375.000000 580.000000) nil) | 6@@list("AC47" "MX_C0402_SMALL_T01" list(8040.000000 1390.000000) nil) | 6@@list("AC52" "MX_C0402_SMALL_T01" list(715.000000 2955.000000) nil) | 6@@list("AC55" "MX_C0402_SMALL_T01" list(715.000000 2285.000000) nil) | 6@@list("AC71" "MX_C0603_SMALL_T02" list(1190.000000 1063.000000) nil) | 6@@list("AC72" "MX_C0402_SMALL_T01" list(1621.000000 215.000000) nil) | 6@@list("AC73" "MX_C0402_SMALL_T01" list(810.000000 440.000000) nil) | 6@@list("AC74" "MX_C0402_SMALL_T01" list(1072.000000 305.000000) nil) | 6@@list("AC75" "MX_C0402_SMALL_T01" list(1215.000000 305.000000) nil) | 6@@list("AC76" "MX_C0402_SMALL_T01" list(1360.000000 305.000000) nil) | 6@@list("AC77" "MX_C0402_SMALL_T01" list(1495.000000 305.000000) nil) | 6@@list("AD1" "MX_SOT23_2D4_H43" list(923.000000 222.000000) nil) | 6@@list("AD10" "MX_VARISTOR_0402" list(1130.000000 445.000000) nil) | 6@@list("AD11" "MX_VARISTOR_0402" list(1295.000000 445.000000) nil) | 6@@list("AD12" "MX_VARISTOR_0402" list(1455.000000 430.000000) nil) | 6@@list("AD13" "MX_VARISTOR_0402" list(292.000000 2740.000000) nil) | 6@@list("AD14" "MX_VARISTOR_0402" list(207.000000 2740.000000) nil) | 6@@list("AD15" "MX_VARISTOR_0402" list(389.000000 2740.000000) nil) | 6@@list("AD16" "MX_VARISTOR_0402" list(495.000000 2740.000000) nil) | 6@@list("AD17" "MX_VARISTOR_0402" list(662.000000 2740.000000) nil) | 6@@list("AD18" "MX_VARISTOR_0402" list(571.000000 2740.000000) nil) | 6@@list("AD19" "MX_VARISTOR_0402" list(688.000000 3542.000000) nil) | 6@@list("AD2" "MX_S0402_AMAZ_COLAY" list(800.000000 1270.000000) nil) | 6@@list("AD20" "MX_VARISTOR_0402" list(2410.770000 411.600000) nil) | 6@@list("AD21" "MX_VARISTOR_0402" list(2812.000000 366.000000) nil) | 6@@list("AD22" "MX_VARISTOR_0402" list(2996.000000 366.000000) nil) | 6@@list("AD23" "MX_VARISTOR_0402" list(2664.000000 355.000000) nil) | 6@@list("AD3" "MX_VARISTOR_0402" list(765.000000 3541.000000) nil) | 6@@list("AD4" "MX_VARISTOR_0402" list(480.000000 3525.000000) nil) | 6@@list("AD5" "MX_VARISTOR_0402" list(437.000000 3525.000000) nil) | 6@@list("AD6" "MX_VARISTOR_0402" list(265.000000 3535.000000) nil) | 6@@list("AD7" "MX_VARISTOR_0402" list(175.000000 2830.000000) nil) | 6@@list("AD8" "MX_VARISTOR_0402" list(1615.000000 175.000000) nil) | 6@@list("AD9" "MX_VARISTOR_0402" list(1014.000000 430.000000) nil) | 6@@list("AL1" "MX_L0603_SMALL_T02" list(765.000000 1200.000000) nil) | 6@@list("AL10" "MX_L0603_SMALL_T02" list(372.000000 3472.000000) nil) | 6@@list("AL11" "MX_L0603_SMALL_T02" list(207.000000 2655.000000) nil) | 6@@list("AL12" "MX_L0603_SMALL_T02" list(200.000000 3484.000000) nil) | 6@@list("AL13" "MX_L0603_SMALL_T02" list(298.000000 2655.000000) nil) | 6@@list("AL14" "MX_L0603_SMALL_T02" list(260.000000 2825.000000) nil) | 6@@list("AL15" "MX_L0603_SMALL_T02" list(1505.000000 370.000000) nil) | 6@@list("AL16" "MX_L0603_SMALL_T02" list(1350.000000 350.000000) nil) | 6@@list("AL17" "MX_L0603_SMALL_T02" list(1177.000000 360.000000) nil) | 6@@list("AL18" "MX_L0603_SMALL_T02" list(995.000000 318.000000) nil) | 6@@list("AL2" "MX_L0603_SMALL_T02" list(1040.000000 687.020000) nil) | 6@@list("AL3" "MX_L0603_SMALL_T02" list(571.000000 2655.000000) nil) | 6@@list("AL4" "MX_L0603_SMALL_T02" list(685.000000 3460.000000) nil) | 6@@list("AL5" "MX_L0603_SMALL_T02" list(662.000000 2655.000000) nil) | 6@@list("AL6" "MX_L0603_SMALL_T02" list(770.000000 3440.000000) nil) | 6@@list("AL7" "MX_L0603_SMALL_T02" list(480.000000 2655.000000) nil) | 6@@list("AL8" "MX_L0603_SMALL_T02" list(550.000000 3484.000000) nil) | 6@@list("AL9" "MX_L0603_SMALL_T02" list(389.000000 2655.000000) nil) | 6@@list("AMB_Q1" "MX_SOT23" list(8964.000000 3027.000000) nil) | 6@@list("APR112" "MX_R0402_SMALL_T01" list(997.000000 5653.000000) nil) | 6@@list("APR13" "MX_R0402_SMALL_T01" list(8397.000000 325.000000) nil) | 6@@list("AQ1" "MX_SOT363_PHILIPS" list(615.000000 2475.000000) nil) | 6@@list("AQ11" "MX_SOT23" list(898.500000 990.000000) nil) | 6@@list("AQ13" "MX_SOT23" list(1024.500000 990.000000) nil) | 6@@list("AQ14" "MX_SOT23" list(1005.000000 1143.000000) nil) | 6@@list("AQ16" "MX_SOT363_PHILIPS" list(245.000000 2475.000000) nil) | 6@@list("AQ17" "MX_SOT363_PHILIPS" list(235.000000 2300.000000) nil) | 6@@list("AQ18" "MX_SOT363_PHILIPS" list(516.000000 2302.360000) nil) | 6@@list("AQ2" "MX_SOT363_PHILIPS" list(430.000000 2475.000000) nil) | 6@@list("AQ23" "MX_SOT23" list(1160.000000 602.000000) nil) | 6@@list("AR1" "MX_R0402_SMALL_T01" list(1080.000000 885.000000) nil) | 6@@list("AR10" "MX_R0402_SMALL_T01" list(917.000000 373.000000) nil) | 6@@list("AR11" "MX_R0402_SMALL_T01" list(339.000000 505.000000) nil) | 6@@list("AR12" "MX_R0402_SMALL_T01" list(1255.000000 375.000000) nil) | 6@@list("AR13" "MX_R0402_SMALL_T01" list(1430.000000 339.000000) nil) | 6@@list("AR14" "MX_R0402_SMALL_T01" list(732.000000 1082.000000) nil) | 6@@list("AR15" "MX_R0402_SMALL_T01" list(732.000000 1117.000000) nil) | 6@@list("AR16" "MX_R0402_SMALL_T01" list(732.000000 1048.000000) nil) | 6@@list("AR17" "MX_R0402_SMALL_T01" list(770.000000 995.000000) nil) | 6@@list("AR18" "MX_R0402_SMALL_T01" list(267.000000 505.000000) nil) | 6@@list("AR19" "MX_R0402_SMALL_T01" list(375.000000 505.000000) nil) | 6@@list("AR199" "MX_R0402_SMALL_T01" list(223.000000 2390.000000) nil) | 6@@list("AR2" "MX_R0402_SMALL_T01" list(930.010000 630.000000) nil) | 6@@list("AR20" "MX_R0402_SMALL_T01" list(578.500000 8974.000000) nil) | 6@@list("AR200" "MX_R0402_SMALL_T01" list(186.620000 2390.260000) nil) | 6@@list("AR201" "MX_R0402_SMALL_T01" list(295.000000 2390.000000) nil) | 6@@list("AR202" "MX_R0402_SMALL_T01" list(259.000000 2390.000000) nil) | 6@@list("AR203" "MX_R0402_SMALL_T01" list(535.000000 2390.000000) nil) | 6@@list("AR204" "MX_R0402_SMALL_T01" list(499.000000 2390.000000) nil) | 6@@list("AR205" "MX_R0402_SMALL_T01" list(563.000000 2610.000000) nil) | 6@@list("AR206" "MX_R0402_SMALL_T01" list(649.500000 2610.000000) nil) | 6@@list("AR207" "MX_R0402_SMALL_T01" list(563.000000 2570.000000) nil) | 6@@list("AR208" "MX_R0402_SMALL_T01" list(649.500000 2570.000000) nil) | 6@@list("AR209" "MX_R0402_SMALL_T01" list(685.000000 3415.000000) nil) | 6@@list("AR210" "MX_R0402_SMALL_T01" list(705.000000 3365.000000) nil) | 6@@list("AR211" "MX_R0402_SMALL_T01" list(478.010000 2570.000000) nil) | 6@@list("AR212" "MX_R0402_SMALL_T01" list(610.000000 3424.000000) nil) | 6@@list("AR213" "MX_R0402_SMALL_T01" list(389.010000 2570.000000) nil) | 6@@list("AR214" "MX_R0402_SMALL_T01" list(308.500000 3479.990000) nil) | 6@@list("AR215" "MX_R0402_SMALL_T01" list(207.010000 2570.000000) nil) | 6@@list("AR216" "MX_R0402_SMALL_T01" list(190.000000 3404.000000) nil) | 6@@list("AR217" "MX_R0402_SMALL_T01" list(298.010000 2570.000000) nil) | 6@@list("AR218" "MX_R0402_SMALL_T01" list(329.500000 2793.000000) nil) | 6@@list("AR219" "MX_R0402_SMALL_T01" list(190.000000 3440.000000) nil) | 6@@list("AR220" "MX_R0402_SMALL_T01" list(298.000000 2610.000000) nil) | 6@@list("AR221" "MX_R0402_SMALL_T01" list(207.000000 2610.000000) nil) | 6@@list("AR222" "MX_R0402_SMALL_T01" list(389.000000 2610.000000) nil) | 6@@list("AR223" "MX_R0402_SMALL_T01" list(329.500000 2829.000000) nil) | 6@@list("AR224" "MX_R0402_SMALL_T01" list(476.000000 2610.000000) nil) | 6@@list("AR225" "MX_R0402_SMALL_T01" list(350.000000 3530.000000) nil) | 6@@list("AR226" "MX_R0402_SMALL_T01" list(560.000000 3439.000000) nil) | 6@@list("AR227" "MX_R0402_SMALL_T01" list(575.010000 8798.130000) nil) | 6@@list("AR228" "MX_R0402_SMALL_T01" list(575.010000 8838.130000) nil) | 6@@list("AR229" "MX_R0402_SMALL_T01" list(1660.000000 251.000000) nil) | 6@@list("AR23" "MX_R0402_SMALL_T01" list(810.000000 1095.000000) nil) | 6@@list("AR231" "MX_R0402_SMALL_T01" list(1335.000000 445.000000) nil) | 6@@list("AR232" "MX_R0402_SMALL_T01" list(715.000000 3015.000000) nil) | 6@@list("AR237" "MX_R0402_SMALL_T01" list(905.000000 5770.000000) nil) | 6@@list("AR238" "MX_R0402_SMALL_T01" list(896.000000 5912.000000) nil) | 6@@list("AR241" "MX_R0402_SMALL_T01" list(605.000000 6010.000000) nil) | 6@@list("AR242" "MX_R0402_SMALL_T01" list(997.000000 5689.000000) nil) | 6@@list("AR243" "MX_R0402_SMALL_T01" list(770.000000 5686.000000) nil) | 6@@list("AR244" "MX_R0402_SMALL_T01" list(1300.000000 6345.000000) nil) | 6@@list("AR247" "MX_R0402_SMALL_T01" list(916.000000 5990.000000) nil) | 6@@list("AR25" "MX_R0402_SMALL_T01" list(303.000000 505.000000) nil) | 6@@list("AR26" "MX_R0402_SMALL_T01" list(580.000000 330.000000) nil) | 6@@list("AR263" "MX_R0402_SMALL_T01" list(968.000000 430.000000) nil) | 6@@list("AR3" "MX_R0402_SMALL_T01" list(980.010000 805.000000) nil) | 6@@list("AR4" "MX_R0402_SMALL_T01" list(895.000000 835.000000) nil) | 6@@list("AR5" "MX_R0402_SMALL_T01" list(1430.000000 375.000000) nil) | 6@@list("AR50" "MX_R0402_SMALL_T01" list(840.000000 873.000000) nil) | 6@@list("AR53" "MX_R0402_SMALL_T01" list(960.000000 885.000000) nil) | 6@@list("AR55" "MX_R0402_SMALL_T01" list(1125.000000 1052.000000) nil) | 6@@list("AR56" "MX_R0402_SMALL_T01" list(1125.000000 1088.000000) nil) | 6@@list("AR57" "MX_R0603_SMALL_T01" list(1140.000000 1133.000000) nil) | 6@@list("AR6" "MX_R0402_SMALL_T01" list(1265.000000 325.000000) nil) | 6@@list("AR61" "MX_R0402_SMALL_T01" list(630.000000 2390.000000) nil) | 6@@list("AR62" "MX_R0402_SMALL_T01" list(594.000000 2390.000000) nil) | 6@@list("AR63" "MX_R0402_SMALL_T01" list(409.000000 2390.000000) nil) | 6@@list("AR64" "MX_R0402_SMALL_T01" list(445.000000 2390.000000) nil) | 6@@list("AR7" "MX_R0402_SMALL_T01" list(917.000000 337.000000) nil) | 6@@list("AR8" "MX_R0402_SMALL_T01" list(1079.000000 365.000000) nil) | 6@@list("AR9" "MX_R0402_SMALL_T01" list(1115.000000 365.000000) nil) | 6@@list("ASR7" "MX_R0402_SMALL_T01" list(1437.000000 5912.000000) nil) | 6@@list("AU1" "MX_QFP_48P_20_354X354_H63" list(630.000000 613.000000) nil) | 6@@list("C1" "MX_C0402_SMALL_T01" list(8486.000000 1775.000000) nil) | 6@@list("C2" "MX_C0402_SMALL_T01" list(8422.000000 1775.000000) nil) | 6@@list("C414" "MX_C0402_SMALL_T01" list(6654.000000 982.000000) nil) | 6@@list("C415" "MX_C0402_SMALL_T01" list(6698.000000 982.000000) nil) | 6@@list("C416" "MX_C0402_SMALL_T01" list(6632.000000 1175.000000) nil) | 6@@list("C417" "MX_C0402_SMALL_T01" list(6391.000000 1239.000000) nil) | 6@@list("C5" "MX_C0402_SMALL_T01" list(4187.000000 412.000000) nil) | 6@@list("C81" "MX_C0402_SMALL_T01" list(8040.000000 1130.000000) nil) | 6@@list("C82" "MX_C0402_SMALL_T01" list(8720.500000 1704.500000) nil) | 6@@list("C83" "MX_C0402_SMALL_T01" list(8894.000000 1031.500000) nil) | 6@@list("C85" "MX_C0603_SMALL_T01" list(8069.000000 906.000000) nil) | 6@@list("C93" "MX_C0201" list(5425.920000 596.400000) nil) | 6@@list("C9357" "MX_C0201" list(8796.000000 4041.000000) nil) | 6@@list("C941399" "MX_C0201" list(8723.000000 4600.000000) nil) | 6@@list("C941400" "MX_C0201" list(9042.000000 4097.000000) nil) | 6@@list("C941401" "MX_C0201" list(9067.000000 4558.000000) nil) | 6@@list("C941402" "MX_C0402_SMALL_T01" list(8787.000000 3908.000000) nil) | 6@@list("CB2" "MX_C0402_SMALL_T01" list(1096.000000 1694.000000) nil) | 6@@list("CB4107" "MX_C0201" list(618.000000 5494.000000) nil) | 6@@list("CB4112" "MX_C0201" list(638.000000 5630.000000) nil) | 6@@list("CB4113" "MX_C0201" list(729.000000 5614.000000) nil) | 6@@list("CB4114" "MX_C0201" list(618.000000 5458.000000) nil) | 6@@list("CB4115" "MX_C0201" list(904.000000 8935.000000) nil) | 6@@list("CB4116" "MX_C0201" list(726.000000 8968.000000) nil) | 6@@list("CB4117" "MX_C0201" list(585.000000 8520.000000) nil) | 6@@list("CB4119" "MX_C0402_SMALL_T01" list(1670.000000 8130.000000) nil) | 6@@list("CB4122" "MX_C0402_SMALL_T01" list(8982.000000 5405.000000) nil) | 6@@list("CB4123" "MX_C0201" list(8868.000000 5406.000000) nil) | 6@@list("CB4124" "MX_C0201" list(9207.000000 4567.000000) nil) | 6@@list("CB4125" "MX_C0201" list(1706.000000 8130.000000) nil) | 6@@list("CB4126" "MX_C0201" list(1515.000000 6415.000000) nil) | 6@@list("CB4127" "MX_C0201" list(944.000000 5643.000000) nil) | 6@@list("CB4128" "MX_C0402_SMALL_T01" list(902.000000 5654.000000) nil) | 6@@list("CB4129" "MX_C0402_SMALL_T01" list(829.000000 5995.000000) nil) | 6@@list("CR17" "MX_R0402_SMALL_T01" list(1410.000000 7900.000000) nil) | 6@@list("CR19" "MX_R0402_SMALL_T01" list(1518.000000 7935.000000) nil) | 6@@list("CR2" "MX_LED_2P_63X31_H16" list(3746.000000 329.000000) nil) | 6@@list("CR25" "MX_LED_2P_63X31_H16" list(3931.000000 329.000000) nil) | 6@@list("CR26" "MX_LED_2P_63X31_H16" list(3871.000000 329.000000) nil) | 6@@list("CR27" "MX_LED_2P_63X31_H16" list(3807.000000 329.000000) nil) | 6@@list("CR7" "MX_LED_2P_63X31_H16" list(3989.000000 329.000000) nil) | 6@@list("CR9" "MX_LED_2P_63X31_EVER" list(4051.000000 329.000000) nil) | 6@@list("D20" "MX_SOT323" list(5253.750000 2516.750000) nil) | 6@@list("D4C1" "MX_C0402_SMALL_T01" list(8160.500000 7221.290000) nil) | 6@@list("D4C12" "MX_C0201" list(8145.000000 4235.000000) nil) | 6@@list("D4C13" "MX_C0201" list(8145.000000 9055.000000) nil) | 6@@list("D4C17" "MX_C0201" list(8181.000000 4235.000000) nil) | 6@@list("D4C18" "MX_C0201" list(8195.000000 9040.000000) nil) | 6@@list("D4C2" "MX_C0201" list(6875.000000 4195.000000) nil) | 6@@list("D4C21" "MX_C0603_SMALL_T01" list(7505.000000 8999.000000) nil) | 6@@list("D4C22" "MX_C0603_SMALL_T01" list(6785.000000 9030.000000) nil) | 6@@list("D4C23" "MX_C0603_SMALL_T01" list(8155.000000 8975.000000) nil) | 6@@list("D4C24" "MX_C0603_SMALL_T01" list(8205.000000 8975.000000) nil) | 6@@list("D4C3" "MX_C0201" list(6830.000000 9050.000000) nil) | 6@@list("D4C4" "MX_C0402_SMALL_T01" list(6805.000000 4065.000000) nil) | 6@@list("D4C5" "MX_C0402_SMALL_T01" list(6805.000000 4130.000000) nil) | 6@@list("D4C7" "MX_C0201" list(7505.000000 4200.000000) nil) | 6@@list("D4C8" "MX_C0201" list(7505.000000 9080.000000) nil) | 6@@list("D4CB1" "MX_C0603_SMALL_T01" list(6830.000000 6480.000000) nil) | 6@@list("D4CB10" "MX_C0201" list(7513.000000 6535.000000) nil) | 6@@list("D4CB11" "MX_C0201" list(8181.000000 4165.000000) nil) | 6@@list("D4CB12" "MX_C0201" list(8145.000000 4165.000000) nil) | 6@@list("D4CB13" "MX_C0603_SMALL_T01" list(8172.000000 6134.000000) nil) | 6@@list("D4CB14" "MX_C0201" list(8146.000000 6480.000000) nil) | 6@@list("D4CB15" "MX_C0201" list(8265.000000 4325.000000) nil) | 6@@list("D4CB16" "MX_C0201" list(8367.000000 4394.000000) nil) | 6@@list("D4CB17" "MX_C0402_SMALL_T01" list(8325.000000 6330.000000) nil) | 6@@list("D4CB18" "MX_C0402_SMALL_T01" list(8170.000000 7095.000000) nil) | 6@@list("D4CB19" "MX_C0402_SMALL_T01" list(6785.000000 7290.000000) nil) | 6@@list("D4CB2" "MX_C0201" list(6872.000000 6490.000000) nil) | 6@@list("D4CB20" "MX_C0402_SMALL_T01" list(7505.000000 6069.000000) nil) | 6@@list("D4CB21" "MX_C0603_SMALL_T02" list(7510.000000 6150.000000) nil) | 6@@list("D4CB22" "MX_C0603_SMALL_T02" list(7510.000000 6630.000000) nil) | 6@@list("D4CB23" "MX_C0603_SMALL_T02" list(8252.000000 6599.500000) nil) | 6@@list("D4CB24" "MX_C0603_SMALL_T02" list(8199.000000 6614.000000) nil) | 6@@list("D4CB25" "MX_C0201" list(8217.000000 6330.000000) nil) | 6@@list("D4CB26" "MX_C0603_SMALL_T02" list(6540.000000 7137.000000) nil) | 6@@list("D4CB27" "MX_C0402_SMALL_T01" list(6850.000000 6855.000000) nil) | 6@@list("D4CB28" "MX_C0603_SMALL_T02" list(6611.000000 6317.000000) nil) | 6@@list("D4CB29" "MX_C0603_SMALL_T02" list(7512.000000 6857.000000) nil) | 6@@list("D4CB3" "MX_C0201" list(6789.000000 3987.000000) nil) | 6@@list("D4CB30" "MX_C0603_SMALL_T02" list(8302.000000 6483.000000) nil) | 6@@list("D4CB31" "MX_C0603_SMALL_T02" list(6665.000000 6317.000000) nil) | 6@@list("D4CB32" "MX_C0603_SMALL_T02" list(8237.500000 6779.000000) nil) | 6@@list("D4CB33" "MX_C0402_SMALL_T01" list(8193.500000 6780.000000) nil) | 6@@list("D4CB34" "MX_C0402_SMALL_T01" list(6253.000000 6842.000000) nil) | 6@@list("D4CB35" "MX_C0402_SMALL_T01" list(8254.000000 6481.000000) nil) | 6@@list("D4CB36" "MX_C0402_SMALL_T01" list(8283.000000 6779.000000) nil) | 6@@list("D4CB37" "MX_C0402_SMALL_T01" list(6489.000000 7081.000000) nil) | 6@@list("D4CB38" "MX_C0603_SMALL_T02" list(8170.000000 6940.000000) nil) | 6@@list("D4CB39" "MX_C0603_SMALL_T02" list(8170.000000 6885.000000) nil) | 6@@list("D4CB4" "MX_C0201" list(6833.000000 3987.000000) nil) | 6@@list("D4CB40" "MX_C0603_SMALL_T02" list(6430.000000 7025.000000) nil) | 6@@list("D4CB41" "MX_C0603_SMALL_T02" list(8170.000000 6995.000000) nil) | 6@@list("D4CB48" "MX_C0402_SMALL_T01" list(5159.000000 6005.000000) nil) | 6@@list("D4CB49" "MX_C0402_SMALL_T01" list(8157.500000 6780.000000) nil) | 6@@list("D4CB5" "MX_C0603_SMALL_T01" list(8262.000000 6175.000000) nil) | 6@@list("D4CB50" "MX_C0402_SMALL_T01" list(7510.000000 7760.000000) nil) | 6@@list("D4CB51" "MX_C0402_SMALL_T01" list(6710.000000 6332.000000) nil) | 6@@list("D4CB52" "MX_C0402_SMALL_T01" list(7510.000000 8463.000000) nil) | 6@@list("D4CB53" "MX_C0402_SMALL_T01" list(7510.000000 8130.000000) nil) | 6@@list("D4CB54" "MX_C0402_SMALL_T01" list(7510.000000 6710.000000) nil) | 6@@list("D4CB55" "MX_C0402_SMALL_T01" list(7513.000000 7030.000000) nil) | 6@@list("D4CB57" "MX_C0201" list(8181.000000 6330.000000) nil) | 6@@list("D4CB58" "MX_C0201" list(7511.000000 7375.000000) nil) | 6@@list("D4CB59" "MX_C0201" list(8289.000000 6330.000000) nil) | 6@@list("D4CB6" "MX_C0201" list(8176.000000 6180.000000) nil) | 6@@list("D4CB60" "MX_C0201" list(7510.000000 5780.000000) nil) | 6@@list("D4CB61" "MX_C0201" list(8220.000000 6480.000000) nil) | 6@@list("D4CB62" "MX_C0201" list(7513.000000 7108.000000) nil) | 6@@list("D4CB63" "MX_C0603_SMALL_T02" list(6359.000000 6947.000000) nil) | 6@@list("D4CB64" "MX_C0201" list(6717.000000 7145.000000) nil) | 6@@list("D4CB65" "MX_C0201" list(8253.000000 6330.000000) nil) | 6@@list("D4CB66" "MX_C0402_SMALL_T01" list(6850.000000 7145.000000) nil) | 6@@list("D4CB67" "MX_C0402_SMALL_T01" list(6818.000000 6084.000000) nil) | 6@@list("D4CB68" "MX_C0402_SMALL_T01" list(6598.000000 7181.000000) nil) | 6@@list("D4CB69" "MX_C0201" list(8156.000000 6628.000000) nil) | 6@@list("D4CB7" "MX_C0201" list(7511.000000 4070.000000) nil) | 6@@list("D4CB70" "MX_C0201" list(7510.000000 5860.000000) nil) | 6@@list("D4CB71" "MX_C0603_SMALL_T02" list(6305.000000 6893.000000) nil) | 6@@list("D4CB72" "MX_C0201" list(7511.000000 5180.000000) nil) | 6@@list("D4CB73" "MX_C0201" list(7510.000000 5590.000000) nil) | 6@@list("D4CB74" "MX_C0201" list(7510.000000 6942.000000) nil) | 6@@list("D4CB75" "MX_C0201" list(8170.000000 6841.000000) nil) | 6@@list("D4CB76" "MX_C0201" list(7510.000000 8839.000000) nil) | 6@@list("D4CB77" "MX_C0201" list(7509.000000 5933.000000) nil) | 6@@list("D4CB78" "MX_C0201" list(6850.000000 6660.000000) nil) | 6@@list("D4CB8" "MX_C0201" list(7510.000000 3985.000000) nil) | 6@@list("D4CB86" "MX_C0402_SMALL_T01" list(8210.000000 9220.000000) nil) | 6@@list("D4CB87" "MX_C0402_SMALL_T01" list(6520.000000 8920.000000) nil) | 6@@list("D4CB88" "MX_C0603_SMALL_T02" list(5146.000000 6144.000000) nil) | 6@@list("D4CB89" "MX_C0603_SMALL_T02" list(5146.000000 6090.000000) nil) | 6@@list("D4CB9" "MX_C0603_SMALL_T01" list(8172.000000 6085.000000) nil) | 6@@list("D4R1" "MX_R0402_SMALL_T01" list(7510.000000 6232.000000) nil) | 6@@list("D4R10" "MX_R0402_SMALL_T01" list(7510.000000 6300.000000) nil) | 6@@list("D4R15" "MX_R0402_SMALL_T01" list(7510.000000 6375.000000) nil) | 6@@list("D4R20" "MX_R0402_SMALL_T01" list(8195.000000 9076.000000) nil) | 6@@list("D4R21" "MX_R0402_SMALL_T01" list(8145.000000 9160.000000) nil) | 6@@list("D4R24" "MX_R0402_SMALL_T01" list(8145.000000 6313.000000) nil) | 6@@list("D4R3" "MX_R0402_SMALL_T01" list(8160.500000 7185.280000) nil) | 6@@list("D4R30" "MX_R0402_SMALL_T01" list(8195.000000 9112.000000) nil) | 6@@list("D4R31" "MX_R0402_SMALL_T01" list(8160.000000 9235.000000) nil) | 6@@list("D4R32" "MX_R0402_SMALL_T01" list(6600.000000 8920.000000) nil) | 6@@list("D4R33" "MX_R0402_SMALL_T01" list(6740.000000 9022.000000) nil) | 6@@list("D4R34" "MX_R0402_SMALL_T01" list(6560.000000 8920.000000) nil) | 6@@list("D4R35" "MX_R0402_SMALL_T01" list(6480.000000 8920.000000) nil) | 6@@list("EC22" "MX_C0201" list(9065.000000 6755.000000) nil) | 6@@list("ECC55" "MX_C0402_SMALL_T01" list(5225.000000 3780.000000) nil) | 6@@list("ECC56" "MX_C0402_SMALL_T01" list(5093.000000 3641.000000) nil) | 6@@list("ECQ12" "MX_SOT23" list(4990.000000 3665.000000) nil) | 6@@list("ECQ13" "MX_SOT23" list(5232.000000 3684.000000) nil) | 6@@list("ECR101" "MX_R0402_SMALL_T01" list(8594.000000 768.000000) nil) | 6@@list("ECR104" "MX_R0402_SMALL_T01" list(8894.000000 995.500000) nil) | 6@@list("ECR105" "MX_R0402_SMALL_T01" list(5129.000000 3641.000000) nil) | 6@@list("ECR67" "MX_R0402_SMALL_T01" list(8068.000000 948.000000) nil) | 6@@list("ECR90" "MX_R0402_SMALL_T01" list(4880.000000 3700.000000) nil) | 6@@list("ECR92" "MX_R0402_SMALL_T01" list(5189.000000 3780.000000) nil) | 6@@list("ECR96" "MX_R0402_SMALL_T01" list(8758.500000 1705.000000) nil) | 6@@list("ECR97" "MX_R0402_SMALL_T01" list(8038.000000 986.000000) nil) | 6@@list("ECR98" "MX_R0402_SMALL_T01" list(8879.500000 1386.000000) nil) | 6@@list("F3CB1" "MX_C0402_SMALL_T01" list(7322.000000 348.240000) nil) | 6@@list("F3CB3" "MX_C0402_SMALL_T01" list(7019.500000 432.000000) nil) | 6@@list("F3CB4" "MX_C0201" list(6985.000000 435.000000) nil) | 6@@list("F3R10" "MX_R0402_SMALL_T01" list(7144.000000 365.000000) nil) | 6@@list("F3R12" "MX_R0402_SMALL_T01" list(6880.000000 191.000000) nil) | 6@@list("F3R13" "MX_R0402_SMALL_T01" list(7216.500000 365.000000) nil) | 6@@list("F3R14" "MX_R0402_SMALL_T01" list(7355.000000 915.000000) nil) | 6@@list("F3R20" "MX_R0402_SMALL_T01" list(7317.000000 915.000000) nil) | 6@@list("F3R21" "MX_R0402_SMALL_T01" list(7191.000000 870.000000) nil) | 6@@list("F3R3" "MX_R0402_SMALL_T01" list(6965.000000 341.000000) nil) | 6@@list("F3R4" "MX_R0402_SMALL_T01" list(7374.000000 365.000000) nil) | 6@@list("F3R6" "MX_R0402_SMALL_T01" list(6940.000000 510.000000) nil) | 6@@list("F3R7" "MX_R0402_SMALL_T01" list(7238.000000 870.000000) nil) | 6@@list("F3R8" "MX_R0402_SMALL_T01" list(7393.000000 832.510000) nil) | 6@@list("F3U1" "MX_SOIC_8P_50_213X311" list(7169.310000 587.520000) nil) | 6@@list("F3U2" "MX_SOIC_8P_50_197X236" list(1560.000000 7330.000000) nil) | 6@@list("FC13" "MX_C0805_SMALL_T02" list(733.000000 6047.000000) nil) | 6@@list("FC14" "MX_C0402_SMALL_T01" list(9235.000000 8587.000000) nil) | 6@@list("FC15" "MX_C0402_SMALL_T01" list(5481.000000 9393.000000) nil) | 6@@list("FC16" "MX_C0402_SMALL_T01" list(4519.000000 9365.000000) nil) | 6@@list("FC2" "MX_C0402_SMALL_T01" list(5131.000000 9193.000000) nil) | 6@@list("FC3" "MX_C0402_SMALL_T01" list(5340.000000 9230.000000) nil) | 6@@list("FC5" "MX_C0402_SMALL_T01" list(9217.000000 8887.000000) nil) | 6@@list("FC6" "MX_C0402_SMALL_T01" list(9156.000000 8924.000000) nil) | 6@@list("FC8" "MX_C0402_SMALL_T01" list(7559.800000 1969.500000) nil) | 6@@list("FCE1" "MX_C1206_H75" list(4442.000000 9336.000000) nil) | 6@@list("FCE4" "MX_C1206_H75" list(5651.000000 9359.000000) nil) | 6@@list("FCE5" "MX_C1206_H75" list(9155.000000 8703.000000) nil) | 6@@list("FD1" "MX_SOT323" list(5045.000000 9215.000000) nil) | 6@@list("FD10" "MX_SOT323" list(5970.000000 9213.000000) nil) | 6@@list("FD3" "MX_SOT323" list(4910.000000 9215.000000) nil) | 6@@list("FD7" "MX_SOT323" list(5722.000000 9166.000000) nil) | 6@@list("FD8" "MX_SOT323" list(9139.750000 9006.250000) nil) | 6@@list("FD9" "MX_SOT323" list(9121.750000 8857.750000) nil) | 6@@list("FR1" "MX_R0402_SMALL_T01" list(5380.000000 9230.000000) nil) | 6@@list("FR17" "MX_R0402_SMALL_T01" list(5340.000000 9165.000000) nil) | 6@@list("FR2" "MX_R0805_SMALL_T02" list(5280.000000 9206.000000) nil) | 6@@list("FR28" "MX_R0805_SMALL_T02" list(9223.000000 8977.000000) nil) | 6@@list("FR29" "MX_R0402_SMALL_T01" list(9092.000000 8924.000000) nil) | 6@@list("FR30" "MX_R0402_SMALL_T01" list(9225.000000 9052.000000) nil) | 6@@list("FR31" "MX_R0402_SMALL_T01" list(9072.000000 8990.000000) nil) | 6@@list("FR32" "MX_R0805_SMALL_T02" list(5845.000000 9225.000000) nil) | 6@@list("FR33" "MX_R0402_SMALL_T01" list(5680.000000 9232.000000) nil) | 6@@list("FR35" "MX_R0402_SMALL_T01" list(5640.000000 9182.000000) nil) | 6@@list("FR36" "MX_R0402_SMALL_T01" list(5146.000000 9246.000000) nil) | 6@@list("FR37" "MX_R0402_SMALL_T01" list(3615.500000 499.500000) nil) | 6@@list("FR8" "MX_R0402_SMALL_T01" list(5380.000000 9165.000000) nil) | 6@@list("GFX_Q1" "MX_SOT23" list(2632.000000 2907.000000) nil) | 6@@list("H1" "MX_HOLE_160_T_U_HP" list(1299.980000 9350.000000) nil) | 6@@list("H13" "MX_SMT_NUT_CT276B195D165" list(1443.720000 3542.560000) nil) | 6@@list("H14" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 2888.890000) nil) | 6@@list("H15" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 3676.290000) nil) | 6@@list("H16" "MX_SMT_N_CT299B196D166_H100" list(8596.790000 2180.230000) nil) | 6@@list("H2" "MX_HOLE_160_T_R_HP" list(9350.000000 3150.000000) nil) | 6@@list("H20" "MX_NUT_CT256BD146_H71" list(3763.810000 8731.590000) nil) | 6@@list("H21" "MX_NUT_CT256BD146_H71" list(2359.030000 8301.710000) nil) | 6@@list("H22" "MX_NUT_CT256BD146_H71" list(5858.300000 8731.590000) nil) | 6@@list("H23" "MX_NUT_CT256BD146_H71" list(2359.030000 5199.350000) nil) | 6@@list("H3" "MX_HOLE_160_T_U_HP" list(6500.000000 9350.000000) nil) | 6@@list("H4" "MX_HOLE_160_T_HP" list(6500.000000 3150.000000) nil) | 6@@list("H5" "MX_HOLE_160_T_HP" list(6500.000000 550.000000) nil) | 6@@list("H6" "MX_H_C315D189N_M2_P2_V8" list(9350.000000 9350.000000) nil) | 6@@list("H7" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 1350.000000) nil) | 6@@list("H8" "MX_HOLE_C315D189N_M2_P2_V8" list(400.000000 3150.000000) nil) | 6@@list("HC11" "MX_C0402_SMALL_T01" list(6986.000000 1121.000000) nil) | 6@@list("HC23" "MX_C0402_SMALL_T01" list(4013.000000 4646.000000) nil) | 6@@list("HC24" "MX_C0402_SMALL_T01" list(3672.000000 8126.500000) nil) | 6@@list("HC25" "MX_C0402_SMALL_T01" list(5220.000000 4446.000000) nil) | 6@@list("HC27" "MX_C0402_SMALL_T01" list(5109.000000 5986.000000) nil) | 6@@list("HC29" "MX_C0402_SMALL_T01" list(8116.000000 2116.000000) nil) | 6@@list("HC3" "MX_C0603_SMALL_T02" list(5164.000000 4589.000000) nil) | 6@@list("HC30" "MX_C0402_SMALL_T01" list(523.000000 2842.000000) nil) | 6@@list("HC31" "MX_C0402_SMALL_T01" list(241.000000 1645.000000) nil) | 6@@list("HC4" "MX_C0402_SMALL_T01" list(5068.000000 4612.120000) nil) | 6@@list("HC5" "MX_C0402_SMALL_T01" list(4005.000000 4795.000000) nil) | 6@@list("HR11" "MX_R0402_SMALL_T01" list(3875.000000 5580.000000) nil) | 6@@list("HR14" "MX_R0402_SMALL_T01" list(3875.500000 5708.000000) nil) | 6@@list("HR15" "MX_R0402_SMALL_T01" list(3875.500000 5672.000000) nil) | 6@@list("HR17" "MX_R0402_SMALL_T01" list(3524.000000 8207.000000) nil) | 6@@list("HR18" "MX_R0402_SMALL_T01" list(3600.000000 8127.000000) nil) | 6@@list("HR20" "MX_R0402_SMALL_T01" list(3564.000000 8127.000000) nil) | 6@@list("HR22" "MX_R0402_T01" list(3999.800000 4891.300000) nil) | 6@@list("HR23" "MX_R0402_SMALL_T01" list(3955.000000 4800.000000) nil) | 6@@list("HR24" "MX_R0402_SMALL_T01" list(3640.000000 8207.000000) nil) | 6@@list("HR25" "MX_R0402_SMALL_T01" list(3958.000000 4714.000000) nil) | 6@@list("HR26" "MX_R0402_SMALL_T01" list(3636.000000 8127.000000) nil) | 6@@list("HR27" "MX_R0402_SMALL_T01" list(4045.000000 4795.000000) nil) | 6@@list("HR28" "MX_R0402_SMALL_T01" list(6027.000000 1713.000000) nil) | 6@@list("HR29" "MX_R0402_SMALL_T01" list(4060.000000 4645.000000) nil) | 6@@list("HR31" "MX_R0402_SMALL_T01" list(4719.000000 6044.000000) nil) | 6@@list("HR32" "MX_R0402_SMALL_T01" list(3604.000000 8207.000000) nil) | 6@@list("HR33" "MX_R0402_SMALL_T01" list(3564.000000 8207.000000) nil) | 6@@list("HR36" "MX_R0402_SMALL_T01" list(3738.500000 4674.000000) nil) | 6@@list("HR4" "MX_R0402_SMALL_T01" list(4719.000000 6007.000000) nil) | 6@@list("HR6" "MX_R0402_SMALL_T01" list(4719.000000 5971.000000) nil) | 6@@list("HR615" "MX_R0402_SMALL_T01" list(3765.000000 4700.000000) nil) | 6@@list("HR616" "MX_R0402_SMALL_T01" list(3792.500000 4748.000000) nil) | 6@@list("HR617" "MX_R0402_SMALL_T01" list(3828.500000 4748.000000) nil) | 6@@list("HR618" "MX_R0402_SMALL_T01" list(3870.000000 4690.000000) nil) | 6@@list("HR619" "MX_R0402_SMALL_T01" list(4058.800000 4557.700000) nil) | 6@@list("HR620" "MX_R0402_SMALL_T01" list(3978.000000 4584.000000) nil) | 6@@list("HR621" "MX_R0402_SMALL_T01" list(3942.000000 4631.000000) nil) | 6@@list("HR622" "MX_R0402_SMALL_T01" list(3906.000000 4653.000000) nil) | 6@@list("HR626" "MX_R0402_SMALL_T01" list(3925.000000 4280.000000) nil) | 6@@list("HR627" "MX_R0402_SMALL_T01" list(7430.000000 1735.000000) nil) | 6@@list("HR629" "MX_R0402_SMALL_T01" list(7404.060000 1836.930000) nil) | 6@@list("HR630" "MX_R0402_SMALL_T01" list(4758.000000 4722.000000) nil) | 6@@list("HR631" "MX_R0402_SMALL_T01" list(5391.000000 8289.000000) nil) | 6@@list("HR78" "MX_R0402_SMALL_T01" list(4082.000000 4795.000000) nil) | 6@@list("HR86" "MX_R0402_SMALL_T01" list(4014.000000 4557.000000) nil) | 6@@list("HR9" "MX_R0402_SMALL_T01" list(3898.000000 5471.000000) nil) | 6@@list("J60" "MX_MINI_PCI_67P_4HD_COLAY" list(1443.730000 4652.000000) nil) | 6@@list("J_TYPEC" "A_USB_CON_2X12P_8HOLD_ACON" list(222.430000 5765.000000) nil) | 6@@list("L1" "MX_L0603_SMALL_T02" list(1595.000000 8285.000000) nil) | 6@@list("L2" "MX_L0603_SMALL_T02" list(1355.000000 8825.000000) nil) | 6@@list("LC10" "MX_C0402_SMALL_T01" list(1421.000000 8293.000000) nil) | 6@@list("LC12" "MX_C0402_SMALL_T01" list(1106.000000 8149.000000) nil) | 6@@list("LC18" "MX_C0402_SMALL_T01" list(1505.000000 8680.000000) nil) | 6@@list("LC4" "MX_C0402_SMALL_T01" list(1253.000000 8765.000000) nil) | 6@@list("LC44" "MX_C0402_SMALL_T01" list(980.000000 8665.000000) nil) | 6@@list("LC47" "MX_C0402_SMALL_T01" list(1585.000000 8470.000000) nil) | 6@@list("LC48" "MX_C0402_SMALL_T01" list(1585.000000 8506.000000) nil) | 6@@list("LC5" "MX_C0402_SMALL_T01" list(1179.000000 8765.000000) nil) | 6@@list("LC6" "MX_C0402_SMALL_T01" list(1223.000000 8140.000000) nil) | 6@@list("LC7" "MX_C0402_SMALL_T01" list(1650.000000 8652.000000) nil) | 6@@list("LC8" "MX_C0402_SMALL_T01" list(1020.000000 8665.000000) nil) | 6@@list("LC9" "MX_C0402_SMALL_T01" list(1457.000000 8293.000000) nil) | 6@@list("LCB10" "MX_C0201" list(1602.000000 8432.000000) nil) | 6@@list("LCB11" "MX_C0402_SMALL_T01" list(1185.000000 8685.000000) nil) | 6@@list("LCB12" "MX_C0201" list(1315.000000 8275.000000) nil) | 6@@list("LCB13" "MX_C0603_SMALL_T01" list(1595.000000 8353.000000) nil) | 6@@list("LCB14" "MX_C0201" list(1210.000000 8395.000000) nil) | 6@@list("LCB15" "MX_C0402_SMALL_T01" list(1187.000000 8543.000000) nil) | 6@@list("LCB16" "MX_C0603_SMALL_T01" list(1585.000000 8795.000000) nil) | 6@@list("LCB17" "MX_C0201" list(1574.000000 8676.000000) nil) | 6@@list("LCB18" "MX_C0402_SMALL_T01" list(1574.000000 8640.000000) nil) | 6@@list("LCB19" "MX_C0402_SMALL_T01" list(1602.000000 8395.000000) nil) | 6@@list("LCB2" "MX_C0402_SMALL_T01" list(1574.000000 8750.000000) nil) | 6@@list("LCB20" "MX_C0201" list(1315.000000 8315.000000) nil) | 6@@list("LCB21" "MX_C0201" list(1556.000000 8561.000000) nil) | 6@@list("LCB22" "MX_C0402_SMALL_T01" list(1612.000000 8565.000000) nil) | 6@@list("LCB3" "MX_C0603_SMALL_T01" list(1585.000000 8845.000000) nil) | 6@@list("LCB4" "MX_C0201" list(1223.000000 8485.000000) nil) | 6@@list("LCB5" "MX_C0402_SMALL_T01" list(1574.000000 8713.000000) nil) | 6@@list("LCB6" "MX_C0201" list(1515.000000 8336.000000) nil) | 6@@list("LCB7" "MX_C0201" list(1374.000000 8680.000000) nil) | 6@@list("LCB9" "MX_C0201" list(1515.000000 8300.000000) nil) | 6@@list("LR1" "MX_R0402_SMALL_T01" list(1505.000000 8794.000000) nil) | 6@@list("LR10" "MX_R0402_SMALL_T01" list(1375.000000 8290.000000) nil) | 6@@list("LR2" "MX_R0402_SMALL_T01" list(1407.000000 8794.500000) nil) | 6@@list("LR20" "MX_R0402_SMALL_T01" list(940.000000 8665.000000) nil) | 6@@list("LR22" "MX_R0402_SMALL_T01" list(1183.000000 8728.000000) nil) | 6@@list("LR23" "MX_R0402_SMALL_T01" list(1407.000000 8680.000000) nil) | 6@@list("LR24" "MX_R0402_SMALL_T01" list(1185.000000 8625.000000) nil) | 6@@list("LR3" "MX_R0402_SMALL_T01" list(1070.000000 8665.000000) nil) | 6@@list("LR4" "MX_R0603_SMALL_T01" list(1202.000000 8092.000000) nil) | 6@@list("LR5" "MX_R0603_SMALL_T01" list(1328.000000 8110.000000) nil) | 6@@list("LR6" "MX_R0402_SMALL_T01" list(1465.000000 8680.000000) nil) | 6@@list("LR9" "MX_R0402_SMALL_T01" list(1687.000000 8652.000000) nil) | 6@@list("M1C1" "MX_C0201" list(513.000000 6907.000000) nil) | 6@@list("M1C12" "MX_C0402_SMALL_T01" list(1400.000000 6896.000000) nil) | 6@@list("M1C13" "MX_C0402_SMALL_T01" list(1400.000000 6860.000000) nil) | 6@@list("M1C35" "MX_C0201" list(770.000000 6690.000000) nil) | 6@@list("M1D1" "MX_S0402_AMAZ_COLAY" list(660.000000 6710.000000) nil) | 6@@list("M1F1" "MX_POLYSWITCH_2P_0805_H30" list(693.500000 6923.000000) nil) | 6@@list("M1R11" "MX_R0402_SMALL_T01" list(1140.000000 6850.000000) nil) | 6@@list("M1R12" "MX_R0402_SMALL_T01" list(908.000000 6874.000000) nil) | 6@@list("M1R13" "MX_R0402_SMALL_T01" list(908.000000 6829.000000) nil) | 6@@list("M1R36" "MX_R0402_SMALL_T01" list(770.000000 6726.000000) nil) | 6@@list("M1R37" "MX_R0402_SMALL_T01" list(583.600000 6702.800000) nil) | 6@@list("M1R4" "MX_R0402_SMALL_T01" list(1534.000000 7035.000000) nil) | 6@@list("M1R40" "MX_R0402_SMALL_T01" list(5355.000000 3780.000000) nil) | 6@@list("M1R5" "MX_R0402_SMALL_T01" list(1440.000000 6975.000000) nil) | 6@@list("M1R8" "MX_R0402_SMALL_T01" list(1211.000000 6950.000000) nil) | 6@@list("M1U1" "MX_ESD_10P_20_98X39_NXP" list(621.000000 6459.000000) nil) | 6@@list("M1U2" "MX_ESD_10P_20_98X39_NXP" list(621.000000 6601.000000) nil) | 6@@list("M1U3" "MX_ESD_10P_20_98X39_NXP" list(1111.000000 7727.000000) nil) | 6@@list("M1U4" "MX_ESD_10P_20_98X39_NXP" list(986.180000 7147.240000) nil) | 6@@list("M1U5" "MX_ESD_10P_20_98X39_NXP" list(986.440000 7276.500000) nil) | 6@@list("M1U6" "MX_ESD_10P_20_98X39_NXP" list(442.000000 4688.000000) nil) | 6@@list("M1U7" "MX_ESD_10P_20_98X39_NXP" list(732.000000 4700.000000) nil) | 6@@list("M1U8" "MX_ESD_10P_20_98X39_NXP" list(1012.000000 8507.000000) nil) | 6@@list("M1U9" "MX_ESD_10P_20_98X39_NXP" list(1114.000000 8336.000000) nil) | 6@@list("M2C1" "MX_C0603_SMALL_T02" list(2002.500000 4556.000000) nil) | 6@@list("M2C13" "MX_C0603_SMALL_T02" list(8007.000000 628.000000) nil) | 6@@list("M2C14" "MX_C0201" list(8816.000000 784.210000) nil) | 6@@list("M2C15" "MX_C0402_SMALL_T01" list(8851.920000 784.210000) nil) | 6@@list("M2C16" "MX_C0603_SMALL_T02" list(8007.000000 575.000000) nil) | 6@@list("M2C17" "MX_C0201" list(8921.790000 783.960000) nil) | 6@@list("M2C18" "MX_C0402_SMALL_T01" list(8958.000000 784.000000) nil) | 6@@list("M2C19" "MX_C0603_SMALL_T02" list(8754.000000 778.000000) nil) | 6@@list("M2C2" "MX_C0201" list(982.000000 4598.000000) nil) | 6@@list("M2C20" "MX_C0201" list(8112.000000 695.000000) nil) | 6@@list("M2C21" "MX_C0402_SMALL_T01" list(8014.000000 676.000000) nil) | 6@@list("M2C22" "MX_C0402_SMALL_T01" list(8517.430000 339.530000) nil) | 6@@list("M2C23" "MX_C0402_SMALL_T01" list(8481.430000 339.530000) nil) | 6@@list("M2C24" "MX_C0402_SMALL_T01" list(8598.870000 340.530000) nil) | 6@@list("M2C25" "MX_C0402_SMALL_T01" list(8634.870000 340.530000) nil) | 6@@list("M2C26" "MX_C0402_SMALL_T01" list(8716.020000 340.530000) nil) | 6@@list("M2C27" "MX_C0402_SMALL_T01" list(8752.020000 340.530000) nil) | 6@@list("M2C28" "MX_C0402_SMALL_T01" list(8836.360000 340.530000) nil) | 6@@list("M2C29" "MX_C0402_SMALL_T01" list(8872.360000 340.530000) nil) | 6@@list("M2C3" "MX_C0402_SMALL_T01" list(910.000000 4597.000000) nil) | 6@@list("M2C4" "MX_C0603_SMALL_T02" list(866.000000 4171.000000) nil) | 6@@list("M2C40" "MX_C0402_SMALL_T01" list(1939.000000 4822.000000) nil) | 6@@list("M2C41" "MX_C0402_SMALL_T01" list(1939.000000 4861.000000) nil) | 6@@list("M2C44" "MX_C0402_SMALL_T01" list(8361.000000 325.000000) nil) | 6@@list("M2C46" "MX_C0402_SMALL_T01" list(2008.000000 4637.000000) nil) | 6@@list("M2C47" "MX_C0402_SMALL_T01" list(2008.000000 4683.000000) nil) | 6@@list("M2C48" "MX_C0402_SMALL_T01" list(2097.000000 4671.000000) nil) | 6@@list("M2C49" "MX_C0402_SMALL_T01" list(1958.000000 4598.000000) nil) | 6@@list("M2C5" "MX_C0201" list(1922.000000 4598.000000) nil) | 6@@list("M2C50" "MX_C0402_SMALL_T01" list(878.000000 4219.000000) nil) | 6@@list("M2C51" "MX_C0402_SMALL_T01" list(8070.000000 693.000000) nil) | 6@@list("M2C52" "MX_C0402_SMALL_T01" list(8119.000000 551.000000) nil) | 6@@list("M2C53" "MX_C0402_SMALL_T01" list(1939.000000 4765.000000) nil) | 6@@list("M2C54" "MX_C0402_SMALL_T01" list(8252.000000 325.000000) nil) | 6@@list("M2C55" "MX_C0402_SMALL_T01" list(8079.000000 552.000000) nil) | 6@@list("M2C6" "MX_C0402_SMALL_T01" list(946.000000 4598.000000) nil) | 6@@list("M2R1" "MX_R0402_SMALL_T01" list(8180.000000 325.000000) nil) | 6@@list("M2R33" "MX_R0402_SMALL_T01" list(8216.000000 325.000000) nil) | 6@@list("M2R34" "MX_R0402_SMALL_T01" list(8288.000000 325.000000) nil) | 6@@list("M2R36" "MX_R0402_SMALL_T01" list(8325.000000 325.000000) nil) | 6@@list("M2R39" "MX_R0402_SMALL_T01" list(1267.000000 4954.000000) nil) | 6@@list("M2R4" "MX_R0402_SMALL_T01" list(1730.000000 4960.000000) nil) | 6@@list("M2R40" "MX_R0402_SMALL_T01" list(2487.000000 2959.000000) nil) | 6@@list("M2R41" "MX_R0402_SMALL_T01" list(2510.000000 2160.000000) nil) | 6@@list("M2R43" "MX_R0402_SMALL_T01" list(2498.000000 1364.000000) nil) | 6@@list("M2R44" "MX_R0402_SMALL_T01" list(2451.000000 625.000000) nil) | 6@@list("M2R46" "MX_R0402_SMALL_T01" list(1939.000000 4685.000000) nil) | 6@@list("M2R47" "MX_R0402_SMALL_T01" list(1939.000000 4649.000000) nil) | 6@@list("M2R52" "MX_R0402_SMALL_T01" list(907.000000 6065.000000) nil) | 6@@list("M2R54" "MX_R0402_SMALL_T01" list(1695.000000 4960.000000) nil) | 6@@list("MQ10" "MX_SOT363" list(1300.000000 6895.000000) nil) | 6@@list("MQ12" "MX_SOT363" list(1035.000000 6880.000000) nil) | 6@@list("MQ15" "MX_SOT23_H43" list(619.000000 6808.000000) nil) | 6@@list("MQ18" "MX_SOT23_H43" list(1440.000000 8100.000000) nil) | 6@@list("MQ19" "MX_SOT363" list(8978.620000 3176.900000) nil) | 6@@list("MQ20" "MX_SOT363" list(8740.000000 4259.000000) nil) | 6@@list("MQ21" "MX_SOT363" list(5138.100000 4356.620000) nil) | 6@@list("MQ22" "MX_SOT23_H43" list(870.000000 9056.000000) nil) | 6@@list("MQ23" "MX_SOT23_2D4_H43" list(800.000000 9194.000000) nil) | 6@@list("MQ24" "MX_SOT363" list(8240.000000 8490.000000) nil) | 6@@list("MQ25" "MX_SOT363" list(8996.000000 6048.000000) nil) | 6@@list("MQ26" "MX_SOT363" list(8950.000000 7870.000000) nil) | 6@@list("MQ28" "MX_SOT363" list(8110.000000 1905.000000) nil) | 6@@list("MQ29" "MX_SOT363" list(5425.000000 3715.000000) nil) | 6@@list("MQ34" "MX_SOT363" list(8903.000000 4268.000000) nil) | 6@@list("MQ35" "MX_SOT363" list(8304.640000 1999.100000) nil) | 6@@list("MQ36" "MX_SOT363" list(8837.260000 4843.790000) nil) | 6@@list("MQ4" "MX_SOT23_2D4_H44" list(913.000000 6611.000000) nil) | 6@@list("MQ8" "MX_SOT363" list(1540.000000 6960.000000) nil) | 6@@list("MR41" "MX_R0402_SMALL_T01" list(515.000000 6770.000000) nil) | 6@@list("O2C1" "MX_C0402_SMALL_T01" list(8915.000000 1159.000000) nil) | 6@@list("O2C2" "MX_C0402_SMALL_T01" list(2637.000000 2802.000000) nil) | 6@@list("O2C4" "MX_C0402_SMALL_T01" list(8966.000000 2946.000000) nil) | 6@@list("O2C5" "MX_C0402_SMALL_T01" list(8884.000000 1115.000000) nil) | 6@@list("O2CB1" "MX_C0201" list(8040.000000 1167.000000) nil) | 6@@list("O2CB10" "MX_C0201" list(8671.000000 865.000000) nil) | 6@@list("O2CB11" "MX_C0201" list(8635.000000 870.000000) nil) | 6@@list("O2CB12" "MX_C0402_SMALL_T01" list(8039.000000 1094.000000) nil) | 6@@list("O2CB15" "MX_C0402_SMALL_T01" list(8910.000000 959.500000) nil) | 6@@list("O2CB16" "MX_C0201" list(8834.000000 870.000000) nil) | 6@@list("O2CB17" "MX_C0201" list(8540.000000 1705.000000) nil) | 6@@list("O2CB19" "MX_C0201" list(8950.000000 1283.000000) nil) | 6@@list("O2CB2" "MX_C0201" list(8870.000000 870.000000) nil) | 6@@list("O2CB20" "MX_C0201" list(8889.000000 1235.000000) nil) | 6@@list("O2CB3" "MX_C0201" list(8764.000000 1655.000000) nil) | 6@@list("O2CB4" "MX_C0201" list(8853.000000 1235.000000) nil) | 6@@list("O2CB5" "MX_C0201" list(8877.140000 1458.730000) nil) | 6@@list("O2CB6" "MX_C0201" list(8877.140000 1494.730000) nil) | 6@@list("O2CB7" "MX_C0201" list(8580.000000 870.000000) nil) | 6@@list("O2CB8" "MX_C0201" list(8181.000000 868.000000) nil) | 6@@list("O2Q6" "MX_SOT363_PHILIPS" list(8645.000000 1815.000000) nil) | 6@@list("O2R1" "MX_R0402_SMALL_T01" list(8743.000000 865.000000) nil) | 6@@list("O2R10" "MX_R0402_SMALL_T01" list(8910.000000 923.000000) nil) | 6@@list("O2R11" "MX_R0402_SMALL_T01" list(8675.000000 1885.000000) nil) | 6@@list("O2R2" "MX_R0402_SMALL_T01" list(8986.000000 1283.000000) nil) | 6@@list("O2R20" "MX_R0402_SMALL_T01" list(8577.000000 1705.000000) nil) | 6@@list("O2R21" "MX_R0402_SMALL_T01" list(8120.000000 1805.000000) nil) | 6@@list("O2R22" "MX_R0402_SMALL_T01" list(9006.000000 1333.000000) nil) | 6@@list("O2R3" "MX_R0402_SMALL_T01" list(8536.000000 1892.000000) nil) | 6@@list("O2R5" "MX_R0402_SMALL_T01" list(8879.500000 1422.000000) nil) | 6@@list("O2R8" "MX_R0402_SMALL_T01" list(8600.000000 1892.000000) nil) | 6@@list("O3R5" "MX_R0402_SMALL_T01" list(2357.000000 418.810000) nil) | 6@@list("OR22" "MX_R0402_SMALL_T01" list(8040.000000 1218.000000) nil) | 6@@list("OR29" "MX_R0402_SMALL_T01" list(7973.000000 989.000000) nil) | 6@@list("OR3" "MX_R0402_SMALL_T01" list(8797.000000 865.000000) nil) | 6@@list("OR34" "MX_R0402_SMALL_T01" list(8040.000000 1058.000000) nil) | 6@@list("OR35" "MX_R0402_SMALL_T01" list(8039.500000 1354.000000) nil) | 6@@list("OR37" "MX_R0402_SMALL_T01" list(8536.000000 1793.500000) nil) | 6@@list("OR44" "MX_R0402_SMALL_T01" list(8038.000000 1022.000000) nil) | 6@@list("OR5" "MX_R0402_SMALL_T01" list(8475.000000 768.000000) nil) | 6@@list("OR51" "MX_R0402_SMALL_T01" list(8181.000000 2116.000000) nil) | 6@@list("OR52" "MX_R0402_SMALL_T01" list(8180.000000 1935.000000) nil) | 6@@list("OR53" "MX_R0402_SMALL_T01" list(8358.000000 1705.000000) nil) | 6@@list("OR56" "MX_R0402_SMALL_T01" list(8686.000000 1704.500000) nil) | 6@@list("OR57" "MX_R0402_SMALL_T01" list(8614.000000 1704.500000) nil) | 6@@list("OR59" "MX_R0402_SMALL_T01" list(8943.000000 1387.000000) nil) | 6@@list("OR6" "TX_R0402" list(8475.000000 804.000000) nil) | 6@@list("OR60" "MX_R0402_SMALL_T01" list(8395.000000 1705.000000) nil) | 6@@list("OR61" "MX_R0402_SMALL_T01" list(8467.000000 1705.000000) nil) | 6@@list("OR65" "MX_R0402_SMALL_T01" list(8180.000000 1870.000000) nil) | 6@@list("OR68" "MX_R0402_SMALL_T01" list(8392.000000 1946.000000) nil) | 6@@list("OR69" "MX_R0402_SMALL_T01" list(8339.000000 1929.000000) nil) | 6@@list("OR70" "MX_R0402_SMALL_T01" list(8059.000000 290.200000) nil) | 6@@list("P118" "MX_FPC_12P_20_2HD_ACES_B" list(7695.000000 250.000000) nil) | 6@@list("P1C2" "MX_C0402_SMALL_T01" list(9255.000000 5835.000000) nil) | 6@@list("P1CB1" "MX_C0402_SMALL_T01" list(9050.000000 7645.000000) nil) | 6@@list("P1CB10" "MX_C0402_SMALL_T01" list(2470.000000 8620.000000) nil) | 6@@list("P1CB11" "MX_C0402_SMALL_T01" list(2470.000000 8660.000000) nil) | 6@@list("P1CB12" "MX_C0402_SMALL_T01" list(9063.000000 6545.000000) nil) | 6@@list("P1CB13" "MX_C1206_H75" list(1963.000000 7933.000000) nil) | 6@@list("P1CB14" "MX_C1206_H75" list(2015.000000 6436.000000) nil) | 6@@list("P1CB15" "MX_C1206_H75" list(2015.000000 6336.000000) nil) | 6@@list("P1CB16" "MX_C1206_H75" list(1966.000000 7192.000000) nil) | 6@@list("P1CB17" "MX_C0402_SMALL_T01" list(2470.000000 8582.000000) nil) | 6@@list("P1CB2" "MX_C0201" list(9029.000000 7335.000000) nil) | 6@@list("P1CB3" "MX_C0201" list(9050.000000 7915.000000) nil) | 6@@list("P1CB4" "MX_C0201" list(9042.000000 5954.000000) nil) | 6@@list("P1CB5" "MX_C0402_SMALL_T01" list(9063.000000 6421.000000) nil) | 6@@list("P1CB8" "MX_C0402_SMALL_T01" list(9042.000000 5918.000000) nil) | 6@@list("P1R1" "MX_R0402_SMALL_T01" list(9065.000000 6625.000000) nil) | 6@@list("P1R2" "MX_R0402_SMALL_T01" list(9255.000000 5755.000000) nil) | 6@@list("P1R3" "MX_R0402_SMALL_T01" list(9254.990000 5795.000000) nil) | 6@@list("P1R4" "MX_R0402_SMALL_T01" list(9065.000000 6690.000000) nil) | 6@@list("PC10" "MX_C0603_SMALL_T02" list(4835.760000 6573.000000) nil) | 6@@list("PC118" "MX_C0805_SMALL_T02" list(8295.000000 5055.000000) nil) | 6@@list("PC121" "MX_C0402_SMALL_T01" list(2058.000000 4870.000000) nil) | 6@@list("PC122" "MX_C0402_SMALL_T01" list(8395.000000 5061.000000) nil) | 6@@list("PC126" "MX_C0402_SMALL_T01" list(8443.000000 4915.000000) nil) | 6@@list("PC13" "MX_C0201" list(2178.000000 4790.000000) nil) | 6@@list("PC131" "MX_C0603_SMALL_T01" list(8426.620000 5241.240000) nil) | 6@@list("PC132" "MX_C0603_SMALL_T01" list(9405.620000 8325.960000) nil) | 6@@list("PC133" "MX_C0402_SMALL_T01" list(5349.000000 4312.000000) nil) | 6@@list("PC137" "MX_C1206_H75" list(2604.000000 5081.000000) nil) | 6@@list("PC138" "MX_C1206_H75" list(2598.000000 5280.000000) nil) | 6@@list("PC142" "MX_C0603_SMALL_T02" list(3112.000000 5339.000000) nil) | 6@@list("PC149" "MX_C0603_SMALL_T02" list(5047.000000 5980.000000) nil) | 6@@list("PC15" "MX_C0603_SMALL_T01" list(4855.000000 3830.000000) nil) | 6@@list("PC150" "MX_C0603_SMALL_T01" list(5275.000000 4000.000000) nil) | 6@@list("PC151" "MX_C0603_SMALL_T01" list(5060.000000 3895.000000) nil) | 6@@list("PC152" "MX_C0402_SMALL_T01" list(5319.000000 3780.000000) nil) | 6@@list("PC153" "MX_C0402_SMALL_T01" list(4925.000000 4060.000000) nil) | 6@@list("PC154" "MX_C0402_SMALL_T01" list(5115.000000 3765.000000) nil) | 6@@list("PC155" "MX_C0402_SMALL_T01" list(5170.000000 3895.000000) nil) | 6@@list("PC156" "MX_C0603_SMALL_T02" list(4835.000000 3970.000000) nil) | 6@@list("PC157" "MX_C0603_SMALL_T02" list(4780.000000 3970.000000) nil) | 6@@list("PC158" "MX_C0402_SMALL_T01" list(5190.000000 3845.000000) nil) | 6@@list("PC159" "MX_C0402_SMALL_T01" list(5185.000000 3950.000000) nil) | 6@@list("PC160" "MX_C0402_SMALL_T01" list(4926.000000 3910.000000) nil) | 6@@list("PC161" "MX_C0603_SMALL_T02" list(4965.000000 4268.000000) nil) | 6@@list("PC162" "MX_C0603_SMALL_T02" list(4965.000000 4320.000000) nil) | 6@@list("PC163" "MX_C0603_SMALL_T02" list(4780.000000 6000.000000) nil) | 6@@list("PC164" "MX_C0603_SMALL_T02" list(4835.000000 6000.000000) nil) | 6@@list("PC193" "MX_C0603_SMALL_T02" list(8269.000000 4423.000000) nil) | 6@@list("PC194" "MX_C0603_SMALL_T02" list(8432.000000 4405.000000) nil) | 6@@list("PC205" "MX_C1206" list(7950.000000 3732.000000) nil) | 6@@list("PC206" "MX_C1206" list(7950.000000 3636.000000) nil) | 6@@list("PC207" "MX_C0805_SMALL_T02" list(7905.000000 3550.000000) nil) | 6@@list("PC208" "MX_C0603_SMALL_T01" list(8681.000000 4392.000000) nil) | 6@@list("PC209" "MX_C0402_SMALL_T01" list(7458.000000 3601.000000) nil) | 6@@list("PC210" "MX_C0603_SMALL_T01" list(7713.000000 3623.000000) nil) | 6@@list("PC211" "MX_C0402_SMALL_T01" list(8127.870000 3516.920000) nil) | 6@@list("PC212" "MX_C0603_SMALL_T01" list(7705.000000 3550.000000) nil) | 6@@list("PC213" "MX_C0603_SMALL_T01" list(7972.000000 2571.000000) nil) | 6@@list("PC214" "MX_C0603" list(8155.000000 3410.000000) nil) | 6@@list("PC215" "MX_C0402_SMALL_T01" list(7970.000000 3250.000000) nil) | 6@@list("PC217" "MX_C0402_SMALL_T01" list(7448.000000 3529.000000) nil) | 6@@list("PC218" "MX_C0603_SMALL_T01" list(7379.000000 3575.000000) nil) | 6@@list("PC231" "MX_C0201" list(9062.000000 6320.000000) nil) | 6@@list("PC232" "MX_C0603_SMALL_T01" list(8975.000000 6520.000000) nil) | 6@@list("PC233" "MX_C0603_SMALL_T01" list(8990.000000 7490.000000) nil) | 6@@list("PC234" "MX_C0201" list(8905.000000 7700.000000) nil) | 6@@list("PC236" "MX_C0603_SMALL_T01" list(8900.000000 7490.000000) nil) | 6@@list("PC238" "MX_C0201" list(9065.000000 7335.000000) nil) | 6@@list("PC239" "MX_C0603_SMALL_T02" list(8855.000000 6520.000000) nil) | 6@@list("PC240" "MX_C0603_SMALL_T02" list(8855.000000 6465.000000) nil) | 6@@list("PC241" "MX_C0402_SMALL_T01" list(9045.000000 7265.000000) nil) | 6@@list("PC242" "MX_C0402_SMALL_T01" list(9220.000000 8010.880000) nil) | 6@@list("PC243" "MX_C0805_SMALL_T02" list(9327.000000 8099.000000) nil) | 6@@list("PC247" "MX_C0402_SMALL_T01" list(8980.000000 6440.000000) nil) | 6@@list("PC272" "MX_C0603_SMALL_T02" list(5112.000000 4589.000000) nil) | 6@@list("PC273" "MX_C0603_SMALL_T02" list(5176.000000 4480.380000) nil) | 6@@list("PC274" "MX_C0603_SMALL_T01" list(4869.000000 4604.000000) nil) | 6@@list("PC329" "MX_C0603_SMALL_T02" list(4908.000000 6035.000000) nil) | 6@@list("PC331" "MX_C0603_SMALL_T02" list(4908.000000 5980.000000) nil) | 6@@list("PC339" "MX_C0402_SMALL_T01" list(8569.500000 5722.000000) nil) | 6@@list("PC341" "MX_C0805_SMALL_T02" list(8570.000000 5359.000000) nil) | 6@@list("PC343" "MX_C0402_SMALL_T01" list(8075.000000 3350.000000) nil) | 6@@list("PC4" "MX_C0603_SMALL_T02" list(4730.000000 6570.000000) nil) | 6@@list("PC481" "MX_C0603_SMALL_T02" list(7512.000000 6457.000000) nil) | 6@@list("PC483" "MX_C0603_SMALL" list(8380.000000 6148.000000) nil) | 6@@list("PC484" "MX_C0402_SMALL_T01" list(8182.000000 5716.000000) nil) | 6@@list("PC485" "MX_C0402_SMALL_T01" list(8234.000000 6105.000000) nil) | 6@@list("PC486" "MX_C0402_SMALL_T01" list(8594.000000 6204.000000) nil) | 6@@list("PC566" "MX_C0402_SMALL_T01" list(4725.000000 2210.000000) nil) | 6@@list("PC567" "MX_C0402_SMALL_T01" list(4536.800000 2089.900000) nil) | 6@@list("PC568" "MX_C0603_SMALL_T01" list(4578.000000 1955.000000) nil) | 6@@list("PC569" "MX_C0201" list(4579.000000 2210.000000) nil) | 6@@list("PC570" "MX_C0201" list(4616.000000 2210.000000) nil) | 6@@list("PC5801" "MX_C0201" list(2860.000000 8240.000000) nil) | 6@@list("PC5802" "MX_C0603_SMALL_T01" list(2885.000000 8335.000000) nil) | 6@@list("PC5803" "MX_C0603_SMALL_T01" list(2965.000000 8332.000000) nil) | 6@@list("PC5804" "MX_C0201" list(2995.000000 8215.000000) nil) | 6@@list("PC5805" "MX_C0603_SMALL_T01" list(2873.000000 8458.000000) nil) | 6@@list("PC5806" "MX_C0201" list(2788.000000 8405.000000) nil) | 6@@list("PC5807" "MX_C0603_SMALL_T01" list(3027.500000 8885.000000) nil) | 6@@list("PC5808" "MX_C0201" list(2988.000000 9005.000000) nil) | 6@@list("PC5809" "MX_C0603_SMALL_T01" list(3081.500000 8885.000000) nil) | 6@@list("PC5810" "MX_C0201" list(3096.000000 9005.000000) nil) | 6@@list("PC5811" "MX_C0603_SMALL_T01" list(3085.000000 8334.000000) nil) | 6@@list("PC5812" "MX_C0201" list(3036.000000 8217.000000) nil) | 6@@list("PC5813" "MX_C0402_SMALL_T01" list(2880.000000 8600.000000) nil) | 6@@list("PC5814" "MX_C0201" list(3559.000000 8755.000000) nil) | 6@@list("PC5815" "MX_C0402_SMALL_T01" list(3265.000000 8320.000000) nil) | 6@@list("PC5816" "MX_C0402_SMALL_T01" list(3170.000000 8400.000000) nil) | 6@@list("PC5817" "MX_C0402_SMALL_T01" list(3222.000000 8245.000000) nil) | 6@@list("PC5818" "MX_C0402_SMALL_T01" list(3150.000000 8245.000000) nil) | 6@@list("PC5819" "MX_C0402_SMALL_T01" list(3250.000000 8380.000000) nil) | 6@@list("PC5820" "MX_C0402_SMALL_T01" list(3272.500000 8900.000000) nil) | 6@@list("PC5821" "MX_C0402_SMALL_T01" list(3150.000000 8990.000000) nil) | 6@@list("PC5822" "MX_C0402_SMALL_T01" list(3225.000000 9007.000000) nil) | 6@@list("PC5823" "MX_C0402_SMALL_T01" list(3175.000000 8850.000000) nil) | 6@@list("PC5824" "MX_C0402_SMALL_T01" list(3240.000000 8850.000000) nil) | 6@@list("PC5825" "C0201" list(2793.000000 8550.000000) nil) | 6@@list("PC5826" "C0201" list(2865.000000 8940.000000) nil) | 6@@list("PC5827" "MX_C0603_SMALL_T01" list(3498.000000 8664.000000) nil) | 6@@list("PC5828" "MX_C0402_SMALL_T01" list(3400.000000 8881.000000) nil) | 6@@list("PC5829" "MX_C0603_SMALL_T01" list(3335.000000 8870.000000) nil) | 6@@list("PC5830" "MX_C0402_SMALL_T01" list(2865.000000 8730.000000) nil) | 6@@list("PC5901" "MX_C0603_SMALL_T01" list(2820.000000 7231.000000) nil) | 6@@list("PC5902" "MX_C0402_SMALL_T01" list(2514.000000 7203.000000) nil) | 6@@list("PC5903" "MX_C0603_SMALL_T01" list(2720.000000 7439.000000) nil) | 6@@list("PC5904" "MX_C0603_SMALL_T02" list(2910.000000 6838.000000) nil) | 6@@list("PC5905" "MX_C0402_SMALL_T01" list(2586.000000 7203.000000) nil) | 6@@list("PC5906" "MX_C0402_SMALL_T01" list(2580.000000 6770.000000) nil) | 6@@list("PC5907" "MX_C0402_SMALL_T01" list(2325.000000 6830.000000) nil) | 6@@list("PC5908" "MX_C0402_SMALL_T01" list(2550.000000 6831.990000) nil) | 6@@list("PC5909" "MX_C0402_SMALL_T01" list(2585.000000 7895.000000) nil) | 6@@list("PC5910" "MX_C0402_SMALL_T01" list(2581.000000 7458.000000) nil) | 6@@list("PC5911" "MX_C0402_SMALL_T01" list(2513.000000 7895.000000) nil) | 6@@list("PC5912" "MX_C0402_SMALL_T01" list(2340.000000 7525.000000) nil) | 6@@list("PC5913" "MX_C0402_SMALL_T01" list(2585.000000 7525.000000) nil) | 6@@list("PC5914" "MX_C0603_SMALL_T02" list(2940.000000 7526.000000) nil) | 6@@list("PC5915" "MX_C0603_SMALL_T01" list(2650.000000 7955.000000) nil) | 6@@list("PC5916" "MX_C0603_SMALL_T01" list(2540.000000 8115.000000) nil) | 6@@list("PC5917" "MX_C1206_H75" list(1966.000000 7349.000000) nil) | 6@@list("PC5918" "MX_C1206_H75" list(1966.000000 7445.000000) nil) | 6@@list("PC5919" "MX_C1206_H75" list(1962.000000 7675.000000) nil) | 6@@list("PC5920" "MX_C1206_H75" list(1962.000000 7771.000000) nil) | 6@@list("PC601" "MX_C0402_SMALL_T01" list(2588.530000 6515.000000) nil) | 6@@list("PC602" "MX_C0402_SMALL_T01" list(2583.000000 6074.000000) nil) | 6@@list("PC603" "MX_C0402_SMALL_T01" list(2516.530000 6515.000000) nil) | 6@@list("PC604" "MX_C0402_SMALL_T01" list(2553.000000 6140.530000) nil) | 6@@list("PC605" "MX_C0402_SMALL_T01" list(2325.000000 6140.000000) nil) | 6@@list("PC606" "MX_C0603_SMALL_T02" list(2908.000000 6145.000000) nil) | 6@@list("PC607" "MX_C0603_SMALL_T01" list(2805.000000 6545.000000) nil) | 6@@list("PC608" "MX_C0603_SMALL_T01" list(2690.000000 6691.000000) nil) | 6@@list("PC609" "MX_C0402_SMALL_T01" list(2587.000000 5814.000000) nil) | 6@@list("PC610" "MX_C0402_SMALL_T01" list(2594.000000 5391.000000) nil) | 6@@list("PC6101" "MX_C0402_SMALL_T01" list(4485.000000 8835.000000) nil) | 6@@list("PC6102" "MX_C0402_SMALL_T01" list(4530.000000 8835.000000) nil) | 6@@list("PC6103" "MX_C0402_SMALL_T01" list(4730.000000 8599.000000) nil) | 6@@list("PC6104" "MX_C0402_SMALL_T01" list(4265.000000 8955.000000) nil) | 6@@list("PC6105" "MX_C0402_SMALL_T01" list(4070.000000 8940.000000) nil) | 6@@list("PC6106" "MX_C0603_SMALL_T02" list(4280.000000 7935.000000) nil) | 6@@list("PC6107" "MX_C0603_SMALL_T01" list(3880.000000 9005.000000) nil) | 6@@list("PC6108" "MX_C0603_SMALL_T01" list(3648.000000 8921.000000) nil) | 6@@list("PC6109" "MX_C0402_SMALL_T01" list(5320.000000 8830.000000) nil) | 6@@list("PC611" "MX_C0402_SMALL_T01" list(2515.000000 5814.000000) nil) | 6@@list("PC6110" "MX_C0402_SMALL_T01" list(5362.000000 8830.000000) nil) | 6@@list("PC6111" "MX_C0402_SMALL_T01" list(5575.000000 8600.000000) nil) | 6@@list("PC6112" "MX_C0402_SMALL_T01" list(4880.000000 8940.000000) nil) | 6@@list("PC6113" "MX_C0402_SMALL_T01" list(5110.000000 8955.000000) nil) | 6@@list("PC6114" "MX_C0603_SMALL_T02" list(4860.000000 7935.000000) nil) | 6@@list("PC6115" "MX_C0603_SMALL_T01" list(5885.000000 8914.000000) nil) | 6@@list("PC6116" "MX_C0603_SMALL_T01" list(5694.000000 9003.000000) nil) | 6@@list("PC6117" "MX_C1206_H75" list(4509.000000 8963.000000) nil) | 6@@list("PC6118" "MX_C1206_H75" list(4691.000000 9210.000000) nil) | 6@@list("PC6119" "MX_C1206_H75" list(5527.000000 9138.000000) nil) | 6@@list("PC612" "MX_C0402_SMALL_T01" list(2325.000000 5444.000000) nil) | 6@@list("PC6120" "MX_C1206_H75" list(5351.000000 8974.000000) nil) | 6@@list("PC613" "MX_C0402_SMALL_T01" list(2546.000000 5444.530000) nil) | 6@@list("PC614" "MX_C0603_SMALL_T02" list(3100.000000 5525.000000) nil) | 6@@list("PC615" "MX_C0603_SMALL_T01" list(2842.000000 5887.000000) nil) | 6@@list("PC616" "MX_C0603_SMALL_T01" list(2710.000000 5996.000000) nil) | 6@@list("PC617" "MX_C1206_H75" list(2015.000000 6048.000000) nil) | 6@@list("PC618" "MX_C1206_H75" list(2015.000000 6144.000000) nil) | 6@@list("PC619" "MX_C1206_H75" list(1993.000000 6714.000000) nil) | 6@@list("PC620" "MX_C1206_H75" list(1993.000000 6617.000000) nil) | 6@@list("PC6201" "MX_C0603_SMALL_T02" list(4945.000000 6375.000000) nil) | 6@@list("PC6202" "MX_C0603_SMALL_T02" list(5000.000000 6375.000000) nil) | 6@@list("PC6203" "MX_C0603_SMALL_T02" list(4945.000000 6265.000000) nil) | 6@@list("PC6204" "MX_C0603_SMALL_T02" list(5000.000000 6265.000000) nil) | 6@@list("PC6205" "MX_C0603_SMALL_T02" list(4945.000000 6500.000000) nil) | 6@@list("PC6206" "MX_C0603_SMALL_T02" list(5110.000000 6500.000000) nil) | 6@@list("PC6207" "MX_C0603_SMALL_T02" list(4730.000000 6625.000000) nil) | 6@@list("PC6208" "MX_C0603_SMALL_T02" list(4780.000000 6265.000000) nil) | 6@@list("PC6209" "MX_C0603_SMALL_T02" list(4835.000000 6500.000000) nil) | 6@@list("PC6210" "MX_C0603_SMALL_T02" list(4890.000000 6265.000000) nil) | 6@@list("PC6211" "MX_C0603_SMALL_T02" list(4725.000000 6265.000000) nil) | 6@@list("PC6212" "MX_C0603_SMALL_T02" list(4725.000000 6375.000000) nil) | 6@@list("PC6213" "MX_C0603_SMALL_T02" list(5165.000000 6375.000000) nil) | 6@@list("PC6214" "MX_C0603_SMALL_T02" list(4835.000000 6170.000000) nil) | 6@@list("PC6215" "MX_C0603_SMALL_T02" list(4780.000000 6170.000000) nil) | 6@@list("PC6216" "MX_C0603_SMALL_T02" list(4890.000000 6375.000000) nil) | 6@@list("PC6217" "MX_C0603_SMALL_T02" list(4725.000000 6170.000000) nil) | 6@@list("PC6218" "MX_C0603_SMALL_T02" list(4890.000000 6500.000000) nil) | 6@@list("PC6219" "MX_C0603_SMALL_T02" list(5055.000000 6500.000000) nil) | 6@@list("PC6220" "MX_C0603_SMALL_T02" list(5000.000000 6500.000000) nil) | 6@@list("PC6221" "MX_C0603_SMALL_T02" list(3915.000000 8435.000000) nil) | 6@@list("PC6222" "MX_C0603_SMALL_T02" list(5087.000000 8244.000000) nil) | 6@@list("PC6223" "MX_C0603_SMALL_T02" list(3975.000000 7935.000000) nil) | 6@@list("PC6224" "MX_C0603_SMALL_T02" list(4860.000000 7880.000000) nil) | 6@@list("PC6225" "MX_C0603_SMALL_T02" list(5044.620000 6735.000000) nil) | 6@@list("PC6226" "MX_C0603_SMALL_T02" list(4939.520000 6680.000000) nil) | 6@@list("PC6227" "MX_C0603_SMALL_T01" list(5044.620000 6680.000000) nil) | 6@@list("PC6228" "MX_C0603_SMALL_T02" list(4939.520000 6625.000000) nil) | 6@@list("PC6229" "MX_C0603_SMALL_T02" list(4939.520000 6735.000000) nil) | 6@@list("PC6230" "MX_C0603_SMALL_T02" list(4834.760000 6625.000000) nil) | 6@@list("PC6231" "MX_C0603_SMALL_T02" list(5044.620000 6625.000000) nil) | 6@@list("PC6232" "MX_C0603_SMALL_T02" list(4834.760000 6735.000000) nil) | 6@@list("PC6233" "MX_C0603_SMALL_T02" list(3975.000000 7880.000000) nil) | 6@@list("PC6234" "MX_C0603_SMALL_T02" list(4280.000000 7880.000000) nil) | 6@@list("PC6235" "MX_C0603_SMALL_T02" list(5149.380000 6680.000000) nil) | 6@@list("PC6236" "MX_C0603_SMALL_T02" list(5149.380000 6735.000000) nil) | 6@@list("PC6237" "MX_C0603_SMALL_T02" list(3810.000000 6290.000000) nil) | 6@@list("PC6238" "MX_C0603_SMALL_T02" list(3810.000000 6500.000000) nil) | 6@@list("PC6239" "MX_C0603_SMALL_T02" list(3810.000000 7055.000000) nil) | 6@@list("PC6240" "MX_C0603_SMALL_T02" list(3810.000000 6865.000000) nil) | 6@@list("PC6241" "MX_C0603_SMALL_T02" list(4575.000000 7935.000000) nil) | 6@@list("PC6242" "MX_C0603_SMALL_T02" list(4575.000000 7880.000000) nil) | 6@@list("PC6243" "MX_C0603_SMALL_T02" list(5149.380000 6624.000000) nil) | 6@@list("PC6244" "MX_C0603_SMALL_T02" list(4834.760000 6680.000000) nil) | 6@@list("PC640625" "MX_C0603_SMALL_T02" list(4730.000000 6680.000000) nil) | 6@@list("PC640626" "MX_C0603_SMALL_T02" list(5110.000000 6265.000000) nil) | 6@@list("PC640627" "MX_C0603_SMALL_T02" list(5110.000000 6375.000000) nil) | 6@@list("PC640628" "MX_C0603_SMALL_T02" list(5165.000000 6265.000000) nil) | 6@@list("PC640629" "MX_C0603_SMALL_T02" list(4780.000000 6375.000000) nil) | 6@@list("PC640630" "MX_C0603_SMALL_T02" list(3810.000000 6690.000000) nil) | 6@@list("PC640632" "MX_C0603_SMALL_T02" list(4908.000000 6145.000000) nil) | 6@@list("PC640633" "MX_C0603_SMALL_T02" list(4908.000000 6090.000000) nil) | 6@@list("PC640634" "MX_C0603_SMALL_T02" list(5050.000000 6145.000000) nil) | 6@@list("PC640635" "MX_C0603_SMALL_T02" list(5050.000000 6090.000000) nil) | 6@@list("PC640636" "MX_C0603_SMALL_T02" list(5047.000000 6035.000000) nil) | 6@@list("PC640637" "MX_C0402_SMALL_T01" list(2615.000000 4705.000000) nil) | 6@@list("PC640639" "MX_C0402_SMALL_T01" list(2995.000000 5406.000000) nil) | 6@@list("PC640641" "MX_C0402_SMALL_T01" list(2775.000000 5108.000000) nil) | 6@@list("PC640644" "MX_C0402_SMALL_T01" list(2615.000000 4770.000000) nil) | 6@@list("PC640645" "MX_C0402_SMALL_T01" list(2707.000000 5329.000000) nil) | 6@@list("PC640646" "MX_C0402_SMALL_T01" list(2885.000000 5350.000000) nil) | 6@@list("PC640647" "MX_C0603_SMALL_T01" list(2885.000000 4780.000000) nil) | 6@@list("PC640648" "MX_C0402_SMALL_T01" list(2625.000000 4940.000000) nil) | 6@@list("PC640649" "MX_C0805_SMALL_T02" list(2768.000000 4904.000000) nil) | 6@@list("PC640651" "MX_C0402_SMALL_T01" list(2995.000000 5442.000000) nil) | 6@@list("PC640653" "MX_C0402_SMALL_T01" list(8350.000000 8820.000000) nil) | 6@@list("PC640656" "MX_C0402_SMALL_T01" list(8295.000000 7621.000000) nil) | 6@@list("PC640658" "MX_C0402_SMALL_T01" list(8649.000000 7808.000000) nil) | 6@@list("PC640660" "MX_C0402_SMALL_T01" list(8237.200000 7799.600000) nil) | 6@@list("PC640661" "MX_C0402_SMALL_T01" list(8409.000000 8835.000000) nil) | 6@@list("PC640662" "MX_C0402_SMALL_T01" list(8638.000000 7384.000000) nil) | 6@@list("PC640663" "MX_C0603_SMALL_T01" list(8395.000000 8511.500000) nil) | 6@@list("PC640664" "MX_C0402_SMALL_T01" list(8555.000000 8815.000000) nil) | 6@@list("PC640665" "MX_C0603_SMALL_T01" list(8515.000000 8575.000000) nil) | 6@@list("PC640667" "MX_C0402_SMALL_T01" list(8294.900000 7397.500000) nil) | 6@@list("PC640671" "MX_C0603_SMALL_T01" list(8490.000000 8840.000000) nil) | 6@@list("PC640672" "MX_C0402_SMALL_T01" list(2591.000000 4844.000000) nil) | 6@@list("PC640674" "MX_C0603_SMALL_T01" list(2470.000000 4935.000000) nil) | 6@@list("PC640675" "MX_C0402_SMALL_T01" list(1555.000000 9090.000000) nil) | 6@@list("PC640676" "MX_C0805_SMALL_T02" list(1415.000000 8985.000000) nil) | 6@@list("PC640679" "MX_C0603_SMALL_T01" list(2116.020000 4948.000000) nil) | 6@@list("PC640681" "MX_C0201" list(2020.000000 5158.000000) nil) | 6@@list("PC640682" "MX_C0603_SMALL_T01" list(755.000000 5985.000000) nil) | 6@@list("PC640683" "MX_C0402_SMALL_T01" list(2199.000000 7952.000000) nil) | 6@@list("PC640684" "MX_C0402_SMALL_T01" list(2797.000000 7445.000000) nil) | 6@@list("PC640685" "MX_C0402_SMALL_T01" list(2600.000000 8177.000000) nil) | 6@@list("PC640686" "MX_C0402_SMALL_T01" list(2201.000000 6076.000000) nil) | 6@@list("PC640687" "MX_C0402_SMALL_T01" list(2755.000000 6745.000000) nil) | 6@@list("PC640688" "MX_C0402_SMALL_T01" list(2710.000000 6059.000000) nil) | 6@@list("PC640689" "MX_C0402_SMALL_T01" list(2932.000000 7479.000000) nil) | 6@@list("PC640690" "MX_C0402_SMALL_T01" list(2920.000000 6784.000000) nil) | 6@@list("PC640691" "MX_C0402_SMALL_T01" list(3153.000000 5528.000000) nil) | 6@@list("PC640692" "MX_C0402_SMALL_T01" list(2916.000000 6100.000000) nil) | 6@@list("PC642" "MX_C0402_SMALL_T01" list(1817.000000 9333.000000) nil) | 6@@list("PC6501" "MX_C1206_H75" list(8302.000000 8100.000000) nil) | 6@@list("PC6502" "MX_C1206_H75" list(8302.000000 7999.000000) nil) | 6@@list("PC6521" "MX_C0603_SMALL_T02" list(8369.000000 6328.000000) nil) | 6@@list("PC6522" "MX_C0603_SMALL_T02" list(8382.000000 6089.000000) nil) | 6@@list("PC6523" "MX_C0603_SMALL_T02" list(6735.000000 7235.000000) nil) | 6@@list("PC6524" "MX_C0603_SMALL_T02" list(8328.500000 6778.000000) nil) | 6@@list("PC6525" "MX_C0603_SMALL_T02" list(8170.000000 7050.000000) nil) | 6@@list("PC6526" "MX_C0603_SMALL_T01" list(8994.000000 8132.000000) nil) | 6@@list("PC6527" "MX_C0603_SMALL_T01" list(8625.000000 8950.000000) nil) | 6@@list("PC661" "MX_C0402_SMALL_T01" list(8400.000000 5199.000000) nil) | 6@@list("PC6805" "MX_C0603_SMALL_T01" list(1703.000000 9364.000000) nil) | 6@@list("PC6807" "MX_C0603_SMALL_T01" list(1650.000000 8945.000000) nil) | 6@@list("PC6808" "MX_C0603_SMALL_T01" list(1700.000000 8945.000000) nil) | 6@@list("PC6809" "MX_C0402_SMALL_T01" list(1763.000000 8972.000000) nil) | 6@@list("PC6810" "MX_C0402_SMALL_T01" list(1642.000000 9317.000000) nil) | 6@@list("PC832" "MX_C0603_SMALL_T02" list(8269.000000 4370.000000) nil) | 6@@list("PC834" "MX_C0603_SMALL_T02" list(5165.000000 6500.000000) nil) | 6@@list("PCH" "BGA_885P_909X949_N" list(6725.000000 1995.000000) nil) | 6@@list("PD1" "MX_SMA" list(2010.000000 9245.000000) nil) | 6@@list("PD2" "MX_SMA" list(2010.000000 9380.000000) nil) | 6@@list("PD3" "MX_SMA" list(3553.260000 3828.040000) nil) | 6@@list("PL1" "MX_INDUCTOR_2P_287X260" list(8753.000000 8284.000000) nil) | 6@@list("PL13" "MX_INDUCTOR_2P_287X260" list(7720.000000 3260.000000) nil) | 6@@list("PL631" "MX_INDUCTOR_2P_287X260" list(3028.000000 5131.000000) nil) | 6@@list("PL661" "MX_INDUCTOR_2P_287X260" list(8363.430000 4636.660000) nil) | 6@@list("PQ10" "MX_SOT23_H43" list(8255.000000 8690.000000) nil) | 6@@list("PQ11" "MX_SOT363" list(9060.820000 819.350000) nil) | 6@@list("PQ115" "MX_SOT23" list(8432.000000 5938.000000) nil) | 6@@list("PQ19" "MX_SO_8FL_COLAY_9VI" list(5099.000000 4118.000000) nil) | 6@@list("PQ2" "MX_SOT23_H43" list(2597.000000 8484.000000) nil) | 6@@list("PQ23" "MX_SOT23_H43" list(2075.000000 4789.000000) nil) | 6@@list("PQ28" "MX_SOT1220_NXP" list(2705.000000 5130.000000) nil) | 6@@list("PQ29" "MX_SOT1220_NXP" list(2970.580000 5336.000000) nil) | 6@@list("PQ30" "MX_SOT1220_NXP" list(2803.000000 5339.000000) nil) | 6@@list("PQ31" "MX_SOT23_2D4_H51" list(8945.000000 7600.000000) nil) | 6@@list("PQ33" "MX_TO252_LF3" list(8934.500000 7050.000000) nil) | 6@@list("PQ34" "MX_SO_8FL_COLAY" list(9140.000000 8213.000000) nil) | 6@@list("PQ37" "MX_SOT23_2D4_H43" list(9365.000000 8233.000000) nil) | 6@@list("PQ40" "MX_POWERPAIR_8P_2PAD_VISHAY" list(8035.000000 3480.000000) nil) | 6@@list("PQ46" "MX_SOT323_S5" list(5366.000000 4431.000000) nil) | 6@@list("PQ54" "MX_SOT23_2D4_H43" list(8560.000000 5252.000000) nil) | 6@@list("PQ56" "MX_SO_8FL_COLAY" list(8661.000000 5546.000000) nil) | 6@@list("PQ591" "MX_SO_8FL_COLAY_9VI" list(2373.010000 7323.230000) nil) | 6@@list("PQ592" "MX_SO_8FL_COLAY_9VI" list(2480.000000 7018.230000) nil) | 6@@list("PQ593" "MX_SO_8FL_COLAY_9VI" list(2235.010000 7018.230000) nil) | 6@@list("PQ594" "MX_SO_8FL_COLAY_9VI" list(2373.010000 8019.230000) nil) | 6@@list("PQ595" "MX_SO_8FL_COLAY_9VI" list(2480.000000 7713.230000) nil) | 6@@list("PQ596" "MX_SO_8FL_COLAY_9VI" list(2235.010000 7713.230000) nil) | 6@@list("PQ60" "MX_SOT23_2D4_H44" list(5009.000000 4495.000000) nil) | 6@@list("PQ601" "MX_SO_8FL_COLAY_9VI" list(2375.530000 6638.230000) nil) | 6@@list("PQ602" "MX_SO_8FL_COLAY_9VI" list(2234.530000 6329.230000) nil) | 6@@list("PQ603" "MX_SO_8FL_COLAY_9VI" list(2482.000000 6329.430000) nil) | 6@@list("PQ604" "MX_SO_8FL_COLAY_9VI" list(2375.530000 5935.230000) nil) | 6@@list("PQ605" "MX_SO_8FL_COLAY_9VI" list(2234.530000 5630.230000) nil) | 6@@list("PQ606" "MX_SO_8FL_COLAY_9VI" list(2482.000000 5630.450000) nil) | 6@@list("PQ611" "MX_SO_8FL_COLAY_9VI" list(4679.000000 8772.230000) nil) | 6@@list("PQ612" "MX_SO_8FL_COLAY_9VI" list(4094.990000 8767.770000) nil) | 6@@list("PQ613" "MX_SO_8FL_COLAY_9VI" list(4338.990000 8767.770000) nil) | 6@@list("PQ614" "MX_SO_8FL_COLAY_9VI" list(5525.010000 8772.230000) nil) | 6@@list("PQ615" "MX_SO_8FL_COLAY_9VI" list(5180.000000 8767.770000) nil) | 6@@list("PQ616" "MX_SO_8FL_COLAY_9VI" list(4930.000000 8767.770000) nil) | 6@@list("PQ651" "MX_SO_8FL_COLAY_9VI" list(8530.010000 7984.230000) nil) | 6@@list("PQ652" "MX_SO_8FL_COLAY_9VI" list(8467.230000 7705.990000) nil) | 6@@list("PQ653" "MX_SO_8FL_COLAY_9VI" list(8467.230000 7456.000000) nil) | 6@@list("PQ691" "MX_SOT23_2D4_H43" list(8975.000000 6335.000000) nil) | 6@@list("PQ80" "MX_SOT23_H43_COLAY" list(8579.000000 6085.000000) nil) | 6@@list("PQ9777" "MX_SOT23_H43" list(8125.000000 2035.000000) nil) | 6@@list("PQ9779" "MX_SOT23_H61" list(8034.000000 1736.000000) nil) | 6@@list("PQ9784" "MX_SOT23_2D4_H55" list(1535.000000 8975.000000) nil) | 6@@list("PQ9786" "MX_SOT23_2D4_H43" list(2070.000000 5056.000000) nil) | 6@@list("PQ9787" "MX_SOT23_H43" list(5456.900000 516.400000) nil) | 6@@list("PR11" "MX_R0402_SMALL_T01" list(8505.000000 8965.000000) nil) | 6@@list("PR115" "MX_R0402_SMALL_T01" list(5400.000000 3630.000000) nil) | 6@@list("PR12" "MX_R0402_SMALL_T01" list(8560.000000 8980.000000) nil) | 6@@list("PR121" "MX_R0402_SMALL_T01" list(9432.000000 8498.000000) nil) | 6@@list("PR122" "MX_R0402_SMALL_T01" list(9095.000000 8440.000000) nil) | 6@@list("PR123" "MX_R0603_SMALL_T01" list(8257.000000 5716.000000) nil) | 6@@list("PR124" "MX_R0402_SMALL_T01" list(4880.000000 3770.000000) nil) | 6@@list("PR125" "MX_R0402_SMALL_T01" list(8306.000000 6105.000000) nil) | 6@@list("PR126" "MX_R0402_SMALL_T01" list(8270.000000 6105.000000) nil) | 6@@list("PR127" "MX_R0805_SMALL_T02" list(5074.000000 3954.000000) nil) | 6@@list("PR128" "MX_R0402_SMALL_T01" list(5154.000000 3845.000000) nil) | 6@@list("PR129" "MX_R0402_SMALL_T01" list(5149.000000 3950.000000) nil) | 6@@list("PR130" "MX_R0402_SMALL_T01" list(4889.000000 3975.000000) nil) | 6@@list("PR131" "MX_R1206" list(4700.000000 3945.000000) nil) | 6@@list("PR132" "MX_R0402_SMALL_T01" list(4890.000000 3910.000000) nil) | 6@@list("PR133" "MX_R0402_SMALL_T01" list(4962.000000 3910.000000) nil) | 6@@list("PR134" "MX_R0402_SMALL_T01" list(8465.000000 5676.000000) nil) | 6@@list("PR135" "MX_R0402_SMALL_T01" list(8481.000000 5366.000000) nil) | 6@@list("PR136" "MX_R0402_SMALL_T01" list(1493.500000 9065.190000) nil) | 6@@list("PR137" "MX_R0402_SMALL_T01" list(8429.000000 5299.500000) nil) | 6@@list("PR138" "MX_R0402_SMALL_T01" list(9263.380000 8012.500000) nil) | 6@@list("PR139" "MX_R0402_SMALL_T01" list(8586.000000 5774.000000) nil) | 6@@list("PR14" "MX_R0402_SMALL_T01" list(8218.000000 4165.000000) nil) | 6@@list("PR161" "MX_R0805_SMALL_T02" list(7668.000000 3702.000000) nil) | 6@@list("PR162" "MX_R0402_SMALL_T01" list(7458.000000 3637.000000) nil) | 6@@list("PR163" "MX_R0805_SMALL_T02" list(8145.000000 3605.000000) nil) | 6@@list("PR164" "MX_R0402_SMALL_T01" list(8165.870000 3516.920000) nil) | 6@@list("PR165" "MX_R0805_SMALL_T02" list(7740.000000 3490.000000) nil) | 6@@list("PR166" "MX_R1206" list(7910.000000 3360.000000) nil) | 6@@list("PR167" "MX_R0402_SMALL_T01" list(7384.000000 3675.000000) nil) | 6@@list("PR168" "MX_R0402_SMALL_T01" list(7573.000000 3506.000000) nil) | 6@@list("PR170" "MX_R0402_SMALL_T01" list(7351.000000 3637.000000) nil) | 6@@list("PR171" "MX_R0402_SMALL_T01" list(8075.000000 3387.000000) nil) | 6@@list("PR172" "MX_R0402_SMALL_T01" list(7448.000000 3565.000000) nil) | 6@@list("PR173" "MX_R0402_SMALL_T01" list(7441.000000 3493.000000) nil) | 6@@list("PR174" "MX_R0402_SMALL_T01" list(7458.000000 3673.000000) nil) | 6@@list("PR175" "MX_R0402_SMALL_T01" list(7509.000000 3493.000000) nil) | 6@@list("PR187" "MX_R0402_SMALL_T01" list(8980.000000 6476.000000) nil) | 6@@list("PR188" "MX_R0402_SMALL_T01" list(9018.000000 7446.000000) nil) | 6@@list("PR189" "MX_R0402_SMALL_T01" list(9030.000000 7410.000000) nil) | 6@@list("PR191" "MX_R0402_SMALL_T01" list(8965.000000 7410.000000) nil) | 6@@list("PR192" "MX_R0402_SMALL_T01" list(8940.000000 7265.000000) nil) | 6@@list("PR193" "MX_R0402_SMALL_T01" list(8990.000000 7285.000000) nil) | 6@@list("PR195" "MX_R0402_SMALL_T01" list(9432.000000 8433.000000) nil) | 6@@list("PR198" "MX_R0402_SMALL_T01" list(9402.000000 8368.000000) nil) | 6@@list("PR199" "MX_R0402_SMALL_T01" list(9029.000000 8440.000000) nil) | 6@@list("PR2" "MX_R0805_SMALL_T02" list(2597.000000 8644.000000) nil) | 6@@list("PR234" "MX_R0402_SMALL_T01" list(2179.000000 4881.000000) nil) | 6@@list("PR235" "MX_R0402_SMALL_T01" list(2122.000000 4870.000000) nil) | 6@@list("PR236" "MX_R0402_SMALL_T01" list(2178.000000 4725.000000) nil) | 6@@list("PR244" "MX_R0402_SMALL_T01" list(5022.000000 4612.500000) nil) | 6@@list("PR245" "MX_R0402_SMALL_T01" list(4971.900000 4597.000000) nil) | 6@@list("PR248" "MX_R0402_SMALL_T01" list(5445.000000 4385.000000) nil) | 6@@list("PR249" "MX_R0402_SMALL_T01" list(5313.000000 4312.000000) nil) | 6@@list("PR3" "MX_R0805_SMALL_T02" list(4704.000000 4480.000000) nil) | 6@@list("PR302" "MX_R0402_SMALL_T01" list(8443.000000 5570.000000) nil) | 6@@list("PR305" "MX_R0402_SMALL_T01" list(8481.000000 5402.000000) nil) | 6@@list("PR312" "MX_R0402_SMALL_T01" list(4998.000000 3910.000000) nil) | 6@@list("PR313" "MX_R0402_SMALL_T01" list(4925.000000 3975.000000) nil) | 6@@list("PR317" "MX_R0402_SMALL_T01" list(2513.000000 4940.000000) nil) | 6@@list("PR340" "MX_R0805_SMALL_T02" list(5115.620000 4488.000000) nil) | 6@@list("PR341" "MX_R0805_SMALL_T02" list(1958.000000 5012.000000) nil) | 6@@list("PR381" "MX_R0402_SMALL_T01" list(8491.000000 6058.000000) nil) | 6@@list("PR4" "MX_R0805_SMALL_T02" list(5240.000000 4357.000000) nil) | 6@@list("PR432" "MX_R0402_SMALL_T01" list(8632.000000 6204.000000) nil) | 6@@list("PR5" "MX_R0402_SMALL_T01" list(9050.000000 7790.000000) nil) | 6@@list("PR511" "MX_R0402_SMALL_T01" list(8959.500000 5896.000000) nil) | 6@@list("PR512" "MX_R0402_SMALL_T01" list(8230.000000 8793.000000) nil) | 6@@list("PR5801" "MX_R0402_SMALL_T01" list(2905.000000 8240.000000) nil) | 6@@list("PR5802" "MX_R0402_SMALL_T01" list(2975.000000 8270.000000) nil) | 6@@list("PR5803" "MX_R0402_SMALL_T01" list(3007.000000 8325.000000) nil) | 6@@list("PR5804" "MX_R0402_SMALL_T01" list(2805.000000 8455.000000) nil) | 6@@list("PR5805" "MX_R0402_SMALL_T01" list(2876.000000 8416.000000) nil) | 6@@list("PR5806" "MX_R0402_SMALL_T01" list(3114.000000 8210.000000) nil) | 6@@list("PR5807" "MX_R0402_SMALL_T01" list(2980.500000 8870.000000) nil) | 6@@list("PR5808" "MX_R0402_SMALL_T01" list(3079.000000 8954.000000) nil) | 6@@list("PR5809" "MX_R0402_SMALL_T01" list(3111.000000 8071.000000) nil) | 6@@list("PR5810" "MX_R0402_SMALL_T01" list(2885.000000 8290.000000) nil) | 6@@list("PR5811" "MX_R0402_SMALL_T01" list(2885.000000 8380.000000) nil) | 6@@list("PR5812" "MX_R0402_SMALL_T01" list(2880.000000 8690.000000) nil) | 6@@list("PR5813" "MX_R0402_SMALL_T01" list(2989.000000 8954.000000) nil) | 6@@list("PR5814" "MX_R0402_SMALL_T01" list(3060.000000 8267.000000) nil) | 6@@list("PR5815" "MX_R0402_SMALL_T01" list(3043.000000 8325.000000) nil) | 6@@list("PR5816" "MX_R0402_SMALL_T01" list(2795.000000 8630.000000) nil) | 6@@list("PR5817" "MX_R0402_SMALL_T01" list(3485.000000 8863.000000) nil) | 6@@list("PR5818" "MX_R0402_SMALL_T01" list(3485.000000 8827.000000) nil) | 6@@list("PR5819" "MX_R0402_SMALL_T01" list(3400.040000 8803.910000) nil) | 6@@list("PR5820" "MX_R0402_SMALL_T01" list(3400.000000 8845.000000) nil) | 6@@list("PR5821" "MX_R0402_SMALL_T01" list(3485.000000 8791.000000) nil) | 6@@list("PR5822" "MX_R0402_SMALL_T01" list(3400.000000 8731.000000) nil) | 6@@list("PR5823" "MX_R0402_SMALL_T01" list(3485.000000 8755.000000) nil) | 6@@list("PR5824" "MX_R0402_SMALL_T01" list(3308.000000 8259.000000) nil) | 6@@list("PR5825" "MX_R0402_SMALL_T01" list(3424.000000 8352.000000) nil) | 6@@list("PR5826" "MX_R0402_SMALL_T01" list(3426.000000 8267.000000) nil) | 6@@list("PR5827" "MX_R0402_SMALL_T01" list(3388.000000 8352.000000) nil) | 6@@list("PR5828" "MX_R0402_SMALL_T01" list(3487.000000 8402.000000) nil) | 6@@list("PR5829" "MX_R0402_SMALL_T01" list(3400.000000 8402.000000) nil) | 6@@list("PR5830" "MX_R0402_SMALL_T01" list(3487.000000 8438.000000) nil) | 6@@list("PR5831" "MX_R0402_SMALL_T01" list(3400.000000 8438.000000) nil) | 6@@list("PR5832" "MX_R0402_SMALL_T01" list(3487.000000 8474.000000) nil) | 6@@list("PR5833" "MX_R0402_SMALL_T01" list(3400.000000 8474.000000) nil) | 6@@list("PR5834" "MX_R0402_SMALL_T01" list(3487.000000 8582.000000) nil) | 6@@list("PR5835" "MX_R0402_SMALL_T01" list(3400.000000 8582.000000) nil) | 6@@list("PR5836" "MX_R0402_SMALL_T01" list(3345.000000 8259.000000) nil) | 6@@list("PR5837" "MX_R0402_SMALL_T01" list(3390.000000 8267.000000) nil) | 6@@list("PR5838" "MX_R0402_SMALL_T01" list(3400.000000 8546.000000) nil) | 6@@list("PR5839" "MX_R0402_SMALL_T01" list(3487.000000 8546.000000) nil) | 6@@list("PR5840" "MX_R0402_SMALL_T01" list(3487.000000 8510.000000) nil) | 6@@list("PR5841" "MX_R0402_SMALL_T01" list(3400.000000 8510.000000) nil) | 6@@list("PR5842" "MX_R0402_SMALL_T01" list(3345.000000 8355.000000) nil) | 6@@list("PR5843" "MX_R0402_SMALL_T01" list(3303.000000 8355.000000) nil) | 6@@list("PR5844" "MX_R0402_SMALL_T01" list(3229.000000 8320.000000) nil) | 6@@list("PR5845" "MX_R0402_SMALL_T01" list(3186.000000 8245.000000) nil) | 6@@list("PR5846" "MX_R0402_SMALL_T01" list(3150.000000 8330.000000) nil) | 6@@list("PR5847" "MX_R0402_SMALL_T01" list(3188.000000 8331.000000) nil) | 6@@list("PR5848" "MX_R0402_SMALL_T01" list(3236.500000 8900.000000) nil) | 6@@list("PR5849" "MX_R0402_SMALL_T01" list(3160.000000 8910.000000) nil) | 6@@list("PR5850" "MX_R0402_SMALL_T01" list(3187.000000 8990.000000) nil) | 6@@list("PR5851" "MX_R0402_SMALL_T01" list(3196.000000 8910.000000) nil) | 6@@list("PR5852" "MX_R0402_SMALL_T01" list(2795.000000 8590.000000) nil) | 6@@list("PR5853" "MX_R0402_SMALL_T01" list(2880.000000 8556.000000) nil) | 6@@list("PR5854" "MX_R0402_SMALL_T01" list(2829.000000 8940.000000) nil) | 6@@list("PR5855" "MX_R0402_SMALL_T01" list(2902.000000 8871.000000) nil) | 6@@list("PR5856" "MX_R0402_SMALL_T01" list(3345.000000 8938.000000) nil) | 6@@list("PR5857" "MX_R0402_SMALL_T01" list(3400.000000 8655.000000) nil) | 6@@list("PR5858" "MX_R0402_SMALL_T01" list(3400.040000 8766.910000) nil) | 6@@list("PR5859" "MX_R0402_SMALL_T01" list(2768.000000 8762.000000) nil) | 6@@list("PR5860" "MX_R0402_SMALL_T01" list(2743.000000 8801.000000) nil) | 6@@list("PR5862" "MX_R0402_SMALL_T01" list(3566.000000 8563.000000) nil) | 6@@list("PR5863" "MX_R0402_SMALL_T01" list(3602.000000 8563.000000) nil) | 6@@list("PR5864" "MX_R0402_SMALL_T01" list(3562.000000 8685.000000) nil) | 6@@list("PR5865" "MX_R0402_SMALL_T01" list(3598.000000 8685.000000) nil) | 6@@list("PR5866" "MX_R0402_SMALL_T01" list(3400.000000 8695.000000) nil) | 6@@list("PR5867" "MX_R0402" list(3400.000000 8618.000000) nil) | 6@@list("PR5868" "MX_R0402_SMALL_T01" list(3490.000000 8620.000000) nil) | 6@@list("PR5869" "MX_R0402_SMALL_T01" list(3485.000000 8718.000000) nil) | 6@@list("PR5870" "MX_R0402_SMALL_T01" list(2865.000000 8766.000000) nil) | 6@@list("PR5871" "MX_R0402_SMALL_T01" list(2881.000000 8512.000000) nil) | 6@@list("PR5872" "MX_R0402_SMALL_T01" list(2931.000000 8957.000000) nil) | 6@@list("PR5873" "MX_R0402_SMALL_T01" list(2944.000000 8870.000000) nil) | 6@@list("PR5874" "MX_R0402_SMALL_T01" list(2793.000000 8513.000000) nil) | 6@@list("PR5875" "MX_R0402_SMALL_T01" list(2820.000000 8850.000000) nil) | 6@@list("PR5876" "MX_R0805_SMALL_T02" list(3166.000000 8072.000000) nil) | 6@@list("PR5877" "MX_R0402_SMALL_T01" list(3124.000000 8873.000000) nil) | 6@@list("PR5878" "MX_R0402_SMALL_T01" list(3075.000000 8396.000000) nil) | 6@@list("PR5879" "MX_R0402_SMALL_T01" list(2880.000000 8640.000000) nil) | 6@@list("PR5880" "MX_R0402_SMALL_T01" list(2950.000000 8215.000000) nil) | 6@@list("PR5881" "MX_R0402_SMALL_T01" list(2769.000000 8455.000000) nil) | 6@@list("PR5882" "MX_R0402_SMALL_T01" list(3078.000000 8210.000000) nil) | 6@@list("PR5883" "MX_R0402_SMALL_T01" list(3024.000000 9005.000000) nil) | 6@@list("PR5884" "MX_R0402_SMALL_T01" list(3060.000000 9005.000000) nil) | 6@@list("PR5901" "MX_R1206_H26" list(2895.000000 7365.000000) nil) | 6@@list("PR5902" "MX_R0603_SMALL_T01" list(2682.000000 7370.000000) nil) | 6@@list("PR5903" "MX_R0805_SMALL_T02" list(2535.990000 7293.000000) nil) | 6@@list("PR5904" "MX_R0402_SMALL_T01" list(2550.000000 7203.000000) nil) | 6@@list("PR5905" "MX_R1206" list(2700.000000 6817.000000) nil) | 6@@list("PR5906" "MX_R0402_SMALL_T01" list(2586.000000 6831.990000) nil) | 6@@list("PR5908" "MX_R0402_SMALL_T01" list(2549.000000 7895.000000) nil) | 6@@list("PR5909" "MX_R0603_SMALL_T01" list(2553.000000 8221.000000) nil) | 6@@list("PR5910" "MX_R0805_SMALL_T02" list(2532.000000 7984.000000) nil) | 6@@list("PR5911" "MX_R1206_H26" list(2740.000000 8035.000000) nil) | 6@@list("PR5912" "MX_R0402_SMALL_T01" list(2549.000000 7525.000000) nil) | 6@@list("PR5913" "MX_R1206" list(2700.000000 7510.000000) nil) | 6@@list("PR6" "MX_R0805_SMALL_T02" list(9075.000000 7989.000000) nil) | 6@@list("PR601" "MX_R0402_SMALL_T01" list(2552.530000 6515.000000) nil) | 6@@list("PR602" "MX_R0603_SMALL_T01" list(2617.000000 6713.000000) nil) | 6@@list("PR603" "MX_R0805_SMALL_T02" list(2595.000000 6596.470000) nil) | 6@@list("PR604" "MX_R1206_H26" list(2880.000000 6665.000000) nil) | 6@@list("PR605" "MX_R0402_SMALL_T01" list(2589.000000 6140.530000) nil) | 6@@list("PR606" "MX_R1206" list(2703.000000 6125.000000) nil) | 6@@list("PR608" "MX_R0402_SMALL_T01" list(2551.000000 5814.000000) nil) | 6@@list("PR609" "MX_R0603_SMALL_T01" list(2603.000000 6007.000000) nil) | 6@@list("PR610" "MX_R0805_SMALL_T02" list(2595.000000 5910.000000) nil) | 6@@list("PR6101" "MX_R0402_SMALL_T01" list(4730.000000 8563.000000) nil) | 6@@list("PR6102" "MX_R0603_SMALL_T01" list(3604.000000 9037.000000) nil) | 6@@list("PR6103" "MX_R0805_SMALL_T02" list(4720.000000 8460.000000) nil) | 6@@list("PR6104" "MX_R1206_H26" list(3760.000000 9065.000000) nil) | 6@@list("PR6105" "MX_R0402_SMALL_T01" list(4070.000000 8976.000000) nil) | 6@@list("PR6106" "MX_R1206" list(4510.000000 8679.000000) nil) | 6@@list("PR6108" "MX_R0402_SMALL_T01" list(5575.000000 8564.000000) nil) | 6@@list("PR6109" "MX_R0603_SMALL_T01" list(5694.000000 8954.000000) nil) | 6@@list("PR611" "MX_R1206_H26" list(2931.000000 5981.000000) nil) | 6@@list("PR6110" "MX_R0805_SMALL_T02" list(5544.000000 8458.000000) nil) | 6@@list("PR6111" "MX_R1206_H26" list(5984.000000 9029.000000) nil) | 6@@list("PR6112" "MX_R0402_SMALL_T01" list(4880.000000 8976.000000) nil) | 6@@list("PR6113" "MX_R1206" list(5354.000000 8679.000000) nil) | 6@@list("PR612" "MX_R0402_SMALL_T01" list(2582.000000 5444.530000) nil) | 6@@list("PR613" "MX_R1206" list(2700.000000 5473.000000) nil) | 6@@list("PR621" "MX_R0402_SMALL_T01" list(3227.000000 8169.000000) nil) | 6@@list("PR622" "MX_R0402_SMALL_T01" list(3294.000000 8170.000000) nil) | 6@@list("PR623" "MX_R0402_SMALL_T01" list(3261.000000 9002.000000) nil) | 6@@list("PR624" "MX_R0402_SMALL_T01" list(3345.000000 8975.000000) nil) | 6@@list("PR641" "MX_R0805_SMALL_T02" list(914.000000 6716.000000) nil) | 6@@list("PR6506" "MX_R0402_SMALL_T01" list(8445.000000 8835.000000) nil) | 6@@list("PR6601" "MX_R0603_SMALL_T01" list(4670.000000 1955.000000) nil) | 6@@list("PR6602" "MX_R0402_SMALL_T01" list(4689.000000 2210.000000) nil) | 6@@list("PR6603" "MX_R0402_SMALL_T01" list(4735.300000 2011.800000) nil) | 6@@list("PR6605" "MX_R0402_SMALL_T01" list(4734.600000 2078.700000) nil) | 6@@list("PR6607" "MX_R0402_SMALL_T01" list(8443.000000 4879.000000) nil) | 6@@list("PR6608" "MX_R0402_SMALL_T01" list(8395.000000 5098.000000) nil) | 6@@list("PR6609" "MX_R0402_SMALL_T01" list(8385.000000 5149.000000) nil) | 6@@list("PR6610" "MX_R0402_SMALL_T01" list(8429.000000 4968.000000) nil) | 6@@list("PR6611" "MX_R0402_SMALL_T01" list(8425.000000 5148.990000) nil) | 6@@list("PR6806" "MX_R0402_SMALL_T01" list(1769.000000 8898.000000) nil) | 6@@list("PR6807" "MX_R0402_SMALL_T01" list(1768.990000 8934.000000) nil) | 6@@list("PR6809" "MX_R0402_SMALL_T01" list(1829.000000 8972.000000) nil) | 6@@list("PR6810" "MX_R0603_SMALL_T01" list(1655.000000 9380.000000) nil) | 6@@list("PR7" "MX_R0805_SMALL_T02" list(9020.000000 6180.000000) nil) | 6@@list("PR70176" "MX_R0402_SMALL_T01" list(2510.000000 4785.000000) nil) | 6@@list("PR70188" "MX_R0402_SMALL_T01" list(2440.000000 4715.000000) nil) | 6@@list("PR70189" "MX_R0402_SMALL_T01" list(2468.000000 4859.000000) nil) | 6@@list("PR70190" "MX_R0402_SMALL_T01" list(2860.000000 4840.000000) nil) | 6@@list("PR70193" "MX_R0805_SMALL_T02" list(2792.000000 5019.000000) nil) | 6@@list("PR70194" "MX_R0402_SMALL_T01" list(2535.000000 4730.000000) nil) | 6@@list("PR70195" "MX_R0603_SMALL_T01" list(3445.000000 5705.000000) nil) | 6@@list("PR70196" "MX_R0402_SMALL_T01" list(2440.000000 4655.000000) nil) | 6@@list("PR70198" "MX_R0805_SMALL_T02" list(2860.000000 4690.000000) nil) | 6@@list("PR70199" "MX_R1206" list(2743.010000 5236.000000) nil) | 6@@list("PR70201" "MX_R0402_SMALL_T01" list(2440.000000 4755.000000) nil) | 6@@list("PR70202" "MX_R0603_SMALL_T01" list(2889.000000 4899.000000) nil) | 6@@list("PR70203" "MX_R0805_SMALL_T02" list(2935.000000 4840.000000) nil) | 6@@list("PR70204" "MX_R0402_SMALL_T01" list(2811.000000 5108.000000) nil) | 6@@list("PR70205" "MX_R0402_SMALL_T01" list(2585.000000 4940.000000) nil) | 6@@list("PR70206" "MX_R0402_SMALL_T01" list(2665.000000 4940.000000) nil) | 6@@list("PR70210" "MX_R0805_SMALL_T02" list(8687.000000 7886.000000) nil) | 6@@list("PR70211" "MX_R0402_SMALL_T01" list(8350.000000 8881.000000) nil) | 6@@list("PR70212" "MX_R0603_SMALL_T01" list(8305.000000 6599.000000) nil) | 6@@list("PR70213" "MX_R0402_SMALL_T01" list(8352.200000 8964.200000) nil) | 6@@list("PR70215" "MX_R0805_SMALL_T02" list(8335.000000 8525.000000) nil) | 6@@list("PR70216" "MX_R1206" list(8312.200000 7878.600000) nil) | 6@@list("PR70217" "MX_R0402_SMALL_T01" list(8300.000000 8900.000000) nil) | 6@@list("PR70219" "MX_R0603_SMALL_T01" list(8541.380000 8646.000000) nil) | 6@@list("PR70220" "MX_R0805_SMALL_T02" list(8455.000000 8491.000000) nil) | 6@@list("PR70221" "MX_R0402_SMALL_T01" list(8649.000000 7771.000000) nil) | 6@@list("PR70222" "MX_R0402_SMALL_T01" list(8555.000000 8851.000000) nil) | 6@@list("PR70223" "MX_R0402_SMALL_T01" list(8545.000000 8905.000000) nil) | 6@@list("PR70225" "MX_R0402_SMALL_T01" list(8300.000000 8975.000000) nil) | 6@@list("PR70227" "MX_R0402_SMALL_T01" list(8455.000000 8567.000000) nil) | 6@@list("PR70228" "MX_R0402_SMALL_T01" list(2468.000000 4823.000000) nil) | 6@@list("PR70231" "MX_R0402_SMALL_T01" list(3460.000000 8915.000000) nil) | 6@@list("PR70238" "MX_R0402_SMALL_T01" list(4880.000000 3635.000000) nil) | 6@@list("PR70244" "MX_R0805_SMALL_T02" list(8840.000000 6335.000000) nil) | 6@@list("PR70245" "MX_R0805_SMALL_T02" list(8840.000000 6265.000000) nil) | 6@@list("PR70246" "MX_R0805_SMALL_T02" list(7760.000000 2617.000000) nil) | 6@@list("PR70250" "MX_R0402_SMALL_T01" list(8520.000000 5680.000000) nil) | 6@@list("PR70254" "MX_R0402_SMALL_T01" list(1600.000000 9090.000000) nil) | 6@@list("PR70256" "MX_R0402_SMALL_T01" list(2129.000000 4906.000000) nil) | 6@@list("PR70260" "MX_R0402_SMALL_T01" list(8581.000000 8905.000000) nil) | 6@@list("PR70261" "MX_R0402_SMALL_T01" list(2549.000000 4940.000000) nil) | 6@@list("PR70291" "MX_R0805_SMALL_T02" list(8117.000000 3296.000000) nil) | 6@@list("PR70296" "MX_R0805_SMALL_T02" list(9000.000000 7720.000000) nil) | 6@@list("PR70298" "MX_R0402_SMALL_T01" list(1781.000000 9333.000000) nil) | 6@@list("PR8" "MX_R0805_SMALL_T02" list(8562.000000 8496.000000) nil) | 6@@list("PR9" "MX_R0805_SMALL_T02" list(8215.000000 8330.000000) nil) | 6@@list("PRT581" "MX_R0402_SMALL_T01" list(2960.000000 7225.000000) nil) | 6@@list("PRT582" "MX_R0402_SMALL_T01" list(3953.000000 8511.000000) nil) | 6@@list("PRT583" "MX_R0402_SMALL_T01" list(2513.000000 7431.000000) nil) | 6@@list("PRT584" "MX_R0402_SMALL_T01" list(3995.000000 8980.000000) nil) | 6@@list("PU10" "MX_DFN_10P_20_S118_PAD_R_4V" list(2725.000000 4790.000000) nil) | 6@@list("PU12" "MX_SOIC_8P_26_118X110_MAXIM" list(4642.000000 2072.000000) nil) | 6@@list("PU5" "MX_SOT23_S6_FITI" list(4990.000000 3802.000000) nil) | 6@@list("PU591" "MX_DFN_8P_20_79X79_PAD_RIC" list(2782.420000 7344.710000) nil) | 6@@list("PU592" "MX_DFN_8P_20_79X79_PAD_RIC" list(2638.100000 8073.710000) nil) | 6@@list("PU601" "MX_DFN_8P_20_79X79_PAD_RIC" list(2777.180000 6661.710000) nil) | 6@@list("PU602" "MX_DFN_8P_20_79X79_PAD_RIC" list(2806.860000 5989.710000) nil) | 6@@list("PU611" "MX_DFN_8P_20_79X79_PAD_RIC" list(3758.000000 8955.000000) nil) | 6@@list("PU612" "MX_DFN_8P_20_79X79_PAD_RIC" list(5816.340000 8998.710000) nil) | 6@@list("PU651" "MX_DFN_10P_20_S118_PAD_R_4V" list(8400.000000 8700.000000) nil) | 6@@list("PU681" "MX_SOIC_8P_50_201X236_P_NIK" list(1737.000000 9144.000000) nil) | 6@@list("PU7" "MX_DFN_10P_20_S118_PAD_R_4V" list(8340.000000 4940.000000) nil) | 6@@list("PU80" "MX_SOIC_8P_50_201X236_PAD" list(8250.000000 5906.000000) nil) | 6@@list("PU9" "MX_DFN_10P_20_S118_PAD_R_4V" list(7583.000000 3596.000000) nil) | 6@@list("P_HDDFAN" "MX_WTOB_4P_49_2H_XINA" list(3488.000000 287.000000) nil) | 6@@list("Q3" "MX_SOT363" list(3820.000000 485.000000) nil) | 6@@list("Q35" "MX_SOT363" list(9047.000000 8510.000000) nil) | 6@@list("Q4" "MX_SOT23" list(4151.000000 307.000000) nil) | 6@@list("Q5" "MX_SOT363" list(4120.000000 485.000000) nil) | 6@@list("Q53" "MX_SOT363" list(8485.000000 5485.000000) nil) | 6@@list("Q9" "MX_SOT23" list(1112.000000 1610.000000) nil) | 6@@list("R18" "MX_R0402_SMALL_T01" list(8486.000000 1812.000000) nil) | 6@@list("R19" "MX_R0402_SMALL_T01" list(8422.000000 1812.000000) nil) | 6@@list("R25" "MX_R0603_SMALL_T01" list(4055.000000 224.000000) nil) | 6@@list("R27" "MX_R0603_SMALL_T01" list(3931.000000 224.000000) nil) | 6@@list("R30" "MX_R0603_SMALL_T01" list(3746.000000 224.000000) nil) | 6@@list("R31" "MX_R0603_SMALL_T01" list(3982.000000 224.000000) nil) | 6@@list("R36" "MX_R0805_SMALL_T02_H26" list(1239.000000 1653.000000) nil) | 6@@list("R37" "MX_R0402_SMALL_T01" list(1109.000000 1495.000000) nil) | 6@@list("R37456" "R0402" list(8760.000000 4136.000000) nil) | 6@@list("R60373" "MX_R0402_SMALL_T01" list(8886.000000 4124.000000) nil) | 6@@list("R60374" "MX_R0402_SMALL_T01" list(8808.000000 4605.000000) nil) | 6@@list("R60375" "R0402" list(8880.520000 3137.000000) nil) | 6@@list("R60381" "MX_R0402_SMALL_T01" list(8772.000000 4605.000000) nil) | 6@@list("R60385" "MX_R0402_SMALL_T01" list(8836.000000 4135.000000) nil) | 6@@list("R636" "MX_R0402_SMALL_T01" list(8880.000000 1350.000000) nil) | 6@@list("R69583" "MX_R0402_SMALL_T01" list(8882.000000 3175.000000) nil) | 6@@list("R69584" "MX_R0402_SMALL_T01" list(8798.000000 4135.000000) nil) | 6@@list("R69686" "MX_R0603_SMALL_T01" list(3871.000000 224.000000) nil) | 6@@list("R69687" "MX_R0603_SMALL_T01" list(3807.000000 224.000000) nil) | 6@@list("R69694" "MX_R0402_SMALL_T01" list(4653.000000 2210.000000) nil) | 6@@list("R69695" "MX_R0402_SMALL_T01" list(8720.500000 3908.000000) nil) | 6@@list("RFC100" "MX_C0402_SMALL_T01" list(8218.000000 5662.000000) nil) | 6@@list("RFC101" "MX_C0402_SMALL_T01" list(8221.980000 6259.950000) nil) | 6@@list("RFC102" "MX_C0402_SMALL_T01" list(8149.000000 4032.000000) nil) | 6@@list("RFC103" "MX_C0402_SMALL_T01" list(8182.000000 6480.000000) nil) | 6@@list("RFC104" "MX_C0402_SMALL_T01" list(6876.000000 3987.000000) nil) | 6@@list("RFC105" "MX_C0402_SMALL_T01" list(7510.000000 5697.000000) nil) | 6@@list("RFC106" "MX_C0402_SMALL_T01" list(8186.000000 6258.000000) nil) | 6@@list("RFC107" "MX_C0402_SMALL_T01" list(8185.000000 4060.000000) nil) | 6@@list("RFC108" "MX_C0402_SMALL_T01" list(7501.000000 5473.000000) nil) | 6@@list("RFC109" "MX_C0402_SMALL_T01" list(8257.980000 6259.950000) nil) | 6@@list("RFC110" "MX_C0402_SMALL_T01" list(8258.000000 4221.000000) nil) | 6@@list("RFC111" "MX_C0402_SMALL_T01" list(8218.000000 5626.000000) nil) | 6@@list("RFC112" "MX_C0402_SMALL_T01" list(2089.000000 2984.000000) nil) | 6@@list("RFC113" "MX_C0402_SMALL_T01" list(911.000000 475.000000) nil) | 6@@list("RFC114" "MX_C0402_SMALL_T01" list(944.000000 685.000000) nil) | 6@@list("RFC115" "MX_C0402_SMALL_T01" list(585.000000 6907.000000) nil) | 6@@list("RFC116" "MX_C0402_SMALL_T01" list(8905.000000 7736.000000) nil) | 6@@list("RFC117" "MX_C0402_SMALL_T01" list(8816.000000 6211.000000) nil) | 6@@list("RFC118" "MX_C0402_SMALL_T01" list(1940.500000 7603.420000) nil) | 6@@list("RFC119" "MX_C0402_SMALL_T01" list(1964.000000 6528.000000) nil) | 6@@list("RFC120" "MX_C0402_SMALL_T01" list(1500.000000 7540.000000) nil) | 6@@list("RFC121" "MX_C0402_SMALL_T01" list(1719.000000 5550.000000) nil) | 6@@list("RFC14" "MX_C0402_SMALL_T01" list(362.000000 5467.000000) nil) | 6@@list("RFC15" "MX_C0402_SMALL_T01" list(858.000000 5493.000000) nil) | 6@@list("RFC29" "MX_C0402_SMALL_T01" list(6837.000000 4195.000000) nil) | 6@@list("RFC30" "MX_C0402_SMALL_T01" list(7505.000000 4290.000000) nil) | 6@@list("RFC31" "MX_C0402_SMALL_T01" list(8181.000000 4300.000000) nil) | 6@@list("RFC32" "MX_C0402_SMALL_T01" list(8145.000000 4300.000000) nil) | 6@@list("RN23" "MX_4R8P0402" list(8040.000000 1286.000000) nil) | 6@@list("RN24" "MX_4R8P0402" list(8040.000000 1560.000000) nil) | 6@@list("RN25" "MX_4R8P0402" list(8040.000000 1460.000000) nil) | 6@@list("RN26" "MX_4R8P0402" list(8290.000000 1705.000000) nil) | 6@@list("SC100" "MX_C0201" list(5302.800000 2430.100000) nil) | 6@@list("SC101" "MX_C0603_SMALL_T01" list(5207.500000 2419.900000) nil) | 6@@list("SC102" "MX_C0603_SMALL_T01" list(6121.500000 1042.000000) nil) | 6@@list("SC103" "MX_C0603_SMALL_T01" list(6068.500000 1043.000000) nil) | 6@@list("SC105" "MX_C0402_SMALL_T01" list(5838.500000 1542.000000) nil) | 6@@list("SC121" "MX_C0402_SMALL_T01" list(5194.000000 1155.000000) nil) | 6@@list("SC141" "MX_C0402_SMALL_T01" list(6427.000000 1239.000000) nil) | 6@@list("SC146" "MX_C0402_SMALL_T01" list(5855.000000 1830.000000) nil) | 6@@list("SC147" "MX_C0402_SMALL_T01" list(6528.000000 948.000000) nil) | 6@@list("SC148" "MX_C0402_SMALL_T01" list(6202.000000 1135.000000) nil) | 6@@list("SC149" "MX_C0402_SMALL_T01" list(5180.000000 1103.000000) nil) | 6@@list("SC152" "MX_C0402_SMALL_T01" list(710.000000 6617.000000) nil) | 6@@list("SC153" "MX_C0402_SMALL_T01" list(710.000000 6653.000000) nil) | 6@@list("SC154" "MX_C0402_SMALL_T01" list(2925.000000 2618.000000) nil) | 6@@list("SC155" "MX_C0402_SMALL_T01" list(2790.000000 2617.000000) nil) | 6@@list("SC156" "MX_C0402_SMALL_T01" list(2961.000000 2618.000000) nil) | 6@@list("SC157" "MX_C0402_SMALL_T01" list(2826.000000 2617.000000) nil) | 6@@list("SC158" "MX_C0402_SMALL_T01" list(2646.000000 1820.000000) nil) | 6@@list("SC159" "MX_C0402_SMALL_T01" list(2925.000000 1815.000000) nil) | 6@@list("SC160" "MX_C0402_SMALL_T01" list(2488.000000 1848.000000) nil) | 6@@list("SC161" "MX_C0402_SMALL_T01" list(2765.000000 1815.000000) nil) | 6@@list("SC162" "MX_C0402_SMALL_T01" list(2524.000000 1848.000000) nil) | 6@@list("SC163" "MX_C0402_SMALL_T01" list(2961.000000 1815.000000) nil) | 6@@list("SC164" "MX_C0402_SMALL_T01" list(2610.000000 1820.000000) nil) | 6@@list("SC165" "MX_C0402_SMALL_T01" list(2801.000000 1815.000000) nil) | 6@@list("SC166" "MX_C0402_SMALL_T01" list(8947.000000 4413.500000) nil) | 6@@list("SC167" "MX_C0402_SMALL_T01" list(8958.000000 3261.000000) nil) | 6@@list("SC168" "MX_C0603_SMALL_T01" list(5366.300000 2484.100000) nil) | 6@@list("SC170" "MX_C0402_SMALL_T01" list(977.000000 9024.000000) nil) | 6@@list("SC171" "MX_C0402_SMALL_T01" list(767.000000 9022.000000) nil) | 6@@list("SC172" "MX_C0603_SMALL_T01" list(654.000000 9163.220000) nil) | 6@@list("SC173" "MX_C0402_SMALL_T01" list(917.000000 9153.000000) nil) | 6@@list("SC174" "MX_C0201" list(6285.000000 1235.000000) nil) | 6@@list("SC175" "MX_C0402_SMALL_T01" list(6588.000000 1280.000000) nil) | 6@@list("SC32" "MX_C0402_SMALL_T01" list(2478.000000 2618.000000) nil) | 6@@list("SC52" "MX_C0402_SMALL_T01" list(8707.000000 865.000000) nil) | 6@@list("SC6" "MX_C0402_SMALL_T01" list(6039.000000 1264.000000) nil) | 6@@list("SC61" "MX_C0402_SMALL_T01" list(2442.000000 2618.000000) nil) | 6@@list("SC62" "MX_C0402_SMALL_T01" list(2619.000000 2617.000000) nil) | 6@@li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