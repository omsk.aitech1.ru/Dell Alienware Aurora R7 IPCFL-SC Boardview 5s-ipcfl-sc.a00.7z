# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_DQ62: length 109.2
  TOP w0.102: CON_XMM4.280 198.52,110.4 198.6,110.31 198.6,110.08 198.7,109.98 199.06,109.98 199.16,110.09 199.16,110.26 199.3,110.4 200.91,110.4 201.02,110.29 201.02,109.65 201.12,109.55 v1(201.45,109.55) 202.23,109.55 202.39,109.4 202.79,109.4 202.97,109.58 202.97,110.21 203.16,110.4 CON_XMM2.280
  TOP w0.159: v1(129.57,147.56) XU1.AE7
  IN1 w0.102: 131.11,139.98 131.11,146.58 130.61,147.08 130.05,147.08 v1(129.57,147.56)
  IN1 w0.14: 131.11,139.98 131.11,137.52 131.27,137.36 131.27,135.35 149.83,116.79 150.19,116.79 150.37,116.97 150.67,116.97 152.09,115.55 152.09,115.28 151.89,115.09 151.89,114.82 152.08,114.63 152.35,114.63 152.54,114.83 152.81,114.83 157.82,109.82 175.02,109.82 175.25,110.05 175.42,110.22 176.28,110.22 177.13,109.37 178.23,109.37 179.33,110.22 180.1,110.22 180.95,109.37 182.14,109.37 183.26,110.22 184.06,110.22 184.91,109.37 185.98,109.37 187.09,110.22 188.02,110.22 188.87,111.07 189.34,111.07 191.6,110.58 192.68,110.58 193.6,111.07 194.36,111.07 195.21,110.22 196.51,110.22 197.08,109.65 198.05,109.65 200.01,110.31 200.69,110.31 v1(201.45,109.55)
M_CHB_DQ63: length 108.2
  TOP w0.102: CON_XMM4.137 192.38,108.86 192.53,108.71 193.09,108.71 193.24,108.86 193.24,109.52 193.45,109.73 194.77,109.73 v1(195.52,108.98) 195.66,108.84 196.55,108.84 197.25,109.55 CON_XMM2.137
  TOP w0.159: v1(130.48,146.61) 130.48,146.64 XU1.AF6
  IN1 w0.102: 130.61,141.56 130.91,141.86 130.91,146.18 v1(130.48,146.61)
  IN1 w0.14: 130.61,141.56 130.61,135.11 150.1,115.62 150.37,115.62 150.61,115.86 150.88,115.86 151.07,115.67 151.07,115.4 150.83,115.16 150.83,114.89 151.97,113.75 152.23,113.75 152.48,114 152.74,114 152.96,113.78 152.96,113.51 152.72,113.27 152.72,113 152.92,112.8 153.18,112.8 153.43,113.05 153.69,113.05 153.88,112.86 153.88,112.59 153.64,112.35 153.64,112.08 153.83,111.89 154.1,111.89 154.34,112.13 154.61,112.13 154.8,111.94 154.8,111.67 154.56,111.43 154.56,111.16 154.75,110.97 155.02,110.97 155.26,111.21 155.53,111.21 155.72,111.02 155.72,110.76 155.48,110.51 155.48,110.25 155.74,109.98 155.91,109.98 156.18,110.26 156.36,110.26 156.59,110.03 156.59,109.88 156.31,109.6 156.31,109.41 156.54,109.18 175.14,109.18 175.45,108.88 176.45,108.88 177.29,108.04 177.29,108.04 177.3,108.03 178.01,108.03 178.86,108.88 180.2,108.88 181.05,108.03 181.82,108.03 182.67,108.88 184.16,108.88 185.01,108.03 185.82,108.03 186.67,108.88 188.1,108.88 188.77,109.55 189.41,109.55 190.09,108.86 190.78,108.86 191.24,109.32 191.24,109.7 191.75,110.22 192.83,110.22 193.32,109.73 194.77,109.73 v1(195.52,108.98)
M_CHB_DQS0: length 122.2
  TOP w0.102: CON_XMM2.153 204.32,223.45 204.6,223.72 204.6,224.03 204.42,224.21 203.74,224.21 202.23,223.42 201.45,223.42 200.32,224.2 199.56,224.2 v1(199.39,224.03) 199.36,224.03 199.1,224.29 198.82,224.29 198.74,224.22 198.74,224.01 199.38,223.38 199.38,222.59 199.2,222.42 198.7,222.42 198.44,222.68 198.44,222.88 197.92,223.39 197.69,223.39 197.46,223.16 197.08,223.16 196.87,223.37 196.87,223.44 196.73,223.58 196.32,223.58 CON_XMM4.153
  TOP w0.165: XU1.AF35 130.68,175.82 130.56,175.94 v1(130.56,176.26)
  IN1 w0.102: 129.17,182.37 129.17,182.26 129.13,182.22 129.13,181.38 130.14,180.38 130.14,175.99 130.35,175.78 130.69,175.78 130.81,175.9 130.81,176.01 v1(130.56,176.26)
  IN1 w0.133: v1(199.39,224.03) 199.08,224.03 198.35,223.3 197.42,223.3 196.56,224.16 195.8,224.16 194.32,223.32 193.65,223.32 192.78,222.45 191.91,222.45 189.39,221.65 188.69,221.65 187.81,222.53 187.21,222.53 185.59,221.62 184.99,221.62 184.1,222.5 183.06,222.5 182.21,221.66 180.93,221.66 180.93,221.66 180.91,221.66 180.11,222.46 179.15,222.46 178.29,221.6 177.18,221.6 176.26,222.52 175.68,222.52 169.35,220.05 167.47,218.17 160.57,218.17 159.76,218.98 159.31,218.98 159.19,218.86 159.19,218.5 158.85,218.16 158.31,218.16 157.89,218.57 157.89,218.77 157.63,219.03 157.26,219.03 156.92,218.69 156.92,218.52 156.64,218.24 155.84,218.24 152.34,214.74 149.33,214.74 128.39,193.79 128.39,184.09 129.17,183.31 129.17,182.37
M_CHB_DQS0#: length 122.1
  TOP w0.102: CON_XMM2.152 204.64,224.3 204.51,224.42 203.69,224.42 202.18,223.63 201.52,223.63 200.39,224.41 199.56,224.41 v1(199.31,224.66) 199.16,224.51 198.73,224.51 198.53,224.3 198.53,223.92 199.16,223.29 199.16,222.68 199.11,222.63 198.79,222.63 198.65,222.77 198.65,222.97 198.01,223.61 197.6,223.61 197.37,223.38 197.17,223.38 197.1,223.45 197.1,223.87 197.26,224.02 CON_XMM4.152
  TOP w0.165: XU1.AF34 v1(130.48,175.36)
  IN1 w0.102: v1(130.48,175.36) 129.94,175.91 129.94,180.29 128.93,181.3 128.93,182.3 128.92,182.31 128.92,182.37
  IN1 w0.133: v1(199.31,224.66) 199.31,224.61 198.25,223.55 197.52,223.55 196.66,224.4 195.73,224.4 194.26,223.56 193.55,223.56 192.68,222.69 191.87,222.69 189.35,221.9 188.79,221.9 187.91,222.78 187.14,222.78 185.53,221.86 185.1,221.86 184.21,222.75 182.95,222.75 182.11,221.91 181.01,221.91 180.22,222.7 179.05,222.7 178.19,221.84 177.29,221.84 176.36,222.77 175.65,222.77 169.21,220.26 167.37,218.42 160.68,218.42 159.87,219.23 159.21,219.23 158.94,218.96 158.94,218.61 158.74,218.41 158.41,218.41 158.15,218.67 158.15,218.87 157.74,219.28 157.16,219.28 156.67,218.79 156.67,218.62 156.54,218.48 155.73,218.48 152.23,214.99 149.23,214.99 128.14,193.9 128.14,183.98 128.92,183.21 128.92,182.37
M_CHB_DQS1: length 114.4
  TOP w0.102: CON_XMM4.164 197.04,214.1 196.94,214.2 196.94,214.34 197.18,214.58 197.18,214.76 197.27,214.86 198.08,214.86 198.94,215.72 199.17,215.72 199.3,215.58 199.3,215.4 198.5,214.6 198.5,214.21 198.79,213.92 199.21,213.92 v1(199.34,213.79) 199.56,214.01 200.59,214.01 201.4,214.81 202.05,214.81 203.61,214.01 204.47,214.01 204.48,214.02 204.55,214.02 CON_XMM2.164
  TOP w0.165: XU1.AL33 v1(135.04,173.52)
  IN1 w0.102: 134.41,182.48 134.41,182.47 134.38,182.44 134.38,182.39 134.37,182.37 134.37,182.3 135.22,181.44 135.22,180.64 135.03,180.44 135.03,178.19 135.64,177.57 135.64,175.13 134.6,174.1 134.6,173.68 134.76,173.52 v1(135.04,173.52)
  IN1 w0.133: 134.41,182.48 134.41,191.39 149.45,206.43 150.37,206.43 150.93,205.87 151.31,205.87 151.8,206.36 151.8,206.75 151.3,207.24 151.3,207.57 152.27,208.53 166.54,208.53 171.96,213.95 176.29,213.95 177.11,213.13 178.18,213.13 179.01,213.96 180.13,213.96 181.02,213.06 182.09,213.06 183.06,214.03 184.02,214.03 184.94,213.11 185.85,213.11 186.71,213.97 187.88,213.97 188.72,213.13 190.68,213.13 191.58,214.03 192.68,214.03 193.6,213.11 194.54,213.11 195.38,213.95 196.5,213.95 197.43,214.88 198.18,214.88 198.45,214.61 198.45,214.5 198.78,214.17 198.96,214.17 v1(199.34,213.79)
M_CHB_DQS1#: length 114.3
  TOP w0.102: CON_XMM4.163 196.63,214.5 196.8,214.5 196.96,214.67 196.96,214.85 197.18,215.07 197.99,215.07 198.85,215.93 199.26,215.93 199.52,215.67 199.52,215.31 198.71,214.51 198.71,214.3 198.88,214.13 199.05,214.13 v1(199.34,214.43) 199.54,214.22 200.5,214.22 201.31,215.03 202.11,215.03 203.66,214.22 204.39,214.22 204.57,214.4 204.57,214.51 204.38,214.7 CON_XMM2.163
  TOP w0.165: v1(134.14,173.53) XU1.AK33
  IN1 w0.102: v1(134.14,173.53) 134.16,173.53 134.4,173.77 134.4,174.18 135.44,175.22 135.44,177.49 134.82,178.1 134.82,180.53 135.02,180.72 135.02,181.35 134.16,182.21 134.16,182.48
  IN1 w0.133: v1(199.34,214.43) 198.87,214.43 198.7,214.6 198.7,214.71 198.28,215.13 197.33,215.13 196.4,214.2 195.28,214.2 194.44,213.36 193.7,213.36 192.78,214.28 191.48,214.28 190.58,213.38 188.82,213.38 187.98,214.22 186.6,214.22 185.75,213.36 185.04,213.36 184.12,214.27 182.96,214.27 181.99,213.31 181.13,213.31 180.23,214.21 178.91,214.21 178.08,213.38 177.21,213.38 176.39,214.2 171.86,214.2 166.44,208.78 152.17,208.78 151.05,207.67 151.05,207.14 151.55,206.65 151.55,206.47 151.2,206.12 151.03,206.12 150.48,206.67 149.34,206.67 134.16,191.49 134.16,182.48
M_CHB_DQS2: length 101.9
  TOP w0.102: CON_XMM4.175 196.59,205.15 196.75,205.15 197.29,204.61 198.01,204.61 198.46,204.15 198.46,204 198.77,203.7 199.15,203.7 199.49,204.04 199.49,204.47 198.72,205.24 198.72,205.38 198.82,205.47 199.17,205.47 199.34,205.31 v1(199.34,205.26) 199.57,205.49 200.4,205.49 201.51,204.65 202.03,204.65 203.6,205.48 204.44,205.48 204.57,205.35 204.57,205.17 204.38,204.98 CON_XMM2.175
  TOP w0.165: XU1.AP33 v1(138.71,174.45)
  IN1 w0.102: 140.98,182.22 140.95,182.2 140.95,178.39 139.7,177.13 139.7,175.66 139.12,175.08 138.72,175.08 138.25,174.61 138.25,174.42 138.37,174.29 138.56,174.29 v1(138.71,174.45)
  IN1 w0.133: 140.98,182.22 140.98,183.1 140.38,183.69 140.38,188.55 142.46,190.63 144.15,190.63 145.13,191.61 145.13,192.36 145.43,192.67 146.46,192.67 147.39,193.59 147.39,194.62 147.71,194.94 165.14,194.94 175.66,205.46 176.3,205.46 177.08,204.68 178.29,204.68 179.09,205.48 180.04,205.48 180.9,204.63 182.05,204.63 182.93,205.51 184.07,205.51 184.91,204.67 186,204.67 186.82,205.49 187.87,205.49 188.73,204.62 191.11,204.62 192,205.51 192.71,205.51 193.59,204.62 194.44,204.62 195.33,205.51 196.55,205.51 197.45,204.6 198.18,204.6 199.03,205.46 199.14,205.46 v1(199.34,205.26)
M_CHB_DQS2#: length 101.8
  TOP w0.102: CON_XMM4.174 197.14,205.6 196.96,205.42 196.96,205.24 197.38,204.82 198.1,204.82 198.68,204.24 198.68,204.09 198.86,203.91 199.06,203.91 199.28,204.13 199.28,204.38 198.51,205.15 198.51,205.47 198.73,205.69 199.14,205.69 v1(199.34,205.89) 199.53,205.7 200.47,205.7 201.58,204.86 201.98,204.86 203.55,205.7 204.53,205.7 204.63,205.6 CON_XMM2.174
  TOP w0.165: XU1.AN33 v1(137.8,174.45)
  IN1 w0.102: 140.74,182.33 140.73,182.32 140.73,182.21 140.75,182.19 140.75,178.47 139.5,177.22 139.5,175.74 139.04,175.29 138.64,175.29 v1(137.8,174.45)
  IN1 w0.133: v1(199.34,205.89) 199.16,205.71 198.93,205.71 198.07,204.85 197.56,204.85 196.65,205.76 195.22,205.76 194.33,204.87 193.7,204.87 192.81,205.76 191.9,205.76 191.01,204.87 188.83,204.87 187.97,205.73 186.71,205.73 185.9,204.92 185.01,204.92 184.18,205.76 182.83,205.76 181.95,204.88 181,204.88 180.14,205.73 178.99,205.73 178.19,204.93 177.19,204.93 176.41,205.71 175.56,205.71 165.04,195.19 147.61,195.19 147.14,194.72 147.14,193.69 146.36,192.91 145.33,192.91 144.88,192.46 144.88,191.71 144.05,190.88 142.36,190.88 140.13,188.66 140.13,183.59 140.74,182.98 140.74,182.33
M_CHB_DQS3: length 94.7
  TOP w0.102: CON_XMM2.186 204.64,195.4 204.53,195.29 203.71,195.29 201.99,196.1 201.4,196.1 200.54,195.24 199.5,195.24 v1(199.34,195.07) 199.17,195.24 198.73,195.24 198.46,195.5 198.46,195.8 199.2,196.54 199.2,196.71 199.03,196.88 198.81,196.88 198.13,196.19 197.23,196.19 197.13,196.09 197.13,195.78 196.91,195.55 196.91,195.35 197.05,195.2 197.59,195.2 CON_XMM4.186
  TOP w0.165: v1(137.78,169.89) 137.47,169.89 137.34,169.76 XU1.AN28
  IN1 w0.102: v1(137.78,169.89) 138.34,170.45 138.34,171.02 138.49,171.17 140.32,171.17 141.42,172.26 141.8,172.26 142.52,172.99 142.52,174.39 144.04,175.9 147.02,175.9 147.04,175.87 147.11,175.87
  IN1 w0.133: 147.11,175.87 147.29,175.87 151.31,179.89 152.43,179.89 152.76,180.22 152.76,180.69 152.57,180.88 152.57,181.15 152.76,181.34 153.02,181.34 153.21,181.15 153.68,181.15 154.02,181.48 154.02,181.95 153.83,182.14 153.83,182.41 154.02,182.6 154.28,182.6 154.47,182.41 154.94,182.41 155.27,182.74 155.27,183.21 155.09,183.4 155.09,183.67 155.27,183.85 155.54,183.85 155.73,183.66 156.2,183.66 156.53,184 156.53,184.95 159.51,187.93 171.75,187.93 175.72,191.9 176.45,191.9 177.29,192.74 178.56,192.74 179.4,193.57 180.16,193.57 180.97,192.76 182.3,192.76 183.06,193.52 184.02,193.52 184.78,192.76 186.39,192.76 187.17,193.55 187.91,193.55 188.72,192.74 190.86,192.74 191.67,193.55 192.71,193.55 193.62,194.46 194.97,194.46 195.76,195.25 196.49,195.25 197.31,196.07 198.62,196.07 198.9,195.79 198.9,195.4 198.81,195.3 198.81,195.1 198.97,194.93 199.2,194.93 v1(199.34,195.07)
M_CHB_DQS3#: length 94.6
  TOP w0.102: CON_XMM4.185 196.18,195.94 196.44,195.68 196.73,195.68 196.91,195.86 196.91,196.18 197.14,196.41 198.04,196.41 198.72,197.09 199.12,197.09 199.42,196.8 199.42,196.45 198.68,195.71 198.68,195.59 198.82,195.45 199.09,195.45 v1(199.34,195.71) 199.59,195.45 200.45,195.45 201.31,196.32 202.04,196.32 203.75,195.5 204.44,195.5 204.55,195.61 204.55,195.83 204.38,196 CON_XMM2.185
  TOP w0.165: XU1.AN29 v1(136.88,169.87)
  IN1 w0.102: 147.02,176.12 147,176.11 143.95,176.11 142.32,174.47 142.32,173.08 141.71,172.47 141.33,172.47 140.24,171.37 138.4,171.37 138.14,171.11 138.14,170.53 137.93,170.33 137.62,170.33 137.16,169.87 v1(136.88,169.87)
  IN1 w0.133: 147.02,176.12 147.19,176.12 151.21,180.14 152.32,180.14 152.51,180.33 152.51,180.59 152.32,180.78 152.32,181.25 152.66,181.59 153.13,181.59 153.32,181.4 153.58,181.4 153.77,181.58 153.77,181.85 153.58,182.04 153.58,182.51 153.91,182.84 154.38,182.84 154.57,182.65 154.84,182.65 155.03,182.84 155.03,183.11 154.84,183.3 154.84,183.77 155.17,184.1 155.64,184.1 155.83,183.91 156.1,183.91 156.28,184.1 156.28,185.06 159.41,188.18 171.65,188.18 175.61,192.14 176.35,192.14 177.19,192.98 178.46,192.98 179.3,193.82 180.26,193.82 181.08,193.01 182.19,193.01 182.96,193.77 184.13,193.77 184.89,193.01 186.28,193.01 187.07,193.8 188.01,193.8 188.82,192.98 190.75,192.98 191.57,193.8 192.61,193.8 193.52,194.71 194.87,194.71 195.66,195.5 196.39,195.5 197.21,196.32 198.72,196.32 199.33,195.71 v1(199.34,195.71)
M_CHB_DQS4: length 88.8
  TOP w0.102: CON_XMM4.245 196.5,140.46 196.73,140.46 196.91,140.29 196.91,140.27 197.17,140.01 197.98,140.01 198.88,139.12 199.25,139.12 199.55,139.41 199.55,139.75 198.66,140.63 198.66,140.82 198.76,140.92 199.14,140.92 v1(199.36,140.69) 199.58,140.91 200.33,140.91 201.36,140.13 202.15,140.13 203.73,140.89 204.5,140.89 204.52,140.86 204.57,140.76 204.57,140.58 204.49,140.5 CON_XMM2.245
  TOP w0.165: v1(136.88,154.33) XU1.AN12
  IN1 w0.102: 143.86,150.22 143.84,150.26 142.32,151.79 141.6,151.79 140.77,152.62 140.5,152.62 140.3,152.82 138.56,152.82 138.56,152.82 138.39,152.82 v1(136.88,154.33)
  IN1 w0.133: 143.86,150.22 143.86,150.22 143.92,150.06 143.92,149.96 145.72,148.16 153.55,148.16 163.08,138.64 173.18,138.64 174.34,137.48 176.28,137.48 177.18,136.58 178.14,136.58 179.09,137.53 180.05,137.53 180.99,136.59 182.13,136.59 182.73,137.19 183.41,137.46 184.1,137.46 185.01,136.56 185.78,136.56 186.64,137.42 187.87,137.42 188.79,138.33 190.73,138.33 191.53,139.13 192.73,139.13 193.63,140.03 194.63,140.03 195.52,140.93 196.46,140.93 197.33,140.06 198.12,140.06 198.62,140.56 198.83,140.56 198.93,140.46 198.93,140.21 199.06,140.08 199.21,140.08 199.36,140.23 v1(199.36,140.69)
M_CHB_DQS4#: length 88.8
  TOP w0.102: CON_XMM2.244 204.7,141 204.59,141.1 203.68,141.1 202.1,140.34 201.43,140.34 200.4,141.12 199.56,141.12 v1(199.36,141.33) 199.17,141.14 198.67,141.14 198.45,140.91 198.45,140.54 199.33,139.66 199.33,139.5 199.16,139.34 198.97,139.34 198.07,140.23 197.26,140.23 197.13,140.36 197.13,140.87 197.25,141 CON_XMM4.244
  TOP w0.165: XU1.AN13 v1(136.88,155.24)
  IN1 w0.102: v1(136.88,155.24) 136.88,154.92 137.39,154.42 137.39,154.11 138.48,153.03 140.38,153.03 140.58,152.83 140.85,152.83 141.68,151.99 142.4,151.99 143.99,150.41 144.07,150.32
  IN1 w0.133: v1(199.36,141.33) 198.84,140.81 198.52,140.81 198.01,140.3 197.43,140.3 196.56,141.17 195.42,141.17 194.53,140.28 193.53,140.28 192.63,139.38 191.43,139.38 190.63,138.58 188.69,138.58 187.77,137.67 186.54,137.67 185.68,136.81 185.11,136.81 184.21,137.71 183.36,137.71 182.59,137.4 182.03,136.84 181.1,136.84 180.16,137.78 178.99,137.78 178.03,136.83 177.28,136.83 176.39,137.73 174.44,137.73 173.28,138.89 163.18,138.89 153.65,148.41 145.82,148.41 144.17,150.07 144.17,150.12 144.09,150.31 144.08,150.32 144.07,150.32
M_CHB_DQS5: length 90.8
  TOP w0.102: CON_XMM4.256 196.97,130.8 196.88,130.89 196.88,131.01 197.42,131.55 198.2,131.55 198.97,132.32 199.12,132.32 199.26,132.18 199.26,132.03 198.44,131.21 198.44,130.88 198.67,130.64 199.19,130.64 199.2,130.65 v1(199.36,130.49) 199.57,130.7 200.58,130.7 201.4,131.51 201.99,131.51 203.71,130.69 204.58,130.69 204.68,130.8 CON_XMM2.256
  TOP w0.165: XU1.AP8 v1(137.8,148.47)
  IN1 w0.102: 141.13,143.58 141.12,143.59 141.12,143.63 141.08,143.66 141.08,143.72 141.08,143.9 141.1,143.91 141.1,145.8 138.2,148.7 138.02,148.7 v1(137.8,148.47)
  IN1 w0.133: v1(199.36,130.49) 199.12,130.73 198.86,130.73 198.09,131.5 197.41,131.5 196.6,130.68 195.28,130.68 194.41,129.82 193.5,129.82 192.61,130.71 191.95,130.71 191.24,130 189.76,130 189.64,129.87 188.87,129.87 187.95,128.96 186.72,128.96 185.88,128.12 184.86,128.12 184,128.98 182.85,128.98 182,128.12 180.92,128.12 180.06,128.98 179.07,128.98 178.24,128.15 177.11,128.15 176.28,128.98 164.24,128.98 152.32,140.9 148.76,140.9 148.05,141.61 147.63,141.61 146.91,140.89 146.23,140.89 145.51,141.61 145.09,141.61 144.45,140.97 143.74,140.97 141.13,143.58
M_CHB_DQS5#: length 90.8
  TOP w0.102: CON_XMM2.255 204.38,131.41 204.57,131.22 204.57,130.99 204.49,130.91 203.75,130.91 202.04,131.72 201.31,131.72 200.49,130.91 199.57,130.91 v1(199.36,131.12) 199.1,130.86 198.76,130.86 198.65,130.97 198.65,131.12 199.47,131.94 199.47,132.27 199.21,132.54 198.88,132.54 198.12,131.77 197.33,131.77 196.7,131.14 196.49,131.14 196.18,131.45 CON_XMM4.255
  TOP w0.165: XU1.AR8 v1(137.8,149.39)
  IN1 w0.102: 141.3,143.76 141.3,145.88 v1(137.8,149.39)
  IN1 w0.133: 141.3,143.76 143.84,141.22 144.35,141.22 144.99,141.86 145.61,141.86 146.34,141.13 146.8,141.13 147.53,141.86 148.15,141.86 148.87,141.14 152.42,141.14 164.34,129.23 176.39,129.23 177.22,128.4 178.14,128.4 178.97,129.23 180.16,129.23 181.02,128.37 181.89,128.37 182.75,129.23 184.11,129.23 184.96,128.37 185.78,128.37 186.61,129.2 187.85,129.2 188.77,130.12 189.53,130.12 189.66,130.24 191.13,130.24 191.84,130.96 192.72,130.96 193.61,130.07 194.31,130.07 195.17,130.93 196.49,130.93 197.31,131.74 198.2,131.74 198.96,130.98 199.21,130.98 v1(199.36,131.12)
M_CHB_DQS6: length 104.5
  TOP w0.102: CON_XMM4.267 196.41,121.67 196.88,121.67 197.19,121.36 198.2,121.36 198.46,121.09 198.46,120.62 198.77,120.31 199.14,120.31 199.46,120.62 199.46,121.29 198.73,122.02 198.73,122.15 198.78,122.21 199.15,122.21 v1(199.36,122) 199.58,122.21 200.49,122.21 201.37,121.33 201.96,121.33 203.67,122.17 204.44,122.17 204.57,122.05 204.57,121.89 204.38,121.69 CON_XMM2.267
  TOP w0.165: v1(134.14,149.39) XU1.AL8
  IN1 w0.102: v1(134.14,149.39) 134.38,149.15 134.38,148.84 135.45,147.76 135.45,147.12 135.98,146.59 135.98,144.86 136.45,144.39 136.45,142.67 136.93,142.19 136.93,140.08 137.08,139.92 137.08,139.9
  IN1 w0.133: 137.08,139.9 143.15,133.83 147.4,133.83 157.1,124.13 157.1,120.9 160.69,117.31 165.44,117.31 168.88,120.75 174.08,120.75 174.41,120.42 176.35,120.42 177.16,119.61 177.98,119.61 178.9,120.53 180.15,120.53 181,119.68 181.94,119.68 182.72,120.46 184.2,120.46 184.97,119.68 185.92,119.68 186.76,120.52 188.08,120.52 188.85,121.29 191.08,121.29 191.96,122.17 192.72,122.17 193.54,121.34 194.67,121.34 195.5,122.17 196.51,122.17 197.37,121.31 198.07,121.31 198.98,122.22 199.14,122.22 v1(199.36,122)
M_CHB_DQS6#: length 104.5
  TOP w0.102: CON_XMM2.266 204.65,122.3 204.53,122.42 203.68,122.42 201.91,121.55 201.46,121.55 200.58,122.43 199.56,122.43 v1(199.35,122.63) 199.15,122.43 198.69,122.43 198.51,122.24 198.51,121.93 199.24,121.2 199.24,120.71 199.05,120.52 198.86,120.52 198.68,120.71 198.68,121.18 198.29,121.57 197.28,121.57 197.09,121.77 197.09,122.08 197.3,122.3 CON_XMM4.266
  TOP w0.165: v1(135.06,149.4) 135.06,149.39 XU1.AM8
  IN1 w0.102: v1(135.06,149.4) 134.79,149.4 134.58,149.18 134.58,148.92 135.65,147.85 135.65,147.2 136.18,146.67 136.18,144.95 136.65,144.48 136.65,142.76 137.13,142.28 137.13,140.17 137.21,140.09 137.25,140.09 137.26,140.08
  IN1 w0.133: v1(199.35,122.63) 199.19,122.47 198.88,122.47 197.96,121.55 197.48,121.55 196.61,122.42 195.4,122.42 194.57,121.59 193.64,121.59 192.82,122.42 191.86,122.42 190.98,121.54 188.74,121.54 187.98,120.77 186.66,120.77 185.82,119.93 185.08,119.93 184.3,120.71 182.61,120.71 181.84,119.93 181.1,119.93 180.25,120.78 178.8,120.78 177.88,119.86 177.27,119.86 176.45,120.67 174.51,120.67 174.18,121 168.78,121 165.33,117.56 160.79,117.56 157.35,121 157.35,124.23 147.5,134.08 143.26,134.08 137.26,140.08
M_CHB_DQS7: length 109.4
  TOP w0.102: CON_XMM2.278 204.68,112.1 204.57,111.99 203.75,111.99 202.09,111.18 201.42,111.18 200.63,111.97 199.56,111.97 v1(199.36,111.78) 199.27,111.87 198.72,111.87 198.53,112.07 198.53,112.57 199.37,113.42 199.37,113.54 199.23,113.68 198.98,113.68 198.12,112.81 197.35,112.81 196.95,112.41 196.95,112.27 197.13,112.1 CON_XMM4.278
  TOP w0.165: v1(131.39,148.47) 131.39,148.47 XU1.AG7
  IN1 w0.102: v1(131.39,148.47) 131.39,148.22 130.97,147.8 130.97,147.36 131.66,146.67 131.66,140.67 132.26,140.07 132.26,139.83 132.24,139.81
  IN1 w0.133: 132.24,139.81 132.24,137.88 132.65,137.47 132.65,135.8 143.72,124.73 144.72,124.73 158.25,111.19 172.08,111.19 172.87,111.98 176.27,111.98 177.12,111.14 178.24,111.14 179.08,111.97 180.15,111.97 180.95,111.18 182.17,111.18 183.03,112.03 184.03,112.03 184.88,111.18 185.93,111.18 186.72,111.97 187.99,111.97 188.83,112.81 190.73,112.81 191.6,113.67 192.7,113.67 193.61,112.76 194.73,112.76 195.48,112.01 196.45,112.01 197.31,111.15 198.15,111.15 199.01,112.01 199.13,112.01 v1(199.36,111.78)
M_CHB_DQS7#: length 109.3
  TOP w0.102: CON_XMM2.277 204.38,112.72 204.58,112.51 204.58,112.33 204.46,112.22 203.72,112.22 202.04,111.39 201.51,111.39 200.71,112.19 199.59,112.19 v1(199.36,112.42) 199.04,112.09 198.81,112.09 198.74,112.16 198.74,112.48 199.59,113.33 199.59,113.63 199.32,113.89 198.89,113.89 198.03,113.03 197.26,113.03 196.76,112.52 196.61,112.52 CON_XMM4.277
  TOP w0.165: XU1.AG6 130.94,147.43 131.07,147.56 v1(131.4,147.56)
  IN1 w0.102: 132.48,139.81 132.48,139.82 132.46,139.84 132.46,140.16 131.86,140.75 131.86,146.76 131.73,146.89 131.65,146.97 131.65,147.15 131.89,147.4 131.89,148 131.78,148.11 131.65,148.11 131.4,147.86 v1(131.4,147.56)
  IN1 w0.133: v1(199.36,112.42) 199.21,112.26 198.91,112.26 198.04,111.4 197.41,111.4 196.55,112.26 195.58,112.26 194.83,113.01 193.71,113.01 192.8,113.92 191.5,113.92 190.63,113.06 188.73,113.06 187.89,112.22 186.62,112.22 185.83,111.43 184.98,111.43 184.13,112.28 182.92,112.28 182.07,111.42 181.05,111.42 180.26,112.22 178.98,112.22 178.14,111.39 177.22,111.39 176.38,112.23 172.76,112.23 171.97,111.44 158.35,111.44 144.82,124.97 143.83,124.97 132.89,135.91 132.89,137.57 132.48,137.98 132.48,139.81
M_CHB_MAA0: length 82.8
  TOP w0.203: XU1.AL19 135.05,161.65 v1(135.05,161.66)
  IN1 w0.102: 141.73,160.22 141.2,160.22 141,160.43 138.49,160.43 137.88,161.04 137.29,161.04 137.08,161.24 135.46,161.24 v1(135.05,161.66)
  IN1 w0.178: CON_XMM2.79 199.57,159.44 198.7,159.44 198.11,158.84 197.32,158.84 196.42,159.74 195.05,159.74 194.32,159.01 193.21,159.01 193.04,158.85 192.39,158.85 CON_XMM4.79 191.06,158.84 190.32,158.1 190.32,157.53 189.77,156.98 188.86,156.98 188.01,156.13 186.99,156.13 186.69,155.83 186.69,155.37 186.39,155.07 186.03,155.07 185.81,155.28 184.89,155.28 184.04,156.13 183.27,156.13 182.93,155.79 182.93,155.42 182.58,155.07 182.14,155.07 181.93,155.28 180.91,155.28 180.06,156.13 179.3,156.13 178.45,155.28 177.11,155.28 176.26,156.13 175.51,156.13 175.13,155.75 174.55,155.75 174.35,155.95 174.35,156.45 174.15,156.65 173.87,156.65 173.67,156.45 173.67,155.95 173.47,155.75 173.18,155.75 172.98,155.95 172.98,156.45 172.78,156.65 172.5,156.65 172.3,156.45 172.3,155.95 172.1,155.75 171.81,155.75 171.61,155.95 171.61,156.45 171.41,156.65 171.13,156.65 170.92,156.45 170.92,155.95 170.72,155.75 170.44,155.75 170.24,155.95 170.24,156.45 170.04,156.65 169.75,156.65 169.55,156.45 169.55,155.95 169.35,155.75 169.07,155.75 168.87,155.95 168.87,156.45 168.67,156.65 168.38,156.65 168.18,156.45 168.18,155.95 167.98,155.75 167.55,155.75 167.35,155.95 167.35,156.45 167.15,156.65 166.86,156.65 166.66,156.45 166.66,155.95 166.46,155.75 166.07,155.75 165.91,155.91 165.91,156.48 165.75,156.64 165.33,156.64 164.29,157.68 162.1,157.68 161.64,158.14 161.64,158.78 161.28,159.14 145.97,159.14 145.41,159.69 143.71,159.69 143.18,160.22 141.73,160.22
M_CHB_MAA1: length 83.1
  TOP w0.203: XU1.AL22 135.04,163.46 v1(135.04,163.46)
  IN1 w0.102: 141.48,164.87 141.13,164.52 137.43,164.52 137.14,164.81 135.79,164.81 135.53,164.55 135.53,163.95 v1(135.04,163.46)
  IN1 w0.178: CON_XMM2.72 201.36,170.3 200.93,170.3 200.69,170.06 198.77,170.06 198.25,170.58 197.23,170.58 196.7,170.06 195.28,170.06 195.12,169.9 CON_XMM4.72 192.26,169.9 190.32,167.95 190,167.95 189.56,167.51 188.86,167.51 188.01,168.36 186.65,168.36 185.8,167.51 185.06,167.51 184.22,168.36 182.71,168.36 181.86,167.51 181.09,167.51 180.24,168.36 178.87,168.36 178.02,167.51 177.29,167.51 176.44,168.36 174.99,168.36 174.7,168.07 174.27,168.07 173.98,168.36 173.46,168.36 172.52,167.41 172.09,167.41 171.93,167.56 171.93,168.2 171.77,168.36 171.41,168.36 171.15,168.1 171.15,166.83 170.97,166.65 168.73,166.65 168.58,166.5 168.58,165.25 168.34,165.01 167.86,165.01 167.66,165.21 167.66,166.5 167.46,166.7 166.84,166.7 166.65,166.51 166.65,165.22 166.44,165.01 165.83,165.01 165.62,165.21 165.62,166.5 165.42,166.7 164.78,166.7 164.61,166.52 164.61,165.24 164.38,165.01 146.27,165.01 146.05,165.23 144.02,165.23 143.66,164.87 141.48,164.87
M_CHB_MAA2: length 81.5
  TOP w0.203: XU1.AM22 v1(135.97,164.39)
  IN1 w0.102: 141.15,164.24 141.07,164.31 137.42,164.31 137.07,163.96 136.4,163.96 v1(135.97,164.39)
  IN1 w0.178: CON_XMM2.216 203.1,169.9 202.35,169.15 201.21,169.15 200.63,169.73 199.63,169.73 199.3,169.4 198.28,169.4 CON_XMM4.216 197.35,169.46 196.96,169.46 196.69,169.73 195.69,169.73 195.02,169.06 193.6,169.06 192.74,168.2 191.72,168.2 190.98,167.46 190.35,167.46 190.07,167.18 188.69,167.18 187.84,168.03 187.11,168.03 186.26,167.18 184.89,167.18 184.04,168.03 183.17,168.03 182.32,167.18 180.91,167.18 180.06,168.03 179.28,168.03 178.43,167.18 177.12,167.18 176.27,168.03 175.51,168.03 174.71,167.23 173.2,167.23 171.86,165.89 171.86,164.8 171.63,164.57 171.35,164.57 171.15,164.77 171.15,165.61 170.95,165.81 170.67,165.81 170.47,165.61 170.47,164.77 170.27,164.57 169.98,164.57 169.78,164.77 169.78,165.61 169.58,165.81 169.3,165.81 169.1,165.61 169.1,164.77 168.9,164.57 145.09,164.57 144.76,164.24 141.15,164.24
M_CHB_MAA3: length 80.7
  TOP w0.203: XU1.AM23 v1(136.88,165.3)
  IN1 w0.102: 141.5,165.25 140.98,164.72 137.73,164.72 137.16,165.3 v1(136.88,165.3)
  IN1 w0.178: CON_XMM2.71 198.79,170.75 198.63,170.91 197.26,170.91 196.74,171.43 195.69,171.43 194.84,170.58 192.55,170.58 CON_XMM4.71 190.52,168.88 188.68,168.88 188.24,169.33 188.24,169.33 187.83,169.73 187.08,169.73 186.23,168.88 184.89,168.88 184.04,169.73 183.32,169.73 182.47,168.88 181.66,168.88 181.66,168.88 181.09,168.88 181.09,168.88 180.91,168.88 180.46,169.33 180.46,169.33 180.06,169.73 179.49,169.73 178.64,168.88 177.11,168.88 176.66,169.33 176.26,169.73 175.46,169.73 175.03,170.15 174.82,170.15 174.62,169.95 174.62,169.06 174.42,168.86 174.14,168.86 173.94,169.06 173.94,169.95 173.74,170.15 173.45,170.15 173.25,169.95 173.25,169.06 173.05,168.86 172.77,168.86 172.57,169.06 172.57,169.95 172.36,170.15 172.08,170.15 171.88,169.95 171.88,169.06 171.68,168.86 171.39,168.86 171.19,169.06 171.19,169.95 170.99,170.15 170.71,170.15 170.51,169.95 170.51,169.06 170.31,168.86 170.02,168.86 169.82,169.06 169.82,169.95 169.62,170.15 165.25,170.15 163.8,168.7 163.8,165.89 163.36,165.46 147.14,165.46 147.08,165.52 143.45,165.52 143.18,165.25 141.5,165.25
M_CHB_MAA4: length 80
  TOP w0.203: XU1.AP23 v1(137.8,165.3)
  IN1 w0.102: v1(137.8,165.3) 138.17,164.93 140.8,164.93 141.41,165.53 143,165.53
  IN1 w0.178: 143,165.53 143.37,165.9 163.19,165.9 163.32,166.03 163.32,167.01 162.41,167.92 162.41,169.18 164.73,171.5 170.2,171.5 171.07,170.64 175.05,170.64 175.63,170.06 176.44,170.06 177.29,169.21 177.86,169.21 178.71,170.06 180.24,170.06 181.09,169.21 181.73,169.21 182.58,170.06 184.21,170.06 185.06,169.21 185.64,169.21 186.49,170.06 188.01,170.06 188.86,169.21 190.27,169.21 191.68,170.62 191.68,171.05 192.06,171.43 192.98,171.43 193.5,170.91 194.48,170.91 195.33,171.76 197.62,171.76 CON_XMM4.214 197.95,171.43 200.65,171.43 201.32,170.76 202.34,170.76 203.17,171.6 CON_XMM2.214
M_CHB_MAA5: length 82.3
  TOP w0.203: XU1.AL23 v1(135.06,165.3)
  IN1 w0.102: 143.32,166.27 142.82,165.77 140.36,165.77 139.98,165.39 138.46,165.39 138.13,165.72 135.48,165.72 v1(135.06,165.3)
  IN1 w0.178: 143.32,166.27 147.07,166.27 147.14,166.34 162.64,166.34 162.84,166.55 162.84,166.88 162.71,167 160.66,167 160.5,167.16 160.5,167.89 164.55,171.93 170.38,171.93 171.24,171.07 175.08,171.07 175.44,171.43 176.26,171.43 177.11,170.58 178.58,170.58 179.43,171.43 180.06,171.43 180.91,170.58 182.54,170.58 183.39,171.43 184.04,171.43 184.89,170.58 186.41,170.58 187.26,171.43 187.84,171.43 188.69,170.58 190.44,170.58 191.62,171.76 193.04,171.76 193.57,172.28 194.72,172.28 194.89,172.11 195.85,172.11 CON_XMM4.213 196.35,172.28 198.39,172.28 198.91,171.76 200.66,171.76 201.35,172.45 CON_XMM2.213
M_CHB_MAA6: length 72.8
  TOP w0.102: XU1.AW26 142.83,167.19 143.14,166.88 143.38,166.88 143.56,167.05 144.35,167.05 144.56,166.84 v1(144.56,166.74)
  IN1 w0.178: v1(144.56,166.74) 146.8,166.74 146.85,166.79 159.55,166.79 159.74,166.98 159.74,167.39 159.54,167.59 156.13,167.59 155.96,167.77 155.96,168.14 156.13,168.32 160.32,168.32 164.39,172.39 170.53,172.39 171.42,171.5 174.5,171.5 174.91,171.91 175.41,171.91 175.56,171.76 176.44,171.76 177.29,170.91 177.97,170.91 178.82,171.76 180.24,171.76 181.09,170.91 181.73,170.91 182.58,171.76 184.21,171.76 185.06,170.91 185.74,170.91 186.59,171.76 188.01,171.76 188.86,170.91 190.14,170.91 191.67,172.45 CON_XMM4.69 193.04,172.45 193.21,172.61 194.53,172.61 194.77,172.85 195.38,172.85 195.66,173.13 196.74,173.13 197.27,172.61 199.02,172.61 199.18,172.45 CON_XMM2.69
M_CHB_MAA7: length 72.4
  TOP w0.102: v1(146.8,167.68) 146.8,167.42 146.02,166.65 145.44,166.65 145.34,166.75 145.34,167.51 145.13,167.72 144.71,167.72 144.53,167.54 144.14,167.54 144.09,167.59 XU1.AY26
  IN1 w0.178: CON_XMM2.211 202.97,174.15 202.81,173.98 201.11,173.98 200.59,173.46 199.77,173.46 198.92,174.31 196.35,174.31 CON_XMM4.211 195.38,174.15 195.12,173.89 194.56,173.89 194.47,173.98 193.7,173.98 193.56,173.84 193.22,173.84 192.84,173.46 191.44,173.46 191.13,173.15 190.91,173.15 190.6,173.46 190.15,173.46 189.97,173.28 189.97,172.82 189.75,172.61 188.87,172.61 188.02,173.46 186.62,173.46 185.77,172.61 185.07,172.61 184.22,173.46 182.6,173.46 181.75,172.61 181.09,172.61 180.24,173.46 178.79,173.46 177.94,172.61 177.29,172.61 176.44,173.46 175.49,173.46 175.03,173.91 174.65,173.91 174.45,173.71 174.45,173.1 173.75,172.4 171.91,172.4 171.78,172.53 171.78,173.92 171.61,174.09 164.87,174.09 161.07,170.29 160.78,170.29 160.61,170.46 160.3,170.46 160.1,170.26 160.1,170 160.3,169.8 160.3,169.52 159.99,169.21 154.91,169.21 154.39,168.69 153.38,167.68 v1(146.8,167.68)
M_CHB_MAA8: length 75.1
  TOP w0.102: v1(144.91,167.3) 144.49,167.3 144.45,167.26 143.56,167.26 143.23,167.58 143.23,167.7 143.02,167.92 141.33,167.92 XU1.AU26
  IN1 w0.178: CON_XMM2.68 201.03,173.3 200.87,173.13 199.11,173.13 198.26,173.98 197.2,173.98 196.68,173.46 194.15,173.46 CON_XMM4.68 193.82,173.13 191.9,173.13 191.69,172.92 191.49,172.92 190.85,172.28 188.69,172.28 187.84,173.13 187.13,173.13 186.28,172.28 184.89,172.28 184.12,173.05 184.03,173.13 183.24,173.13 182.39,172.28 180.91,172.28 180.06,173.13 179.38,173.13 178.53,172.28 177.11,172.28 176.26,173.13 175.42,173.13 174.26,171.97 171.57,171.97 171.35,172.19 171.35,173.46 171.15,173.66 170.71,173.66 170.51,173.46 170.51,173.17 170.31,172.97 170.03,172.97 169.83,173.17 169.83,173.46 169.63,173.66 169.34,173.66 169.14,173.46 169.14,173.17 168.94,172.97 168.66,172.97 168.46,173.17 168.46,173.46 168.25,173.66 167.97,173.66 167.77,173.46 167.77,173.17 167.57,172.97 167.28,172.97 167.08,173.17 167.08,173.46 166.88,173.66 166.6,173.66 166.4,173.46 166.4,173.17 166.2,172.97 165.91,172.97 165.71,173.17 165.71,173.46 165.51,173.66 165.05,173.66 160.16,168.76 155.15,168.76 154.94,168.55 154.94,168.33 155.52,167.74 155.52,167.46 155.3,167.23 155.02,167.23 154.46,167.79 154.15,167.79 153.59,167.23 147.22,167.23 147.12,167.13 145.95,167.13 145.78,167.3 v1(144.91,167.3)
M_CHB_MAA9: length 71.7
  TOP w0.102: XU1.AW27 143.09,168.5 143.44,168.15 146.94,168.15 147.19,168.4 147.19,168.66 146.94,168.91 146.19,168.91 146.09,168.81 v1(146.09,168.57)
  IN1 w0.178: CON_XMM2.66 201.37,175.39 200.91,175.39 200.69,175.16 199.67,175.16 199.15,175.68 197.04,175.68 196.52,175.16 194.77,175.16 194.6,175 CON_XMM4.66 193.33,175 193.17,175.16 191.8,175.16 190.95,174.31 188.87,174.31 188.02,175.16 186.56,175.16 185.71,174.31 185.07,174.31 184.22,175.16 182.63,175.16 181.78,174.31 181.09,174.31 180.24,175.16 178.81,175.16 177.96,174.31 177.29,174.31 176.44,175.16 175.59,175.16 174.98,175.77 174.27,175.77 173.46,174.96 163.52,174.96 163.07,174.51 163.07,174.22 163.28,174.01 163.28,173.72 163.08,173.52 162.8,173.52 162.59,173.74 162.3,173.74 162.1,173.54 162.1,173.25 162.31,173.04 162.31,172.75 162.11,172.55 161.83,172.55 161.62,172.77 161.33,172.77 161.13,172.57 161.13,172.28 161.34,172.07 161.34,171.78 161.14,171.58 160.86,171.58 160.64,171.8 160.36,171.8 158.64,170.07 154.52,170.07 153.5,169.06 153.02,168.57 v1(146.09,168.57)
M_CHB_MAA10: length 80.1
  TOP w0.203: v1(137.83,159.87) 137.85,159.87 XU1.AP18
  IN1 w0.102: v1(137.83,159.87) 137.88,159.82 139.64,159.82 140.27,159.18 141.07,159.18 141.22,159.34 141.68,159.34 142,159.02
  IN1 w0.178: 142,159.02 143.04,159.02 144.31,157.75 160,157.75 160.22,157.53 160.22,157.3 160.02,157.1 158.75,157.1 158.55,156.9 158.55,156.64 158.78,156.41 161.34,156.41 164.69,153.06 172.85,153.06 173.05,153.26 173.05,154.13 173.25,154.33 173.54,154.33 173.74,154.13 173.74,153.26 173.94,153.06 176.44,153.06 176.89,152.61 176.89,152.61 177.29,152.21 177.96,152.21 178.81,153.06 180.24,153.06 181.09,152.21 181.72,152.21 182.57,153.06 184.22,153.06 184.66,152.61 184.66,152.61 185.07,152.21 185.63,152.21 185.64,152.21 185.69,152.21 186.54,153.06 187.84,153.06 188.69,153.91 189.5,153.91 190.02,154.44 190.02,155.09 191.4,156.46 192.91,156.46 193.44,156.98 196.02,156.98 CON_XMM4.225 196.35,156.98 199.08,156.98 199.6,156.46 200.66,156.46 201.34,157.15 CON_XMM2.225
M_CHB_MAA11: length 75.2
  TOP w0.102: v1(146.15,167.69) 146.15,167.06 146.02,166.93 145.69,166.93 145.58,167.04 145.58,167.79 145.44,167.93 143.33,167.93 143.11,168.15 141.36,168.15 XU1.AU27
  IN1 w0.178: v1(146.15,167.69) 146.6,168.14 148.13,168.14 148.15,168.12 153.2,168.12 153.95,168.87 154.72,169.64 158.81,169.64 160.33,171.15 161.32,171.15 164.69,174.52 172.01,174.52 172.21,174.32 172.21,173.43 172.52,173.13 173.61,173.13 173.91,173.43 173.91,174 174.74,174.83 176.26,174.83 177.11,173.98 178.53,173.98 179.38,174.83 179.49,174.83 179.49,174.83 180.06,174.83 180.91,173.98 182.41,173.98 183.26,174.83 184.03,174.83 184.88,173.98 186.2,173.98 187.05,174.83 187.83,174.83 188.24,174.43 188.68,173.98 191.25,173.98 192.09,174.82 192.09,174.82 192.1,174.83 192.86,174.83 193.38,174.31 194.6,174.31 195.13,174.83 196.95,174.83 197.12,175 CON_XMM4.210 198.84,175 199.01,174.83 200.68,174.83 201.2,174.31 202.26,174.31 202.95,175 CON_XMM2.210
M_CHB_MAA12: length 75
  TOP w0.102: XU1.AV27 142.27,168.85 143.99,168.85 144.13,169 145.02,169 v1(145.45,168.57)
  IN1 w0.178: v1(145.45,168.57) 145.45,168.82 145.8,169.16 146.18,169.16 146.33,169.32 146.33,169.46 146.49,169.62 146.79,169.62 146.96,169.44 146.96,169.21 147.17,169.01 152.83,169.01 153.06,169.24 154.66,170.84 154.66,171.09 154.91,171.35 155.3,171.35 155.52,171.12 155.52,170.69 155.68,170.54 156.01,170.54 156.18,170.71 156.18,171.09 156.37,171.28 156.69,171.28 156.84,171.13 156.84,170.71 157.05,170.51 158.46,170.51 164.18,176.23 166.87,176.23 167.07,176.02 167.07,175.59 167.28,175.39 167.56,175.39 167.76,175.59 167.76,176.02 167.96,176.23 168.25,176.23 168.45,176.02 168.45,175.59 168.65,175.39 168.93,175.39 169.13,175.59 169.13,176.02 169.33,176.23 169.62,176.23 169.82,176.02 169.82,175.59 170.02,175.39 170.3,175.39 170.5,175.59 170.5,176.02 170.7,176.23 170.99,176.23 171.19,176.02 171.19,175.59 171.39,175.39 171.67,175.39 171.88,175.59 171.88,176.22 172.08,176.43 172.36,176.43 172.56,176.22 172.56,175.71 172.76,175.51 173.05,175.51 173.25,175.71 173.25,176.14 173.46,176.35 175.31,176.35 175.49,176.53 175.69,176.53 175.69,176.53 176.26,176.53 177.11,175.68 178.55,175.68 179.4,176.53 180.06,176.53 180.91,175.68 182.51,175.68 183.36,176.53 183.46,176.53 183.47,176.53 184.03,176.53 184.04,176.53 184.89,175.68 186.3,175.68 187.15,176.53 187.83,176.53 188.24,176.13 188.24,176.13 188.68,175.68 189.57,175.68 189.94,175.31 191.39,175.31 191.92,175.85 CON_XMM4.65 193.01,175.85 193.18,175.68 194.96,175.68 195.81,176.53 196.72,176.53 197.24,176.01 198.18,176.01 198.43,176.26 199.23,176.26 199.64,175.85 CON_XMM2.65
M_CHB_MAA13: length 77.5
  TOP w0.203: v1(138.65,157.06) 139.11,157.53 XU1.AR15
  IN1 w0.102: 147.07,153.71 145.72,155.06 143.51,155.06 143.04,155.53 141.11,155.53 140.11,156.52 139.19,156.52 v1(138.65,157.06)
  IN1 w0.178: 147.07,153.71 155.6,153.71 161.99,147.32 174.47,147.32 175.53,146.26 176.44,146.26 177.28,145.41 177.29,145.41 177.29,145.41 177.99,145.41 179.35,146.25 180.26,146.25 181.09,145.41 181.82,145.41 183.18,146.26 184.22,146.26 185.07,145.41 185.87,145.41 187.23,146.26 187.83,146.26 188.68,147.11 189.51,147.11 191.12,148.72 191.12,149.14 191.55,149.57 191.55,150.66 191.92,151.03 192.77,151.03 193.71,150.44 194.28,150.44 195.76,151.03 196.8,151.03 CON_XMM4.232 200.3,151.2 201.63,150.37 202.15,150.37 203.78,151.2 CON_XMM2.232
M_CHB_MAA14: length 81.9
  TOP w0.203: XU1.AL17 135.03,158.88 v1(135,158.88)
  IN1 w0.102: 146.64,156.21 144.22,156.21 142.54,157.89 140.31,157.89 139.6,158.6 138.86,158.6 138.65,158.39 136.51,158.39 136.42,158.47 135.41,158.47 v1(135,158.88)
  IN1 w0.178: CON_XMM2.228 203.61,154.6 202.81,153.8 201.32,153.8 200.68,154.44 198.77,154.44 198.62,154.6 CON_XMM4.228 197.15,153.96 197.15,153.41 196.8,153.06 195.5,153.06 195.33,153.24 195.33,153.95 195.15,154.13 194.69,154.13 194.31,153.75 193.6,153.75 192.91,153.06 191.67,153.06 189.97,151.36 189.97,151 189.47,150.51 188.68,150.51 187.83,149.66 186.57,149.66 185.72,148.81 185.07,148.81 184.22,149.66 182.65,149.66 181.8,148.81 181.09,148.81 180.24,149.66 178.89,149.66 178.04,148.81 177.29,148.81 176.44,149.66 175.56,149.66 175.08,150.14 166.89,150.14 166.09,150.94 161.42,150.94 156.67,155.68 147.17,155.68 146.64,156.21
M_CHB_MAA15: length 79.9
  TOP w0.203: XU1.AP16 137.77,157.96 v1(137.77,157.96)
  IN1 w0.102: 147.1,155.24 146.33,156.01 144.06,156.01 142.39,157.68 140.15,157.68 139.96,157.49 139.39,157.49 138.92,157.96 v1(137.77,157.96)
  IN1 w0.178: 147.1,155.24 156.51,155.24 162.03,149.71 162.46,149.71 162.66,149.91 162.66,150.29 162.87,150.51 163.14,150.51 163.35,150.3 163.35,149.86 163.5,149.71 163.85,149.71 164.05,149.91 164.05,150.3 164.25,150.51 164.53,150.51 164.73,150.3 164.73,149.91 164.93,149.71 165.22,149.71 165.42,149.91 165.42,150.3 165.62,150.51 165.9,150.51 166.1,150.3 166.1,149.91 166.31,149.71 170.99,149.71 171.19,149.51 171.19,149.02 171.39,148.82 171.68,148.82 171.88,149.02 171.88,149.51 172.08,149.71 172.36,149.71 172.57,149.51 172.57,149.02 172.77,148.82 173.05,148.82 173.25,149.02 173.25,149.51 173.45,149.71 173.89,149.71 174.12,149.48 174.12,148.97 174.24,148.84 174.7,148.84 174.83,148.97 174.83,149.17 174.98,149.33 176.27,149.33 177.11,148.48 178.48,148.48 179.33,149.33 180.06,149.33 180.92,148.48 182.49,148.48 183.34,149.33 184.04,149.33 184.89,148.48 186.3,148.48 187.15,149.33 188.01,149.33 188.86,150.18 189.63,150.18 190.53,151.08 190.53,151.33 191.92,152.73 193.82,152.73 CON_XMM4.86 194.14,152.74 196.76,152.74 197.3,152.21 198.37,152.21 199.09,152.93 200.51,152.93 200.94,153.37 201.28,153.37 CON_XMM2.86
M_CHB_MAA16: length 80.5
  TOP w0.203: XU1.AN18 136.88,159.81 v1(136.88,159.79)
  IN1 w0.102: 144.39,157.26 143.16,158.49 140.59,158.49 139.63,159.45 136.97,159.45 136.88,159.54 v1(136.88,159.79)
  IN1 w0.178: CON_XMM2.82 201.59,156.13 199.87,156.13 199.87,156.13 199.51,156.13 198.99,155.61 197.31,155.61 196.63,156.3 CON_XMM4.82 193.82,156.13 191.83,156.13 190.8,155.11 190.8,154.25 190.13,153.58 188.86,153.58 188.01,152.73 187.15,152.73 186.3,151.88 184.88,151.88 184.03,152.73 183.24,152.73 182.39,151.88 180.91,151.88 180.06,152.73 179.42,152.73 178.57,151.88 177.11,151.88 176.26,152.73 175.52,152.73 175.22,152.44 164.65,152.44 164.03,153.06 161.42,153.06 161.19,153.29 161.19,153.57 161.37,153.75 162.59,153.75 162.8,153.96 162.8,154.29 162.63,154.46 160,154.46 159.77,154.69 159.77,154.97 159.99,155.19 161.06,155.19 161.3,155.44 161.3,155.69 161.15,155.84 158.61,155.84 157.2,157.26 144.39,157.26
M_CHB_ODT0: length 70.7
  TOP w0.159: v1(135.97,157.9) 136.43,158.36 XU1.AM16
  IN1 w0.102: v1(135.97,157.9) 136.31,157.9 136.76,157.45 137.94,157.45 138.17,157.68 138.91,157.68 139.3,157.29 140.07,157.29 140.26,157.48 141.91,157.48 142.06,157.33 142.06,156.44 142.24,156.26 143.13,156.26 143.92,155.47 146.36,155.47 147.07,154.76
  IN1 w0.14: 147.07,154.76 147.11,154.72 156.32,154.72 161.83,149.21 166.55,149.21 166.74,149.02 166.74,148.51 166.93,148.32 167.2,148.32 167.39,148.51 167.39,149.02 167.58,149.21 167.84,149.21 168.03,149.02 168.03,148.51 168.22,148.32 168.49,148.32 168.68,148.51 168.68,149.02 168.87,149.21 169.14,149.21 169.33,149.02 169.33,148.51 169.52,148.32 169.79,148.32 169.98,148.51 169.98,149.02 170.17,149.21 170.44,149.21 170.62,149.02 170.62,148.51 170.81,148.32 175.23,148.32 175.57,147.98 176.45,147.98 176.91,147.52 176.91,147.52 177.3,147.13 177.94,147.13 178.79,147.98 180.24,147.98 181.09,147.13 181.88,147.13 182.73,147.98 184.2,147.98 185.05,147.13 185.81,147.13 186.67,147.98 187.27,147.98 187.27,147.98 187.83,147.98 188.22,148.37 188.22,148.37 188.68,148.83 189.65,148.83 190.87,150.05 190.88,150.06 190.88,150.86 192.06,152.05 CON_XMM4.87
M_CHB_ODT1: length 71.3
  TOP w0.159: XU1.AL16 135.11,158.04 v1(135.11,158)
  IN1 w0.102: v1(135.11,158) 135.69,157.42 136.15,157.42 136.42,157.14 136.42,156.86 137.17,156.12 139.91,156.12 140.96,155.07 142.63,155.07 143.46,154.24
  IN1 w0.14: 143.46,154.24 143.88,153.82 146.02,153.82 147.17,152.68 155.24,152.68 161.58,146.34 167.02,146.34 167.21,146.15 167.21,145.63 167.4,145.44 167.67,145.44 167.86,145.63 167.86,146.15 168.05,146.34 168.31,146.34 168.5,146.15 168.5,145.63 168.69,145.44 168.96,145.44 169.15,145.63 169.15,146.15 169.34,146.34 169.61,146.34 169.8,146.15 169.8,145.63 169.99,145.44 174.63,145.44 175.49,144.58 176.42,144.58 177.28,143.71 178.08,143.71 178.91,144.55 180.24,144.55 181.06,143.73 181.85,143.73 182.7,144.58 184.2,144.58 185.05,143.73 185.71,143.73 186.56,144.58 187.83,144.58 187.83,144.58 187.89,144.58 188.74,145.43 190.64,145.43 191.17,145.96 191.17,146.91 192.38,148.12 CON_XMM4.91
M_CHB_ODT2: length 77.6
  TOP w0.159: v1(137.82,157.03) 137.82,157.1 XU1.AP15
  IN1 w0.102: 146.94,154.31 145.98,155.27 143.66,155.27 143.2,155.73 141.19,155.73 139.94,156.98 139.32,156.98 138.82,157.48 138.27,157.48 v1(137.82,157.03)
  IN1 w0.14: CON_XMM2.87 199.97,151.86 197.23,151.86 196.73,151.37 195.34,151.37 195.12,151.59 195.12,152.07 194.97,152.22 194.67,152.22 194.46,152.02 193.57,152.02 192.91,151.36 191.74,151.36 191.14,150.75 191.14,149.95 191.06,149.86 190.6,149.4 190.6,149.22 189.86,148.48 188.86,148.48 188.01,147.63 187.05,147.63 186.2,146.78 184.91,146.78 184.06,147.63 183.02,147.63 182.8,147.42 182.8,146.79 182.6,146.58 182.12,146.58 181.86,146.84 180.87,146.84 180.08,147.63 179.36,147.63 178.51,146.78 177.11,146.78 176.26,147.63 175.33,147.63 175.13,147.83 166.43,147.83 166.24,148.02 166.24,148.53 166.05,148.72 165.79,148.72 165.6,148.53 165.6,148.02 165.41,147.83 165.14,147.83 164.95,148.02 164.95,148.53 164.76,148.72 164.49,148.72 164.3,148.53 164.3,148.02 164.11,147.83 163.8,147.83 163.6,148.03 163.6,148.54 163.42,148.72 163.12,148.72 162.92,148.51 162.92,147.98 162.76,147.83 162.52,147.83 162.31,148.04 162.31,148.53 162.13,148.72 161.63,148.72 156.12,154.23 147.02,154.23 146.94,154.31
M_CHB_ODT3: length 80
  TOP w0.159: XU1.AL15 135.07,157.09 v1(135.07,157.05)
  IN1 w0.102: v1(135.07,157.05) 135.07,156.78 135.5,156.35 135.5,156.07 135.89,155.68 139.74,155.68 140.93,154.48
  IN1 w0.14: CON_XMM2.91 198.34,146.82 197.2,146.82 196.42,146.04 195.43,146.04 194.66,145.28 193.58,145.28 192.73,144.42 191.67,144.42 191.19,143.95 189.9,143.95 189.48,143.53 188.67,143.53 187.84,142.7 187.04,142.7 185.78,141.91 184.96,141.91 184.2,142.67 182.94,142.67 181.63,141.85 181.08,141.85 180.23,142.7 179.14,142.7 177.85,141.9 177.26,141.9 176.47,142.7 175.51,142.7 173.74,144.48 173.25,144.48 173.06,144.29 173.06,143.8 172.87,143.61 172.61,143.61 172.42,143.8 172.42,144.29 172.23,144.48 171.96,144.48 171.77,144.29 171.77,143.8 171.58,143.61 171.31,143.61 171.12,143.8 171.12,144.29 170.93,144.48 170.66,144.48 170.47,144.29 170.47,143.8 170.28,143.61 170.01,143.61 169.83,143.8 169.83,144.29 169.64,144.48 162.08,144.48 154.89,151.66 146.82,151.66 145.42,153.06 143.56,153.06 142.14,154.48 140.93,154.48
M_CHB_PAR: length 80.3
  TOP w0.203: v1(135.99,161.66) 135.95,161.66 XU1.AL20
  IN1 w0.102: v1(135.99,161.66) 137.17,161.66 137.58,161.25 138.03,161.25 138.3,160.99
  IN1 w0.178: 138.3,160.99 138.6,160.68 144.99,160.68 146.1,159.57 161.87,159.57 162.08,159.37 162.08,158.32 162.28,158.12 162.69,158.12 162.86,158.29 162.86,159.34 163.09,159.57 163.39,159.57 163.66,159.3 163.66,158.46 163.98,158.14 164.54,158.14 165.6,157.09 174.87,157.09 175.49,156.46 176.44,156.46 177.29,155.61 178.04,155.61 178.89,156.46 180.24,156.46 180.69,156.01 180.69,156.01 181.09,155.61 181.82,155.61 182.67,156.46 184.21,156.46 185.06,155.61 185.81,155.61 186.66,156.46 187.83,156.46 187.94,156.57 187.95,156.57 188.69,157.31 189.54,157.31 189.95,157.72 189.95,158.32 190.94,159.31 191.53,159.31 191.86,159.64 192.87,159.64 193.62,160.38 197.1,160.38 CON_XMM4.222 198.48,160.39 203.87,160.39 204.57,159.7 CON_XMM2.222
MAIN POWER DISCHARGE: length 457.9
  TOP w0.102: MQ26.5 227.33,200.55 v1(226.66,199.87) 227.33,199.2 MQ26.2 ; MQ25.3 229.15,152.89 228.96,153.09 228.7,153.09 228.5,152.88 MQ25.2 228.5,152.48 227.57,151.55 PR511.2 227.15,149.76 227.15,146.76 v1(227.43,146.48) ; v1(217.25,229.55) 217.92,228.88 219.13,228.88 219.56,228.44 219.59,228.44 219.68,228.35 219.68,228.32 v1(220.9,227.1) ; v1(65.01,219.58) PQ2.1 ; MQ21.2 MQ21.5 131.94,110.66 132.13,110.85 132.13,115.09 132.41,115.37 136.22,115.37 137.62,113.97 v1(137.62,113.77)
  BOTTOM w0.102: v1(220.9,227.1) 221.34,227.53 224.1,227.53 229.29,222.35 229.29,214.75 228.69,214.15 228.69,213.74 228.69,205.99 226.66,203.96 v1(226.66,199.87) 226.86,199.67 226.86,192.01 225.29,190.44 225.29,188.68 225.01,188.4 225.01,185.12 225.08,185.04 225.08,171.9 223.96,170.79 223.96,167.63 224.92,166.67 224.92,149 v1(227.43,146.48) 222.96,142.01 222.96,133.2 218.1,128.34 218.1,125.11 217.74,124.76 217.74,112.51 217.74,112.33 215.22,109.8 215.22,106.45 216.11,105.56 216.11,105.38 216.11,105.38 216.11,102.93 215.53,102.35 215.53,99.39 213.06,96.92 213.06,94.35 212.13,93.41 212.13,92.54 212.28,92.39 212.28,90.48 211.46,89.66 209.33,89.66 207.59,91.4 207.59,94.01 206.68,94.92 201.94,94.92 200.98,95.89 198.14,95.89 196.61,94.36 190.42,94.36 189.44,93.38 184.25,93.38 183.44,94.19 173.24,94.19 170.54,96.89 153.67,96.89 152.49,98.07 152.49,106.46 v2(152.52,106.49) 152.58,106.55 152.58,109.17 147.49,114.25 139.21,114.25 138.72,113.77 v1(137.62,113.77) ; v1(65.01,219.58) 65.01,221.3 69.04,225.32 69.04,227.89 75.73,234.58 85.31,234.58 89.04,238.32 101.44,238.32 107.03,232.72 117.73,232.72 118.66,231.79 130.04,231.79 131.52,233.27 146.12,233.27 146.24,233.16 154.79,233.16 159.53,228.42 168.88,228.42 175.11,234.65 175.11,234.79 177.96,237.64 206.23,237.64 209,234.87 210.88,234.87 216.2,229.55 v1(217.25,229.55)
MCLK: length 6
  TOP w0.102: v1(209.22,30.84) 208.42,31.64 U104.115 206.46,31.64 205.84,32.26 205.38,32.26 205.23,32.41 RN23.3
  BOTTOM w0.102: v1(209.22,30.84) 209.91,30.84 v2(209.98,30.91)
MDAT: length 3.6
  TOP w0.102: RN23.1 205.47,31.81 v1(205.54,31.75) 205.87,31.42 206.35,31.42 206.53,31.24 U104.116
  BOTTOM w0.102: v2(206.38,31.75) v1(205.54,31.75)
ME_DISABLE#: length 28.3
  TOP w0.089: PCH.AY39 179.4,43 181.4,43 181.46,43.05 182.32,43.05
  TOP w0.102: SR13.1 202.27,47.79 v1(202.56,47.5) ; 182.32,43.05 184.91,43.05 185.19,43.33 SR275.2 190.88,43.33 v1(192.33,44.78)
  BOTTOM w0.102: v1(202.56,47.5) v2(202.56,45.72) 202.56,45.22 202.16,44.82 197.8,44.82 197.67,44.95 194.12,44.95 193.54,44.36 192.75,44.36 v1(192.33,44.78)
ME_DISABLE#_B: length 3.1
  TOP w0.102: v1(200.81,48.29) SR13.2 201.62,48.47 SQ1.1
  BOTTOM w0.102: v1(200.81,48.29) 200.43,47.9 v2(200.43,47.65)
ME_DISABLE#_E: length 4.5
  TOP w0.102: SQ1.2 203.52,50.83 203.31,51.04 v1(203.31,52.58) SR14.1
  BOTTOM w0.102: v1(203.31,52.58) v2(202.59,52.58)
MF_MODE#: length 13.1
  TOP w0.102: PCH.AK43 180.96,47.54 182,47.54 182.17,47.37 186.02,47.37 188.68,50.03 FC8.1 SR94.2
MIC1-L: length 82.4
  TOP w0.254: AR216.2 5.98,86.46 6.89,85.55 6.89,84.37 4.76,82.25 4.76,77.44 7.45,74.75 8.73,74.75 11.23,72.26 v1(11.23,71.72) ; AC163.2 12.45,24.61 11.89,24.05 v1(5.59,24.05)
  BOTTOM w0.254: v1(5.59,24.05) 5.24,24.4 5.24,28.07 5.96,28.79 5.96,30.39 5.37,30.98 5.37,31.28 4.51,32.14 4.51,45.6 6.32,47.41 6.32,52.11 4.48,53.96 4.48,64.67 6.77,66.95 8.61,66.95 9.96,68.31 v2(9.96,69.67) 9.96,70.35 10.3,70.69 10.3,71.31 10.71,71.72 v1(11.23,71.72)
MIC1-L_C: length 6.5
  TOP w0.254: AC163.1 13.44,22.86 14.75,21.54 AU1.21 14.75,19.02 v1(15.01,18.76)
  BOTTOM w0.254: v2(15.01,19.52) v1(15.01,18.76)
MIC1-R: length 58.5
  TOP w0.254: v1(4.37,26.16) 4.37,25.17 4.98,24.56 7.39,24.56 8.23,25.4 AC164.2 ; AR218.2 9.53,70.94 v1(9.55,70.92)
  BOTTOM w0.254: v1(4.37,26.16) 4.37,27.94 5.45,29.02 5.45,30.18 4.86,30.76 4.86,31.07 4,31.93 4,45.88 5.71,47.6 5.71,52 3.97,53.75 3.97,64.88 6.62,67.53 v2(7.54,67.53) 8.46,67.53 9.34,68.41 9.34,70.71 v1(9.55,70.92)
MIC1-R_C: length 10.5
  TOP w0.254: AC164.1 9.91,22.17 10.03,22.05 13.49,22.05 14.25,21.28 AU1.22 14.25,18.49 14.72,18.02 v1(15.01,18.02)
  BOTTOM w0.254: v1(15.01,18.02) 15.01,17.31 v2(15.44,16.88)
