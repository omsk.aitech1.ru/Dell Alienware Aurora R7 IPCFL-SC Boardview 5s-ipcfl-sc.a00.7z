# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VRM_ISEN4N_A: length 74.7
  TOP w0.254: v1(77.7,207.21) 77.61,207.3 77.61,208.8 77.44,208.97 PC5812.1 77.11,209.74 77.3,209.93 PR5814.2 77.3,211.02 PR5815.2 77.79,211.04 77.81,211.01 PC5811.2
  BOTTOM w0.254: v1(77.7,207.21) 78.31,207.21 80.47,205.05 80.47,203.78 82.7,201.55 82.7,184.3 80.01,181.61 80.01,178.05 78.11,176.15 78.11,159.51 v2(76.83,158.24) 76,157.4 76,156.79 74.27,155.07 74.27,148.69 72.72,147.14 72.39,147.14 71.98,146.74 71.98,145.67 72.14,145.52 PJP12.2
VRM_ISEN4P_A: length 71.6
  TOP w0.254: v1(77.83,206.48) 78.24,206.9 78.24,207.45 78.18,207.52 PR5882.2
  BOTTOM w0.254: PJP11.2 71.59,147.04 72.39,147.84 v2(72.39,147.96) 72.97,147.96 73.79,148.77 73.79,155.3 75.51,157.02 75.51,158.93 77.51,160.92 77.51,176.4 79.5,178.39 79.5,181.95 82.27,184.72 82.27,201.35 79.93,203.68 79.93,204.72 78.18,206.48 v1(77.83,206.48)
VRM_PWM1_A: length 44.1
  TOP w0.203: v1(74.95,217.87) 75,217.93 PU581.52
  TOP w0.254: v1(72.06,190.32) 72.06,188.87 70.92,187.74 PU591.2
  BOTTOM w0.254: v1(74.95,217.87) 74.62,217.87 73.74,216.99 71.93,216.99 69.19,214.25 69.19,210.61 71.91,207.89 71.91,204.95 77.7,199.16 77.7,192.35 v2(75.45,190.11) 74.83,189.48 72.9,189.48 v1(72.06,190.32)
VRM_PWM1_BOT_C: length 0.8
  BOTTOM w0.102: v1(72.85,187.48) 72.16,187.48 v2(72.06,187.58)
VRM_PWM1_BOTR_C: length 1
  BOTTOM w0.102: v2(72.85,185.32) 73.08,185.09 v1(73.08,184.38)
VRM_PWM1_HG_D: length 10
  TOP w0.279: PU591.8 71.42,185.5 v3(71.91,185.01)
  TOP w0.635: PR5903.1 66.12,186.11 67.31,184.91 v3(67.31,184.78)
  BOTTOM w0.635: v3(71.91,185.01) 71.91,184.84 70.84,183.77 v2(69.75,183.77) 68.81,183.77 67.79,184.78 v3(67.31,184.78)
VRM_PWM1_HGR_D: length 1.3
  BOTTOM w0.635: v2(64.19,184.2) 63.7,183.72 v1(63.07,183.72)
VRM_PWM1_LG_D: length 37.4
  BOTTOM w0.635: v3(65.81,175.87) 65.79,175.9 v3(59.69,175.9) 54.31,175.9 53.47,176.73 53.47,185.37 54.1,186 v2(65.2,186) 68.5,186 v3(69.06,185.45)
VRM_PWM1_SN: length 2.1
  BOTTOM w0.508: v1(68.35,171.96) 69.98,171.96 v2(70.28,172.26)
VRM_PWM1_SW_C: length 16.2
  TOP w0.279: PU591.7 70.92,184.98
  TOP w0.635: 70.92,184.98 70.92,183.7 PC5901.2 69.37,183.67 68.25,182.55
  TOP w0.889: PL591.1 68.56,179.02 ; PL591.1 68.56,176.36 ; PL591.1 69.89,177.69 ; PL591.1 67.22,177.69
  BOTTOM w0.889: 68.56,176.27 PL591.1 ; PL591.1 67.14,177.69 ; PL591.1 69.98,177.69 ; PL591.1 68.56,179.11
  vias: v3(55.07,183.44) v3(57.4,183.49) v3(59.92,181.74) v3(59.92,177.37) v3(65.99,177.34) v3(66.55,182.35) v3(67.21,174.93) v3(69.24,181.61) v3(70.15,174.98)
VRM_PWM1_VCC_C: length 5.9
  TOP w0.279: PU591.4 69.92,187.91
  TOP w0.457: 69.92,187.91 70.62,188.61 PC640684.1 69.91,189.1 PC5903.1
  TOP w0.508: PC5903.1 v1(68.95,188.15) 68.79,187.99 PR5902.2
  BOTTOM w0.102: v1(68.95,188.15) 68.95,187.62 v2(68.71,187.38)
VRM_PWM2_A: length 20.2
  TOP w0.203: PU581.51 75.48,218.33 75.4,218.4 74.34,218.4 v1(74.23,218.29)
  TOP w0.254: v1(68.5,210.24) 68.33,210.06 68.33,206.88 68.07,206.63 67.44,206.63 67.26,206.45 PU592.2
  BOTTOM w0.254: v1(74.23,218.29) 74.23,218.58 73.56,219.25 v2(73.56,219.41) 72.27,219.41 71.06,218.2 71.06,216.93 68.5,214.38 v1(68.5,210.24)
VRM_PWM2_BOT_C: length 0.9
  BOTTOM w0.102: v2(69.27,205.77) 69.19,205.84 v1(69.19,206.6)
VRM_PWM2_BOTR_C: length 0.9
  BOTTOM w0.102: v1(68.78,201.29) v2(69.7,201.29)
VRM_PWM2_HG_D: length 6.2
  TOP w0.279: PU592.8 67.76,203.63 68.04,203.35 v3(68.22,203.35)
  TOP w0.635: PR5910.1 65.25,203.66 65.53,203.38 v3(65.53,202.82)
  BOTTOM w0.635: v3(65.53,202.82) 65.8,202.55 v2(66.65,202.55) 67.42,202.55 v3(68.22,203.35)
VRM_PWM2_HGR_D: length 1
  BOTTOM w0.635: v1(63.2,201.42) 63.2,202.06 v2(63.42,202.29)
VRM_PWM2_LG_D: length 33.1
  BOTTOM w0.635: v3(65.79,193.42) v3(59.58,193.42) 54.13,193.42 53.26,194.28 53.26,201.47 55.5,203.71 v2(61.44,203.71) 64.08,203.71 v3(65,204.62)
VRM_PWM2_SN: length 0.9
  BOTTOM w0.508: v2(66.5,187.81) 66.7,188.01 v1(66.7,188.59)
VRM_PWM2_SW_C: length 14
  TOP w0.279: PU592.7 67.26,203.15
  TOP w0.635: 67.26,203.15 67.26,202.67 PC5915.2 66.64,200.06
  TOP w0.889: PL592.1 67.22,195.29 ; PL592.1 69.89,195.29 ; PL592.1 68.56,193.96 ; PL592.1 68.56,196.62
  BOTTOM w0.889: PL592.1 68.56,196.71 ; PL592.1 67.14,195.29 ; PL592.1 68.56,193.87
  vias: v3(54.94,199.97) v3(57.4,201.12) v3(59.89,199.42) v3(59.87,194.92) v3(65.94,194.87) v3(66.55,199.85) v3(67.18,193.07) v3(67.36,197.92) v3(69.85,198.37) v3(69.98,193.04)
VRM_PWM2_VCC_C: length 6.1
  TOP w0.279: PU592.4 66.26,207.06 PC640685.1
  TOP w0.381: PC640685.1 65.66,206.9 65.66,206.59 PC5916.1
  TOP w0.508: PR5909.2 v1(64.85,207.39) 64.85,206.46 PC5916.1
  BOTTOM w0.102: v1(64.85,207.39) 64.85,208.05 v2(64.62,208.28)
VRM_PWM3_A: length 57.1
  TOP w0.203: v1(74.67,217.13) 74.94,217.13 75.27,217.46 75.27,217.46 75.34,217.53 PU581.53
  TOP w0.254: PU601.2 70.79,170.64 71.96,171.81 71.96,181.66 v1(73.03,182.73)
  BOTTOM w0.254: v1(74.67,217.13) 74.07,216.53 73.44,216.53 69.96,213.06 69.96,210.55 72.42,208.1 72.42,205.21 78.21,199.42 78.21,192 v2(74.55,188.34) 74.17,187.96 74.17,183.87 v1(73.03,182.73)
VRM_PWM3_BOT_C: length 0.8
  BOTTOM w0.508: v1(73.58,169.82) v2(73.58,170.61)
VRM_PWM3_BOTR_C: length 0.8
  BOTTOM w0.508: v1(73.03,166.34) v2(73.03,167.16)
VRM_PWM3_HG_D: length 4.9
  TOP w0.279: v3(71.73,167.44) 71.29,167.88 PU601.8
  BOTTOM w0.635: v3(71.73,167.44) 70.59,166.3 v2(69.8,166.3) 69.16,166.3 v3(68.58,166.88)
VRM_PWM3_HGR_D: length 1
  BOTTOM w0.635: v1(63.32,166.52) v2(64.29,166.52)
VRM_PWM3_LG_D: length 36.5
  BOTTOM w0.635: v3(68.99,168.15) 67.26,168.15 66.73,168.68 v2(65.71,168.68) 55.52,168.68 53.59,166.75 53.59,159.26 54.48,158.37 v3(59.56,158.37) v3(65.86,158.37)
VRM_PWM3_SN: length 0.9
  BOTTOM w0.508: v2(68.22,154.48) 67.64,154.48 v1(67.44,154.28)
VRM_PWM3_SW_C: length 16.3
  TOP w0.279: PU601.7 70.79,167.31
  TOP w0.508: 70.79,167.31 70.79,166.93 70.58,166.72 PC607.2
  TOP w0.635: 68.07,164.72 68.83,165.48 69.81,165.48 PC607.2
  TOP w0.889: PL601.1 67.22,160.09 ; PL601.1 68.56,161.42 ; PL601.1 68.56,158.75 ; PL601.1 69.89,160.09
  BOTTOM w0.889: PL601.1 68.56,161.51 ; PL601.1 67.14,160.09 ; PL601.1 68.56,158.66 ; PL601.1 69.98,160.09
  vias: v3(54.91,164.82) v3(57.45,166.19) v3(59.89,164.39) v3(59.87,159.82) v3(66.09,159.77) v3(66.55,164.77) v3(67.36,157.28) v3(69.01,163.63) v3(69.82,157.28)
VRM_PWM3_VCC_C: length 5
  TOP w0.279: PC640687.1 69.79,171.09 PU601.4
  TOP w0.457: PC640687.1 v1(68.91,171.32)
  TOP w0.508: v1(68.91,171.32) 68.33,170.74 PC608.1 68.21,170.51 PR602.2
  BOTTOM w0.508: v1(68.91,171.32) 68.4,170.81 v2(68.4,170.66)
VRM_PWM4_A: length 84.7
  TOP w0.254: v1(73.1,174.73) v1(73.1,181.99) ; v1(71.93,164.87) 71.7,164.64 71.7,153.57 71.54,153.41 PU602.2 ; PR5879.2 72.06,219.46 71.78,219.74 70.94,219.74 70.54,220.14 67.28,220.14 67.03,219.89 67.03,218.14 66.65,217.75 66.65,216.08 68.61,214.12 68.61,213 70.59,211.02 v1(71.09,211.02)
  BOTTOM w0.254: v1(71.93,164.87) v2(72.69,164.87) 73.86,164.87 75.59,166.6 75.59,172.42 73.28,174.73 v1(73.1,174.73) ; v1(73.1,181.99) 74.61,183.5 74.61,187.39 78.71,191.49 78.71,199.67 72.92,205.46 72.92,209.19 v1(71.09,211.02)
VRM_PWM4_BOT_C: length 0.9
  BOTTOM w0.508: v1(73.23,153.06) 73.23,153.39 v2(72.8,153.82)
VRM_PWM4_BOTR_C: length 1.1
  BOTTOM w0.508: v1(72.87,148.64) 72.87,149.45 v2(73.05,149.63)
VRM_PWM4_HG_D: length 6.6
  TOP w0.635: v3(68.58,149.61) 68.07,150.11 PR610.1
  BOTTOM w0.635: v3(68.58,149.61) 68.71,149.48 v2(70.15,149.48) 71.04,149.48 72.24,150.67 v3(72.59,150.67)
VRM_PWM4_HGR_D: length 0.9
  BOTTOM w0.254: v2(65.13,149.33) 64.62,148.82 v1(64.41,148.82)
VRM_PWM4_LG_D: length 36.3
  BOTTOM w0.635: v3(65.86,140.59) v3(59.59,140.59) 54.76,140.59 53.7,141.66 53.7,148.16 54.25,148.72 62.79,148.72 64.95,150.88 v2(66.85,150.88) v3(69.72,150.88)
VRM_PWM4_SN: length 0.9
  BOTTOM w0.508: v1(67.31,137.03) 67.64,137.36 v2(67.64,137.77)
VRM_PWM4_SW_C: length 17.5
  TOP w0.279: PU602.7 71.54,150.45
  TOP w0.635: 67.79,147.09 70.23,149.53 PC615.2 71.54,149.56 71.54,150.45
  TOP w0.889: PL602.1 68.69,144.83 ; PL602.1 70.02,143.5 ; PL602.1 67.35,143.5 ; PL602.1 68.69,142.17
  BOTTOM w0.889: PL602.1 70.11,143.5 ; PL602.1 68.69,142.08 ; PL602.1 68.69,144.92 ; PL602.1 67.26,143.5
  vias: v3(54.89,147.17) v3(57.25,147.45) v3(59.94,146.46) v3(59.94,142.04) v3(65.94,142.06) v3(66.52,146.96) v3(67.26,140.61) v3(69.6,146.91) v3(70.08,141.02)
VRM_PWM4_VCC_C: length 6.1
  TOP w0.279: PU602.4 70.54,153.44 70.34,153.64 v1(69.95,153.64)
  TOP w0.457: PC640688.1 69.25,153.39 PC616.1
  TOP w0.508: v1(69.95,153.64) 69.7,153.9 PC640688.1 ; PR609.2 67.18,152.97 PC616.1
  BOTTOM w0.508: v1(69.95,153.64) 69.95,153.34 v2(69.55,152.93)
VRM_SET1_A: length 6.8
  TOP w0.203: PU581.14 81.04,215.51 81.41,215.14
  TOP w0.254: PR5842.2 PR5843.2 83.9,212.93 v1(82.75,214.07) 81.69,215.14 81.41,215.14
  BOTTOM w0.102: v2(82.52,213) 82.55,213 82.75,213.21 v1(82.75,214.07)
VRM_SET1_R1_A: length 3.6
  TOP w0.254: PR5836.2 v1(84.96,211.02) PR5842.1
  BOTTOM w0.102: v1(84.96,211.02) 84.96,210.72 83.77,209.52 v2(83.74,209.52)
VRM_SET1_R2_A: length 2.6
  TOP w0.254: PR5843.1 84.18,211.52 v1(84.18,210.97) 84.02,210.82 PR5824.2
  BOTTOM w0.102: v2(83.57,211.51) 83.64,211.51 v1(84.18,210.97)
VRM_SET2_A: length 7.7
  TOP w0.203: PU581.15 81.76,215.81
  TOP w0.254: 81.76,215.81 82.63,214.93 v1(82.96,214.93) 84.05,213.84 84.58,213.84 85.51,212.92 85.7,212.92 PR5827.2 PR5825.2
  BOTTOM w0.102: v2(83.59,214.48) 83.13,214.93 v1(82.96,214.93)
VRM_SET2_R1_A: length 3.1
  TOP w0.254: PR5825.1 86.97,211.11 v1(87.02,211.06) PR5826.2
  BOTTOM w0.102: v1(87.02,211.06) 87.02,209.52 v2(87.2,209.35)
VRM_SET2_R2_A: length 2.8
  TOP w0.254: PR5827.1 v1(86.06,211.06) 86.11,211.01 PR5837.2
  BOTTOM w0.102: v1(86.06,211.06) 86.06,210.44 v2(85.47,209.85)
VRM_SET3_A: length 7.3
  TOP w0.203: 82.58,216.61 82.46,216.73 PU581.17
  TOP w0.254: PR5829.2 PR5831.2 84.86,214.33 v1(83.65,215.53) 82.58,216.61
  BOTTOM w0.102: v1(83.65,215.53) 83.65,215.91 83.31,216.26 83.26,216.26 83.24,216.23 v2(83.24,216.2)
VRM_SET3_R1_A: length 3
  TOP w0.254: PR5828.2 87.67,213.41 v1(87.49,213.59) 87.31,213.41 PR5829.1
  BOTTOM w0.102: v2(88.07,212.33) 87.49,212.92 v1(87.49,213.59)
VRM_SET3_R2_A: length 5.9
  TOP w0.254: PR5830.2 v1(87.49,214.33) PR5831.1
  BOTTOM w0.102: v1(87.49,214.33) 87,213.83 87,212.01 v2(88.39,210.62)
VRM_TON_A: length 15.1
  TOP w0.254: v1(67.31,217.55) 67.94,218.19 PR5852.2
  BOTTOM w0.254: v1(67.31,217.55) 66.55,218.31 64.9,218.31 v2(64.14,217.55) 63.2,217.55 62.97,217.32 PJP595.1
VRM_TONSET_A: length 5.8
  TOP w0.203: v1(72.06,217.7) 72.16,217.81 73.38,217.81 73.57,217.61 PR5853.2 73.57,217.02 74.33,216.26 74.98,216.26 75.45,216.73 PU581.55
  BOTTOM w0.102: v1(72.06,217.7) v2(72.87,217.7)
VRM_TONSET_R_A: length 6.4
  TOP w0.254: v1(68.9,217.11) 69.47,217.68 70.89,217.68 71.4,218.19 PR5852.1 71.41,217.56 71.36,217.51 PC5825.2 72.58,217.17 PR5853.1
  BOTTOM w0.102: v1(68.9,217.11) 68.9,217.74 v2(69.14,217.98)
VRM_TSEN_A: length 6.7
  TOP w0.203: 74.98,215.24 75.56,215.24 75.84,215.51 PU581.1
  TOP w0.254: PR5874.2 71.91,216.78 73.03,216.78 PR5871.2 73.84,216.2 74.32,215.72 v1(74.5,215.72) 74.98,215.24
  BOTTOM w0.102: v1(74.5,215.72) 73.84,215.72 v2(73.63,215.93)
VRM_TSEN_R1_A: length 48.8
  TOP w0.254: PR5874.1 67.84,216.23 v1(67.28,216.79) ; PRT583.2 64.2,188.33 64.31,188.21 65.02,188.21 v1(65.25,188.44)
  BOTTOM w0.254: v1(65.25,188.44) 68.83,192.02 v2(73.91,192.02) 75.69,192.02 77.19,193.52 77.19,198.15 70.89,204.44 70.89,206.22 64.76,212.36 64.76,214.74 65.9,215.89 66.38,215.89 v1(67.28,216.79)
VRM_VCC_B: length 25.3
  TOP w0.203: PU581.29 81.44,222.05
  TOP w0.381: v1(82.63,222.28) 84.71,224.36 PC5829.1 84.17,224.63 82.45,222.91 82.3,222.91 81.44,222.05 ; v1(80.64,207.24) 80.42,207.01 PR5876.2
  BOTTOM w0.381: v1(82.63,222.28) 82.63,221.08 81.31,219.76 v2(81.31,218.19) 81.31,216.03 80.95,215.67 80.95,207.54 v1(80.64,207.24)
VRM_VCLK: length 7.7
  TOP w0.102: PR5820.1 85.62,224.35 85.62,224.15 84.66,223.19 84.66,222.87 84.56,222.77 v1(84.56,222.63) 84.56,222.46 82.98,220.88 82.47,220.88 81.92,220.33 PU581.26
  BOTTOM w0.102: v2(83.85,223.14) 84.05,223.14 v1(84.56,222.63)
VRM_VDIO: length 8.3
  TOP w0.102: PU581.25 82.04,219.93 82.37,220.25 83.03,220.25 v1(84.57,221.78) 85.04,222.26 85.04,222.72 PR5819.1
  BOTTOM w0.102: v2(85.57,223.42) 85.57,222.79 v1(84.57,221.78)
VRM_VR_RDY_A: length 542.4
  TOP w0.102: v1(208.51,50.74) PQ9777.1 ; v1(209.46,55.71) 210.02,55.16 212.52,55.16 213.61,56.25 213.61,61.06 223.21,70.66 223.21,75.48 219.68,79 219.68,87.75 222.32,90.38 222.32,95.02 219.25,98.09 218.19,98.09 v1(217.6,98.68) ; Q5.5 107.11,12.32 107.47,12.67 107.47,14.8 108.18,15.51 122.37,15.51 v1(123.98,13.91) ; v1(67.68,219.48) 68.47,218.69 70.9,218.69 PR5816.2 71.64,218.97 73.04,218.97 PC5813.1 73.57,218.07 74.02,217.63 74.02,217.02 74.47,216.57 74.85,216.57 75.4,217.13 PU581.54 ; U104.109 209.12,34.04 v1(209.32,33.84) 209.43,33.73 213.11,33.73 213.51,33.32 v1(213.87,33.32)
  BOTTOM w0.102: v1(217.6,98.68) 217.6,99.62 217.07,100.15 217.07,101.71 217.65,102.29 217.65,106.2 216.76,107.09 216.76,109.13 219.29,111.67 219.29,118.29 222.41,121.41 222.41,124.41 220.7,126.12 220.7,128.71 226.91,134.92 v2(226.91,139.59) 230.02,142.7 230.02,146.35 226.24,150.13 226.24,165.84 227.75,167.35 227.75,175.89 227.67,175.97 227.67,184.32 226.33,185.66 226.33,187.86 226.61,188.14 226.61,189.66 228.18,191.24 228.18,202.68 230.01,204.51 230.01,212.84 230.01,213.6 230.61,214.2 230.61,222.9 224.61,228.89 216.19,228.89 210.69,234.39 208.79,234.39 208.64,234.24 175.33,234.24 169.08,227.99 159.35,227.99 154.69,232.65 146.09,232.65 145.83,232.4 144.68,232.4 144.02,233.06 131.76,233.06 130.28,231.57 118.47,231.57 117.53,232.5 106.94,232.5 103.73,235.71 102.11,235.71 100.84,236.98 89.28,236.98 85.94,233.64 76.61,233.64 71.55,228.58 71.55,227.38 69.91,225.74 69.91,224.24 67.68,222.02 v1(67.68,219.48) ; v1(209.46,55.71) 209.14,55.4 209.14,51.37 v1(208.51,50.74) 209.73,49.52 209.73,47.13 213.18,43.68 213.18,38.76 213.02,38.6 213.02,35.87 213.87,35.02 v1(213.87,33.32) ; v1(209.32,33.84) 209.99,33.17 209.99,31.7 209.6,31.31 208.25,31.31 205.74,28.8 205.03,28.8 204.29,28.07 201.36,28.07 200.63,27.34 199.78,27.34 197.13,24.7 197.13,23.51 196.67,23.05 196.15,23.05 195.4,23.8 182.22,23.8 180.37,21.95 177.68,21.95 176.36,20.62 169.42,20.62 168.66,21.38 164.67,21.38 163.9,22.15 158.76,22.15 158.06,21.45 155.67,21.45 154.9,20.68 154.62,20.68 153.68,19.74 147.63,19.74 146.21,18.32 137.11,18.32 133.37,14.58 131.65,14.58 131.36,14.3 124.37,14.3 v1(123.98,13.91)
VRM_VR_RDY_A_LED: length 6.2
  TOP w0.102: Q5.3 103.02,11.67 102.4,11.05 v1(102.11,11.05) 100.97,11.05 99.85,9.93 CR25.2
  BOTTOM w0.102: v2(101.32,11.07) 101.35,11.05 v1(102.11,11.05)
VRM_VREF_A: length 87.8
  TOP w0.203: 82.77,218.49 82.61,218.33 PU581.21
  TOP w0.254: v1(75.27,184.62) 74.76,184.11 PRT581.1 ; 82.77,218.49 84.33,218.49 85.67,219.84 PR5857.1 86.44,220.33 87.21,220.33 87.73,220.85 89.8,220.85 PR5864.1 90.63,220.03 v1(90.63,218.67) 92.08,218.67 95.39,215.35 99.07,215.35 99.48,215.76 PRT582.1 ; v1(90.25,215.26) 89.66,215.26 89.64,215.24 PR5832.1 ; v1(90.25,215.26) 90.58,214.93 90.58,214.4 89.59,213.41 PR5828.1 88.99,212.97 87.71,211.68 87.71,210.25 PR5826.1 87.02,208.9 86.33,208.21 85.61,208.21 84.96,208.86 PR5836.1 ; v1(90.25,215.26) 90.58,215.6 PR5862.1 ; PR5839.1 89.36,217.07 89.51,216.92 89.97,216.92 90.13,217.08 PR5862.1 ; PR5862.1 91.14,216.52 91.14,214.43 88.24,211.53 88.24,209.6 81.53,202.9 77.37,202.9 v1(77.19,202.72)
  BOTTOM w0.254: v1(77.19,202.72) 77.19,201.96 79.22,199.92 79.22,191.21 75.27,187.26 v2(75.27,185.42) v1(75.27,184.62) ; v1(90.63,218.67) 90.63,215.65 v1(90.25,215.26)
VRM_VREF_F: length 2.3
  TOP w0.254: PR5857.2 v1(87.45,219.84) 87.68,220.07 PC5827.1
  BOTTOM w0.102: v2(86.78,220.21) 87.15,219.84 v1(87.45,219.84)
VRM_VRHOT#: length 6.8
  TOP w0.102: PU581.23 82.22,219.13 82.63,219.53 83.68,219.53 v1(84.02,219.87) 84.92,220.77 84.94,220.77 PR5822.2
  BOTTOM w0.102: v1(84.02,219.87) 83.04,219.87 v2(82.85,219.68)
VRM_VSEN_A: length 10.6
  TOP w0.203: PU581.12 80.24,215.26
  TOP w0.254: PC5818.1 PR5845.1 80.95,209 81.41,209.47 81.46,209.47 PC5817.1 81.47,210.21 81.47,211.2 PR5844.2 82.02,212.29 82.13,212.41 PC5819.1 82.13,213.02 v1(81.61,213.54) 80.24,214.91 80.24,215.26
  BOTTOM w0.102: v2(81.76,214.6) 81.61,214.45 v1(81.61,213.54)
VRP: length 16.2
  TOP w0.254: v1(10.16,8.09) 10.16,9.22 12.84,11.89 13.11,11.89 13.25,11.75 AU1.37
  BOTTOM w0.254: v1(10.16,8.09) 10.19,8.09 11.17,7.11 v2(14.68,7.11) 15.77,6.02 16.69,6.02 17.96,4.75 ACE3.1
VTT_DDR_EN: length 14.1
  TOP w0.102: PQ80.1 218.86,155.9 218.29,156.46 PC486.1 PR432.2 219.51,156.91 219.51,153.88 215.41,149.78 v1(215.01,149.78) PQ115.3
  BOTTOM w0.102: v1(215.01,149.78) 214.71,149.48 v2(214.71,149.02)
VTT_DDR_VCNTL: length 4.6
  TOP w0.102: PC484.1 v1(208.24,144.5)
  TOP w0.508: PU80.6 208.91,146.46 208.24,145.78 PC484.1 PR123.2
  BOTTOM w0.102: v2(208.38,143.71) 208.24,143.85 v1(208.24,144.5)
WAKE#: length 479.3
  TOP w0.102: PCH.BE9 164.24,40.79 v1(164.24,41.2) ; M2R34.1 210.52,6.35 v1(210.69,6.17) ; v1(50.99,123.28) 50.17,124.1 48.69,124.1 46.49,126.31 v1(46.22,126.31) 46.07,126.16 44.78,126.16 44.54,126.4 M2R4.2 ; v1(35.64,150.86) 36.22,150.86 ASR7.1 ; SLOT2.B11 55.45,59.12 59.86,54.71 59.86,49.95 60.49,49.31 60.49,46.75 59.04,45.3 58.24,45.3 57.52,44.59 57.52,42.68 57.66,42.55 58.63,41.57 58.63,40.31 57.73,39.41 56.3,39.41 56.02,39.69 SLOT3.B11 56.77,38.37 56.77,37.23 60.36,33.64 60.36,28.76 58.68,27.08 56.39,27.08 55.87,26.56 55.87,23.33 54.73,22.19 54.73,21.45 55.45,20.73 SLOT4.B11 56.58,18.24 v1(56.58,17.39) 56.58,17.08 57.11,16.55 57.11,13.32 54.42,10.63 54.42,8.98 v1(53.8,8.36) ; v1(57.3,85.57) 56.06,84.33 55.92,84.33 54.73,83.13 54.73,81.05 SLOT1.B11 56.21,80.33 57.28,79.26 57.28,77.85 60.09,75.03 60.8,75.03 62.45,73.39 62.45,69.44 58.53,65.53 58.01,65.53 v1(57.35,64.87) ; v1(163.77,37.1) 163.77,36.95 161.75,34.94 161.75,34.44 160.2,32.88 160.2,31.67 SC174.1 159.89,30.81 v1(160.05,30.66) 160.02,30.63 160.02,29.45 SR363.2
  BOTTOM w0.102: v1(57.3,85.57) 58.03,86.3 58.03,109.39 50.67,116.74 50.67,122.96 v1(50.99,123.28) ; v1(160.05,30.66) 158.64,29.25 156.49,29.25 156.26,29.48 153.25,29.48 152.13,28.35 150.36,28.35 147.11,25.1 139.9,25.1 137.11,22.3 134.5,22.3 131.06,18.86 129.48,18.86 127.92,20.41 63.34,20.41 62.51,19.58 62.51,19.28 61.43,18.2 57.39,18.2 v1(56.58,17.39) ; v1(35.64,150.86) 36.53,149.97 36.53,146.78 39.49,143.82 39.49,143.7 40.86,142.33 40.86,135.75 43.41,133.2 43.41,131.98 46.22,129.17 v2(46.22,127.86) v1(46.22,126.31) ; v1(210.69,6.17) 210.3,6.57 207.2,6.57 206.53,7.24 192.46,7.24 191.41,8.28 191.41,8.45 191.14,8.72 190.43,8.72 189.61,9.55 189.2,9.55 187.81,10.95 184.89,10.95 184.4,10.46 178,10.46 177.09,9.56 175.96,9.56 173.15,6.76 171.17,6.76 170.89,6.47 170.89,6.22 169.52,4.86 161,4.86 156.66,9.2 155.98,9.2 153.59,11.6 141.91,11.6 138.34,8.03 121.37,8.03 120.34,9.06 116.14,9.06 115.37,9.82 106.44,9.82 105.89,9.28 105.89,9.28 105.74,9.13 103.89,9.13 103.66,8.9 95.27,8.9 94.41,9.77 92.69,9.77 92.6,9.68 83.51,9.68 82.65,8.81 75.04,8.81 74.49,8.27 70.12,8.27 69.67,7.82 60.28,7.82 59.55,8.55 58.46,8.55 58.26,8.36 v1(53.8,8.36) ; v1(57.35,64.87) 57.35,63.35 58.67,62.03 58.67,60.67 57.73,59.73 55.73,59.73 SLOT2.B11 ; v1(163.77,37.1) 163.95,37.28 163.95,40.53 164.24,40.82 v1(164.24,41.2)
WIFI_ON/OFF#: length 118.5
  TOP w0.102: J60.56 41.17,112.21 v1(42.75,110.63) 44.21,110.63 45.12,111.54 49.33,111.54 52.27,114.49 54.24,114.49 54.56,114.81 54.56,115.25 SR713.2 ; v1(22.66,40.27) 23.11,40.72 23.11,55.85 26.01,58.75 26.01,62.43 29.88,66.3 29.88,68.77 26.07,72.59 26.07,94.21 35.64,103.78 v1(42.8,103.78)
  BOTTOM w0.102: v1(42.8,103.78) 43.26,104.24 43.26,110.12 v1(42.75,110.63) ; v1(22.66,40.27) 22.89,40.04 22.89,32.11 24.92,30.08 v2(24.92,29.65)
WLAN_PRST#: length 322.2
  TOP w0.089: PCH.AY29 v1(173.52,43.25)
  TOP w0.102: v1(181.26,35.4) 182.37,34.29 182.37,31.69 SR678.2 ; v1(45.06,126.64) 44.82,126.87 43.52,126.87 M2R54.2 ; v1(23.57,123.85) 25.1,123.85 25.62,124.38 29.14,124.38 29.46,124.05 29.46,121.64 33.88,117.22 38.66,117.22 39.19,117.75 41.2,117.75 41.63,118.19 44,118.19 46.1,120.29 v1(46.84,120.29)
  BOTTOM w0.089: v1(173.52,43.25) 174.28,42.49 174.28,41.37 176.08,39.56 176.08,38.47 176.58,37.97
  BOTTOM w0.102: v1(46.84,120.29) 46.84,123.01 46.23,123.62 46.23,125.09 45.06,126.27 v1(45.06,126.64) ; 176.58,37.97 176.78,37.77 179.23,37.77 181.26,35.74 v1(181.26,35.4) 181.26,33.76 180.86,33.36 178.84,33.36 176.93,31.46 175.31,31.46 174.07,30.21 174.07,30.15 170.78,26.86 168.45,26.86 167.61,26.02 166.66,26.02 165.9,25.26 163.28,25.26 162.67,24.65 160.78,24.65 160.39,24.26 156.5,24.26 154.73,22.48 150.58,22.48 149.73,21.63 143.23,21.63 141.99,20.38 134.92,20.38 132.73,18.2 129.08,18.2 128.88,18.4 128.02,18.4 127.97,18.34 127.02,18.34 126.97,18.4 126.02,18.4 125.97,18.34 124.93,18.34 124.88,18.4 124.02,18.4 123.97,18.34 122.93,18.34 122.88,18.4 121.93,18.4 121.88,18.34 120.89,18.34 120.84,18.4 85.85,18.4 85.41,17.96 85.41,17 84.75,16.34 42.27,16.34 41.54,17.07 41.54,17.46 29.82,29.18 29.82,37.17 25.3,41.69 25.11,41.69 v2(24.43,42.37) 23.37,43.43 23.37,57.39 21.82,58.94 21.82,112.98 21.54,113.26 21.54,119.54 23.32,121.32 23.32,123.6 v1(23.57,123.85)
WLAN_PRST_R: length 4.1
  TOP w0.102: J60.53 40.42,124.52 41.47,125.56 M2R54.1
WLAN_RXN1: length 193.5
  TOP w0.102: PCH.L17 167.51,56.96 v1(167.24,56.69) ; v1(45.08,122.15) 44.07,122.15 43.39,121.47 38.35,121.47 37.92,121.9 J60.43
  BOTTOM w0.089: v1(167.24,56.69) 167.89,57.34 167.89,58.09 168.27,58.47 168.73,58.47 169.18,58.92 169.18,61.25 169.42,61.49 169.42,62.74
  BOTTOM w0.102: 136.38,72.94 134.01,70.57 79.47,70.57 74,76.04 56.61,76.04 55.91,76.74 54.7,76.74 53.59,77.85 53.59,78.8 52.47,79.93 52.47,83.28 53.47,84.28 53.47,95.82 49.76,99.53 49.76,114.94 48.81,115.89 48.81,118.59 47.76,119.64 46.64,119.64 46.21,120.07 46.21,121.02 v1(45.08,122.15) ; 136.38,72.94 v2(136.17,73.15) ; 136.38,72.94 138.08,74.64 160.1,74.64 164.69,70.04 164.69,67.7 169.42,62.98 169.42,62.74
WLAN_RXP1: length 193.5
  TOP w0.102: v1(45.09,121.51) 44.65,121.95 44.16,121.95 43.47,121.27 38.26,121.27 37.72,121.81 37.72,122.25 37.64,122.33 37.52,122.33 37.42,122.42 J60.41 ; PCH.K17 167.44,57.72 167.26,57.55 v1(167.26,57.35)
  BOTTOM w0.089: v1(167.26,57.35) 167.41,57.2 167.5,57.2 167.71,57.41 167.71,58.16 168.19,58.65 168.66,58.65 169,58.99 169,61.33 169.24,61.57 169.24,62.69 169.21,62.71
  BOTTOM w0.102: v1(45.09,121.51) 45.43,121.51 46,120.94 46,119.99 46.56,119.44 47.68,119.44 48.61,118.51 48.61,115.81 49.56,114.86 49.56,99.44 53.26,95.74 53.26,84.36 52.26,83.36 52.26,79.84 53.39,78.71 53.39,77.77 54.62,76.54 55.83,76.54 56.53,75.84 73.91,75.84 79.38,70.37 134.09,70.37 135.22,71.49 ; 169.21,62.71 169.21,62.89 164.49,67.62 164.49,69.96 160.01,74.43 138.16,74.43 135.22,71.49 ; 135.22,71.49 v2(135.43,71.27)
WLAN_TXN1: length 200
  TOP w0.089: PCH.B20 169.15,62.52 169.08,62.59 169.08,63.36 169.06,63.37
  TOP w0.102: v1(52.45,120.88) 52.26,120.7 50.93,120.7 50.6,121.03 50.6,122.73 50.22,123.11 50.03,123.11 M2C41.2 ; 169.06,63.37 169.06,67.34 168.43,67.97 168.43,69.29 v1(168.29,69.43)
  BOTTOM w0.102: 139.22,81.86 132.99,81.86 130.35,79.22 61.09,79.22 60.27,80.04 60.27,80.79 59.64,81.42 59.64,81.77 60.43,82.56 60.43,83.23 59.28,84.37 59.28,85.34 58.74,85.88 58.74,111.09 54.15,115.67 52.91,115.67 51.41,117.17 51.41,120.29 51.79,120.68 52.24,120.68 v1(52.45,120.88) ; 139.22,81.86 v2(139.22,81.57) ; 139.22,81.86 140.39,81.86 140.77,81.48 152.86,81.48 161.3,89.92 168.37,89.92 174.62,83.66 174.62,75.85 173.66,74.88 173.46,74.88 172.1,73.52 172.1,71.72 170.5,70.12 169.23,70.12 168.54,69.43 v1(168.29,69.43)
WLAN_TXP1: length 200
  TOP w0.089: 169.27,63.37 169.26,63.36 169.26,62.67 169.33,62.6 169.33,61.79 169.42,61.7 169.42,61.44 169.15,61.18 PCH.C20
  TOP w0.102: v1(168.86,69.11) 168.63,68.88 168.63,68.05 169.27,67.42 169.27,63.37 ; M2C40.2 50.06,122.87 50.17,122.87 50.39,122.65 50.39,120.95 50.84,120.5 52.17,120.5 v1(52.43,120.24)
  BOTTOM w0.102: v1(168.86,69.11) 168.86,69.46 169.32,69.92 170.59,69.92 172.3,71.64 172.3,73.44 173.54,74.68 173.74,74.68 174.83,75.76 174.83,83.74 168.45,90.12 161.21,90.12 152.78,81.68 141.86,81.68 ; 141.86,81.68 140.86,81.68 140.47,82.07 132.9,82.07 130.26,79.43 61.17,79.43 60.48,80.12 60.48,80.87 59.84,81.51 59.84,81.69 60.63,82.47 60.63,83.31 59.49,84.45 59.49,85.42 58.94,85.97 58.94,111.17 54.24,115.87 52.99,115.87 51.61,117.25 51.61,120.21 51.87,120.47 52.2,120.47 v1(52.43,120.24) ; 141.86,81.68 v2(141.86,81.97)
XCLK_BIASREF_WSL: length 19.8
  TOP w0.102: SR400.2 145.79,63.35 v1(145.79,61.54) 145.79,61.45 147.15,60.09 154.27,60.09 154.56,60.38 158.45,60.38 159.19,59.63 PCH.F1
  BOTTOM w0.102: v1(145.79,61.54) 144.5,61.54 v2(144.35,61.39)
XDP2_OBSFN_A0: length 2.8
  TOP w0.102: SR7634.2 93.15,116.4 93.5,116.4 XDP2.3
XDP2_OBSFN_A1: length 3
  TOP w0.102: XDP2.5 93.27,115.93 92.33,115.93 91.94,116.31
XI: length 6.6
  TOP w0.102: U4.51 34.02,139.55 33.16,138.69 UC1.1 32.82,137.1 32.82,135.36 32.92,135.25 33.2,135.25 33.3,135.36 33.3,135.56 X1.3
XLINE2_L: length 65.1
  TOP w0.254: AQ18.3 13.74,59.13 v1(13.26,58.65) ; v1(22.38,7.92) 23.07,7.23 24.42,7.23 24.6,7.41 AL18.1 24.19,8.08 AR7.2 AR10.1 24.75,9.47 AD9.1
  BOTTOM w0.254: v1(22.38,7.92) 21.42,8.88 19.78,8.88 18.63,10.03 18.63,11.49 18,12.12 18,20 17.35,20.65 17.35,28.32 16.72,28.95 16.72,32.75 16.89,32.93 16.89,37.11 16.76,37.24 v2(16.76,38.33) 16.76,39.4 16.89,39.52 16.89,40.39 14.61,42.67 14.61,55.19 12.7,57.1 12.7,58.09 v1(13.26,58.65)
XLINE2_R: length 66.7
  TOP w0.254: v1(13.3,57.9) 13.23,57.83 AQ18.6 ; v1(27.43,10.67) 27.41,10.64 AR8.2 AR9.1 28.21,9.8 28.21,10.37 AD10.1 28.77,10.86 29.08,10.54 29.08,9.91 29.23,9.76 AL17.1
  BOTTOM w0.254: v1(27.43,10.67) 26.67,10.67 26.39,10.39 24.9,10.39 23.19,8.69 22.43,8.69 21.73,9.39 19.99,9.39 19.13,10.24 19.13,11.7 18.5,12.33 18.5,20.21 17.86,20.86 17.86,28.53 17.23,29.16 17.23,32.54 17.4,32.71 17.4,40.69 15.2,42.88 v2(15.2,48.01) 15.2,55.41 13.34,57.28 13.34,57.86 v1(13.3,57.9)
XMIC2_L: length 5.4
  TOP w0.254: AL15.1 38.14,10.07 37.73,10.48 AD12.1 36.96,9.74 AR5.2 AR13.2 v1(36.74,7.92)
  BOTTOM w0.254: v1(36.74,7.92) 36.78,7.92 v2(37.65,8.79)
XMIC2_L_D: length 13.4
  TOP w0.254: AR13.1 35.9,8.28 35.91,7.88 v1(35.91,7.87) ; AD1.2 25.54,6.59 v1(25.81,6.86)
  BOTTOM w0.254: v1(25.81,6.86) 26.04,7.09 26.26,7.09 26.8,7.62 34.62,7.62 34.83,7.84 35.87,7.84 v1(35.91,7.87) v2(35.91,8.86)
XMIC2_R: length 5.7
  TOP w0.254: AR6.2 32.3,8.84 AR12.2 32.3,10.45 32.7,10.86 AD11.1 33.27,10.48 v1(33.27,9.98) 33.27,9.24 AL16.1
  BOTTOM w0.254: v2(32.54,10.19) 33.07,10.19 v1(33.27,9.98)
XMIC2_R_D: length 12.4
  TOP w0.254: v1(23.55,6.63) 23.55,5.05 23.91,4.69 AD1.1 ; v1(31.37,8.76) 31.46,8.85 AR12.1
  BOTTOM w0.254: v1(23.55,6.63) 23.65,6.63 v2(24.42,7.4) 25.65,8.64 29.59,8.64 29.72,8.76 v1(31.37,8.76)
XMM1_EVENT#: length 14.8
  TOP w0.102: D4R1.2 188.73,158.71 187.81,159.64 186.84,159.64 186.25,159.05 185.07,159.05 184.33,159.79 182.91,159.79 182.16,159.05 181.11,159.05 180.29,159.87 177.75,159.87 CON_XMM3.78
XMM2_EVENT#: length 6.1
  TOP w0.102: D4R10.2 190.13,158.98 188.8,158.98 187.91,159.87 186.51,159.87 186.34,159.7 CON_XMM1.78
XMM3_EVENT#: length 4
  TOP w0.102: D4R15.2 192.17,161.51 CON_XMM4.78
XMM4_EVENT#: length 5.6
  TOP w0.102: D4R24.2 206.45,160.36 204.26,160.36 203.59,159.7 201.76,159.7 CON_XMM2.78
XO: length 6.6
  TOP w0.102: U4.50 33.52,139.55 32.8,138.84 32.8,137.92 UC1.2 32.32,136.97 32.46,136.83 32.46,135.23 X1.1
XSPI_CLK: length 18.1
  TOP w0.102: v1(187.45,19.51) 187.73,19.23 188.06,19.23 188.16,19.33 188.16,19.86 188.01,20.02 187.2,20.02 187.05,20.16 187.05,20.31 187.47,20.73 F3R8.2 ; v1(180.42,16.92) 180.87,16.46 180.87,15.77 180.66,15.56 F3U1.6
  BOTTOM w0.102: v1(180.42,16.92) 180.67,16.66 180.9,16.66 181,16.76 181,17.27 181.13,17.4 181.28,17.4 181.38,17.3 181.38,16.79 181.51,16.66 181.69,16.66 181.79,16.76 181.79,17.22 v2(181.97,17.4) 186.79,17.4 187.45,18.06 v1(187.45,19.51)
XSPI_CS#: length 12.3
  TOP w0.102: F3CB1.1 v1(186.4,9.5) 185.28,10.62 185.28,11.57 185.72,12.01 F3U1.1 ; F3CB1.1 185.98,8.42 185.61,8.42 184.35,7.17 184.35,5.26 185.02,4.59 E16.4 ; F3CB1.1 186.84,8.85 186.84,8.85 F3R4.2
  BOTTOM w0.102: v1(186.4,9.5) 186.89,9.5 v2(187.08,9.7)
XSPI_IO2: length 16.9
  TOP w0.102: v1(186.58,18.73) 186.83,18.48 186.83,16.01 186.37,15.56 F3U1.3 ; v1(179.68,17.53) 179.68,18.71 F3R21.2
  BOTTOM w0.102: v1(186.58,18.73) 186.27,18.43 184.2,18.43 v2(184.18,18.41) 183.9,18.12 180.28,18.12 v1(179.68,17.53)
XSPI_IO3: length 18.6
  TOP w0.102: v1(176.17,11.89) 175.82,12.24 175.82,12.92 F3R6.1 176.82,13.37 177.04,13.59 177.04,13.97 177.36,14.29 F3U1.7 180.57,14.29 182.08,15.8 182.08,17.09 186.82,21.83 F3R14.2
  BOTTOM w0.102: v2(175.46,12.01) 175.59,11.89 v1(176.17,11.89)
XSPI_MISO: length 17.9
  TOP w0.102: F3U1.2 187.57,14.29 187.88,14.61 187.88,16.92 187.05,17.75 187.05,19.08 v1(186.61,19.51) ; v1(183.21,19.15) 185.01,20.96 185.01,21.13 184.51,21.64 184.51,21.82 184.81,22.12 184.96,22.12 185.5,21.59 185.67,21.59 185.85,21.77 F3R20.2
  BOTTOM w0.102: v1(186.61,19.51) 186.45,19.67 v2(185.86,19.67) 185.47,19.67 184.95,19.15 v1(183.21,19.15)
XSPI_MOSI: length 18.2
  TOP w0.102: v1(177.2,16.24) 177.79,16.83 F3U1.5 179.16,16.83 179.43,17.09 179.91,17.09 180.15,17.33 180.15,17.78 180.59,18.23 180.59,18.47 180.26,18.8 180.26,18.99 180.51,19.23 180.72,19.23 181.23,18.72 181.43,18.72 181.62,18.92 181.62,19.17 181.16,19.63 181.16,19.88 181.34,20.06 181.59,20.06 182.06,19.6 182.31,19.6 182.49,19.78 182.49,20.03 182.03,20.49 182.03,20.75 182.2,20.93 182.46,20.93 182.92,20.46 183.17,20.46 183.32,20.62 183.32,22.87 183.61,23.15 184.34,23.15 184.48,23.01 184.48,22.64 184.36,22.52 F3R7.2
  BOTTOM w0.102: v1(177.2,16.24) v2(178,16.24)
XTAL_24M_PCH_IN: length 14.1
  TOP w0.102: PCH.E1 159.31,60.82 159.31,61.44 159.23,61.52 159.03,61.52 158.93,61.42 158.93,61.16 158.82,61.06 158.55,61.06 158.5,61.11 158.5,61.52 158.42,61.59 158.22,61.59 158.12,61.49 158.12,61.16 158.01,61.06 157.74,61.06 157.64,61.16 157.64,61.51 157.53,61.62 157.33,61.62 157.23,61.52 157.23,61.12 157.15,61.04 156.9,61.04 156.82,61.11 156.82,61.51 156.71,61.63 156.3,61.63 156.21,61.55 156.21,61.12 156.16,61.06 155.83,61.06 155.57,61.32 155.09,61.32 154.99,61.21 154.13,61.21 v1(153.85,61.49) 153.61,61.49 SR59.2 SC9.1 SR747.1
  BOTTOM w0.102: v2(154.64,61.21) 154.13,61.21 v1(153.85,61.49)
XTAL_24M_PCH_OUT: length 15.9
  TOP w0.102: PCH.A5 161.51,62.33 160.25,62.33 160.12,62.46 159.41,62.46 158.88,61.93 154.38,61.93 v1(153.9,62.41) 153.45,62.85 SR59.1 152.13,62.85 152.08,62.8 SC8.1 150.84,62.8 150.6,62.56 149.22,62.56 Y18.1
  BOTTOM w0.102: v1(153.9,62.41) v2(152.88,62.41)
Y18_R: length 1.5
  TOP w0.102: Y18.3 150.68,61.33 150.84,61.18 SR747.2
N22229907: length 7.3
  TOP w0.254: v1(25.43,28.3) 26.57,29.44 AQ14.2 27.6,29.98 27.66,29.92 AC198.1 28.29,29.92 AR57.1 28.29,28.55 28.72,28.12 28.72,27.91 AR56.2
  BOTTOM w0.254: v2(25.76,27.58) 25.76,27.97 v1(25.43,28.3)
N22229995: length 7.4
  TOP w0.102: AC71.1 29.56,27.67 29.41,27.52 29.41,27.14 AR55.1 27.85,25.58 v1(27.85,23.22) AR1.2
  BOTTOM w0.102: v1(27.85,23.22) 28.02,23.05 v2(28.02,22.4)
N22236315: length 4.6
  TOP w0.102: v1(32.61,125.18) 32.41,125.18 M2R39.1 31.42,125.49 J60.17
  BOTTOM w0.102: v2(32.61,124.28) v1(32.61,125.18)
N22238618: length 5.9
  TOP w0.305: SR759.2 134.8,60.73 v1(134.77,60.75) 134.69,60.83 SC100.1 135.14,61.47 135.28,61.61
  TOP w0.457: 135.28,61.61 SR758.1 SC168.1 135.45,63.28 D20.1
  BOTTOM w0.254: v1(134.77,60.75) v2(134.03,60.75)
N22821452: length 21.6
  TOP w0.089: 183.66,52.46 182.97,51.77 182.3,51.77 181.9,51.37 180.95,51.37 PCH.AC43
  TOP w0.102: SR129.2 199.29,53.27 v1(199.24,53.32) ; 183.66,52.46 v1(185.07,53.87)
  BOTTOM w0.102: v1(185.07,53.87) 185.31,54.1 188.61,54.1 189.46,53.26 194.56,53.26 v2(195.43,54.13) 198.43,54.13 v1(199.24,53.32)
N22824353: length 13.8
  TOP w0.089: 167.49,38.43 167.49,38.81 167.07,39.23 167.07,39.71 167,39.78 167,40.53 PCH.BD15
  TOP w0.102: 167.49,38.43 167.68,38.24 167.68,35.12 165.56,33 165.56,32.55 SR7656.2 164.82,31.81 164.82,30.92 SR746.2 165.6,30.94 v1(165.89,30.94)
  BOTTOM w0.102: v1(165.89,30.94) 166.07,30.76 v2(166.83,30.76)
N22834018: length 14.6
  TOP w0.089: PCH.BF9 163.9,39.74 163.63,39.47 163.63,39.15 162.66,38.18 162.66,37.97
  TOP w0.102: 162.66,37.97 162.66,37.17 159.89,34.41 159.89,33.91 158.6,32.61 158.6,32.26 v1(157.58,31.24) 157.58,31.18 SR364.2
  BOTTOM w0.102: v2(156.39,31.34) 156.95,31.34 157.05,31.24 v1(157.58,31.24)
N22999854: length 34
  TOP w0.102: XU1.AC40 128.2,180.84 124.17,184.87 124.17,195.11 132.36,203.3 v1(132.87,203.3)
  BOTTOM w0.102: v1(132.87,203.3) 132.87,206.38 HT34.1
N23001600: length 24.6
  TOP w0.102: HR630.2 119.94,120.43 119.94,139.09 121.16,140.31 121.16,140.72 121.56,141.11 121.56,142.25 121.47,142.34 121.47,142.72 121.8,143.05 XU1.U2
N23059953: length 2.8
  TOP w0.102: Y5.1 151.26,30.45 v1(151.52,30.7) 151.64,30.82 SR44.1
  BOTTOM w0.102: v2(152.36,30.75) 151.56,30.75 v1(151.52,30.7)
N23556498: length 11.6
  TOP w0.102: SS4.54 214.36,16.54 v1(213.77,15.95) 211.38,13.57 211.38,12.37 211.81,11.94 211.81,9.97 M2R34.2
  BOTTOM w0.102: v2(213.77,16.79) v1(213.77,15.95)
N23953325: length 7.2
  TOP w0.089: PCH.BB1 159.91,41.71 158.82,40.62 158.82,40.18
  TOP w0.102: 158.82,40.18 159.96,39.04 159.96,38.68 158.64,37.36 v1(158.27,37.36)
  BOTTOM w0.102: v1(158.27,37.36) 158.7,36.93 ST128.1
N24344620: length 1.5
  TOP w0.089: v1(169.53,44.52) 169.29,44.28 PCH.AU19
  BOTTOM w0.102: v1(169.53,44.52) 169.85,44.2 ST37.1
N24344621: length 2.3
  TOP w0.102: v1(168.28,44.96) 168.15,45.09 168.15,45.38 PCH.AP17
  BOTTOM w0.102: v1(168.28,44.96) 167.64,45.59 ST36.1
N27023811: length 8.9
  TOP w0.102: M1R37.1 14.4,169.69 v1(14.31,169.59) 13.59,169.59 11.18,167.18 8.3,167.18 J125.14
  BOTTOM w0.102: v2(14.77,170.41) 14.77,170.05 v1(14.31,169.59)
N27303827: length 6.9
  TOP w0.102: PR5812.1 73.57,220.51 73.18,220.12 72.31,220.12 72.14,220.29 71.53,220.29 v1(71.15,220.68)
  TOP w0.203: PU581.49 75.26,219.13
  TOP w0.254: PR5812.1 73.95,220.35 73.95,219.97 74.45,219.47 74.92,219.47 75.26,219.13
  BOTTOM w0.102: v2(70.43,220.68) v1(71.15,220.68)
N27304232: length 3.5
  TOP w0.203: PR5879.1 74.1,218.92 v1(74.68,218.92) 74.87,218.73 PU581.50
  BOTTOM w0.102: v2(75.59,218.8) 75.46,218.92 v1(74.68,218.92)
N27340129: length 1.8
  TOP w0.102: MQ20.6 222.65,106.54 222.61,106.5 222.61,106.05 222.5,105.94 R37456.2
N27340146: length 5.7
  TOP w0.102: v1(225.3,78.94) 225.76,78.94 226.01,79.2 R60375.2 226.62,80.29 226.85,80.29 227.05,80.49 228.42,80.49 228.71,80.21 MQ19.6
  BOTTOM w0.102: v2(226.09,78.94) v1(225.3,78.94)
N27340213: length 53.4
  TOP w0.102: v1(219.58,100.48) 219.58,99.29 221.65,97.22 222.88,97.22 223.67,96.43 224.22,96.43 224.37,96.28 224.37,90.39 221.28,87.3 221.28,80.84 222.68,79.45 224.48,79.45 224.7,79.68 R60375.1 225.17,80.11 225.18,80.12 R69583.1 ; v1(221.74,118.39) 222.3,117.83 222.3,117.06 R60381.1 223.7,115.65 U942691.16
  BOTTOM w0.102: v1(221.74,118.39) 222.3,117.83 222.3,117.2 221.58,116.47 221.58,115.86 v2(221.18,115.47) 220.87,115.15 220.87,111.65 221.31,111.2 221.31,107.69 219.37,105.75 219.37,101.46 219.58,101.24 v1(219.58,100.48)
N27340226: length 5.3
  TOP w0.102: U942691.15 224.21,116.07 R60374.1 223.29,116.98 223.29,118.19 v1(222.81,118.67)
  BOTTOM w0.102: v1(222.81,118.67) 222.66,118.82 v2(222.66,119.74)
N27340366: length 4.1
  TOP w0.102: v1(226.01,106.17) 226.12,106.06 R60373.1 225.8,104.43 225.8,103.76 226.08,103.48 U51.15
  BOTTOM w0.102: v2(226.16,106.93) 226.16,106.68 226.01,106.53 v1(226.01,106.17)
N27340446: length 6.5
  TOP w0.102: U51.16 225.58,103.93 225.27,104.24 224.8,104.24 R60385.1 R69584.1 R37456.1 v1(220.93,104.61)
  BOTTOM w0.102: v2(220.8,103.84) 220.93,103.96 v1(220.93,104.61)
N27396902: length 8.1
  TOP w0.102: v1(36.2,187.78) 36.14,187.73 UR195.2 36.84,187.11 38.07,185.88 39.34,185.88 40.26,184.96 F3U2.3
  BOTTOM w0.102: v1(36.2,187.78) v2(37.01,187.78)
N27412583: length 12.4
  TOP w0.508: PU681.3 43.48,236.25 43.26,236.47 PC6805.1 44.33,238.25 v1(45.62,238.25) PD2.2 PD1.2
  BOTTOM w0.102: v1(45.62,238.25) v2(45.62,237.41)
N27474150: length 7.6
  TOP w0.102: FR32.2 150.32,234.31 FD10.1 150.67,235.16 150.24,235.59 v1(149.96,235.59) 149.96,235.86 P70.4
  BOTTOM w0.102: v1(149.96,235.59) 149.65,235.27 v2(149.15,235.27)
N27670481: length 4
  TOP w0.102: SR7767.2 AC193.1 59.87,7.47 59.49,7.09 P189.3
N27670502: length 7.9
  TOP w0.254: UF5.2 v1(62.87,11.33)
  TOP w0.305: 62.1,8.59 62.1,9.02 ; 62.1,9.02 62.53,9.02 ; 62.1,9.02 62.1,9.45
  TOP w0.635: P189.5 63.49,6.79
  BOTTOM w0.102: v2(58.56,11.47) 59.02,11.02 62.56,11.02 v1(62.87,11.33)
N27670584: length 12.3
  TOP w0.305: v1(69.42,12.17) 69.42,11.56 69.22,11.35 UF7.2 68.39,10.27 69.16,9.5 UCB26.1 AD23.1 68.11,7.58 67.49,6.96 P189.7
  BOTTOM w0.102: v1(69.42,12.17) 70.83,12.17 70.84,12.15 v2(72.83,12.15)
N27702633: length 3.1
  TOP w0.254: D4CB87.2 D4R35.2 164.22,226.99 163.86,226.62 v1(163.86,226.16)
  BOTTOM w0.102: v2(163.09,226.16) v1(163.86,226.16)
N28010235: length 3.9
  TOP w0.102: v1(35.64,150.22) 36.03,150.22 ASR7.2 36.5,149.29 36.52,149.28 U4.25
  BOTTOM w0.102: v1(35.64,150.22) 36.09,149.76 36.09,148.97 v2(35.84,148.72)
N30179390: length 4.1
  TOP w0.102: AC186.2 15.35,226.15 v1(15.24,226.26)
  TOP w0.254: AR228.1 15.57,224.49 16,224.92 AC186.2
  BOTTOM w0.102: v1(15.24,226.26) 15.8,226.26 v2(16.03,226.49)
N30429432: length 7.7
  TOP w0.635: 214.76,209.29 PCE651.1 ; PCE651.1 213.82,210.23 ; PCE651.1 213.82,208.35 ; PCE651.1 212.88,209.29
  BOTTOM w0.254: PQ651.9 214.69,203.02
  BOTTOM w0.635: 213.82,208.26 PCE651.1 ; PCE651.1 213.82,210.32 ; PCE651.1 214.85,209.29
  vias: v1(213.89,204.93) v1(213.87,203.3) v2(214.15,202.49) v3(214.12,207.37) v3(215.87,210.21) v3(216.66,207.24) v3(217.02,208.97) v3(218.64,207.09)
N31341317: length 60.9
  TOP w0.102: SR7781.1 156.65,10.7 v1(156.26,10.32) ; v1(170.75,5.45) 169.54,5.45 v1(169.21,5.77)
  TOP w0.381: 157.17,12.16 SR7781.1 156.65,12.69
  BOTTOM w0.102: v1(156.26,10.32) 156.57,10.32 161.26,5.63 169.07,5.63 v1(169.21,5.77) ; v1(170.75,5.45) 170.85,5.55 173.22,5.55 176.29,8.62 189.62,8.62 191.49,6.76 206.38,6.76 206.81,6.32 208.2,6.32 P17.1
N31343191: length 9.7
  TOP w0.102: v1(88.66,115.58) 89.58,114.67 SR7642.2 89.58,113.88 89.84,113.61 89.84,113.36 90.07,113.13 90.4,113.13 XDP2.21
  BOTTOM w0.102: v2(83.95,115.39) 84.14,115.58 v1(88.66,115.58)
N31343435: length 5.9
  TOP w0.102: v1(87.25,113.61) 87.91,113.61 88.28,113.24 SR7643.2 89.25,113.24 89.92,112.57 90.26,112.57 XDP2.23
  BOTTOM w0.102: v1(87.25,113.61) 86.47,112.84 v2(86.47,112.67)
N31617893: length 5
  TOP w0.102: v1(213,20.95) 213,22.03 SR839.2 213.74,22.77 U104.13
  BOTTOM w0.102: v1(213,20.95) 212.98,20.93 v2(212.98,20.08)
N31617918: length 3.2
  TOP w0.102: OR57.2 218.8,42.55 218.67,42.42 v1(218.67,42.04) 218.67,41.48 218.54,41.35 U104.72
  BOTTOM w0.102: v2(218.67,42.8) v1(218.67,42.04)
N31617920: length 5.6
  TOP w0.102: U104.70 219.34,41.28 220.62,42.57 OR56.2 221.04,43.29 221.04,44.06 v1(220.7,44.4)
  BOTTOM w0.102: v2(220.7,45.21) v1(220.7,44.4)
N31618104: length 4.9
  TOP w0.102: ECR104.1 224.94,25.29 224.76,25.46 v1(224.76,25.83) 224.76,26.18 223.91,27.03 223.91,27.47 223.74,27.64 U104.36
  BOTTOM w0.102: v2(225.53,25.83) v1(224.76,25.83)
N31618424: length 9.1
  TOP w0.102: v1(208.46,26.64) 208.46,26.82 208.04,27.24 U104.126 206.54,27.24 205.24,25.95 205.24,24.63 205.12,24.5 203.56,24.5 OR29.2
  BOTTOM w0.102: v1(208.46,26.64) 208.13,26.31 v2(207.52,26.31)
N31618460: length 5.4
  TOP w0.102: U104.127 206.47,26.84 205.71,26.09 v1(205.71,24.77) 205.71,24.45 ECR67.2
  BOTTOM w0.102: v1(205.71,24.77) 205.31,24.36 205.31,24.08 v2(204.93,23.7)
N31618714: length 6.8
  TOP w0.102: v1(223.11,44.23) 222.97,44.23 ECR96.2 222.14,43.4 222.14,43.28 221.96,43.1 221.96,42.62 221.35,42.01 220.68,42.01 220.14,41.47 U104.68
  BOTTOM w0.102: v1(223.11,44.23) v2(222.15,43.27)
N31619395: length 3.8
  TOP w0.102: OR22.1 205.33,30.94 v1(205.71,30.56) 206.23,30.04 U104.119
  BOTTOM w0.102: v2(204.9,30.56) v1(205.71,30.56)
N31775606: length 4.3
  TOP w0.102: O2Q6.5 217.81,46.1 217.68,46.23 217.68,46.99 218.02,47.33 v1(218.02,47.37) O2R8.1 O2R3.1
  BOTTOM w0.102: v2(218.02,48.18) v1(218.02,47.37)
N31775611: length 4.7
  TOP w0.102: v1(220.33,48.55) 220.76,48.12 O2R11.2 220.76,47.28 220.77,47.27 O2Q6.3 220.21,46.75 220.01,46.56 220.01,46.25 220.17,46.1 O2Q6.2
  BOTTOM w0.102: v1(220.33,48.55) v2(219.83,49.06)
N31776343: length 2.9
  TOP w0.102: v1(206.25,44.75) O2R21.2 205.83,45.43 205.54,45.14 PQ9779.1
  BOTTOM w0.102: v2(205.41,44.75) v1(206.25,44.75)
N31824604: length 4.5
  TOP w0.102: PR6610.1 214.1,125.34 214.03,125.27 PC126.1 213.56,124.37 213.56,123.72 v1(213.32,123.48) 213.14,123.48 212.84,123.79 PU7.5
  BOTTOM w0.102: v1(213.32,123.48) 213.51,123.29 v2(213.51,122.63)
N32020546: length 2.6
  TOP w0.254: PC661.1 213.78,131.42 PR6611.2 214.3,131.2 v1(214.65,131.55)
  BOTTOM w0.102: v2(214.11,130.9) 214.65,131.44 v1(214.65,131.55)
N32093772: length 3.7
  TOP w0.102: P150.1 234.42,136.15 UR69747.1
N32303663: length 11.4
  TOP w0.102: SR7776.2 57.83,13.75 57.83,12.63 55.47,10.27 55.47,9.14 55.89,8.72 ; P189.1 54.84,6.48 UCB27.1 55.89,8.72 ; 55.89,8.72 SR7660.2
N32303673: length 10.5
  TOP w0.102: P189.2 57,6.32 UCB28.1 SR7659.2 58.15,8.72 58.45,9.02 58.45,11.68 59.42,12.66 SR7777.2
N32361839: length 2.5
  TOP w0.457: P216.2 SR7788.1
N32362081: length 2.8
  TOP w0.457: 119.76,4.83 119.08,5.51 SR7787.1
N32532704: length 15.1
  TOP w0.305: P189.6 65.49,7.43 65.66,7.59 UF6.2
  TOP w0.508: UF6.2 66.77,10.33 67.49,11.05 v1(67.49,11.89)
  BOTTOM w0.102: v2(74.75,12.04) 74.35,11.65 71.66,11.65 71.61,11.6 67.78,11.6 v1(67.49,11.89)
N33174972: length 4.4
  TOP w0.102: PQ11.6 230.79,18.9 SR8.2 ; PQ11.5 230.14,19.12 SR8.2 ; SR8.2 v1(229.59,18.68)
  BOTTOM w0.102: v2(230.14,19.23) v1(229.59,18.68)
N33732994: length 9.1
  TOP w0.102: v1(221.18,32.11) 222.32,33.24 U104.50 223.87,33.24 224.45,33.82 226.44,33.82 226.67,34.05 226.89,34.05 227.57,34.73 OR59.1
  BOTTOM w0.102: v1(221.18,32.11) 220.85,31.78 v2(220.85,31.17)
N34397341: length 3.1
  TOP w0.254: D4CB86.2 208.14,234.61 208.1,234.57 D4R31.2 207.65,234.61 207.65,235.23 v1(207.54,235.33)
  BOTTOM w0.102: v2(206.43,236.12) 206.76,236.12 v1(207.54,235.33)
N35057076: length 5.1
  TOP w0.102: SR7682.1 49.17,35.12 49.17,38.53 49.45,38.8 SLOT3.B5
N35057079: length 3
  TOP w0.102: SLOT3.B6 50.45,36.05 50.16,35.76 SR7683.1
N35057128: length 7.2
  TOP w0.102: SLOT2.B5 49.71,59.75 49.71,56.64 48.67,55.6 48.67,53.95 48.74,53.87 SR7684.1
N35057131: length 5.6
  TOP w0.102: SR7685.1 48.88,54.13 48.88,55.51 49.94,56.57 49.94,57.5 SLOT2.B6
N35113534: length 4.9
  TOP w0.102: SR7768.2 77.2,9.56 77.35,9.71 AC196.1 UCR43.2 77.7,8.2 77.49,8 P189.12
N35259136: length 7.4
  TOP w0.102: SLOT4.B5 48.24,18.16 48.21,18.16 47.68,17.63 47.68,15.38 SR7686.1
N35259139: length 4.3
  TOP w0.102: SR7687.1 51.08,13.96 51.08,16.74 SLOT4.B6
N35259888: length 15.2
  TOP w0.102: SR7688.1 48.11,66.46 48.11,67.53 49.23,68.65 49.23,77.22 49.68,77.67 49.68,80.1 SLOT1.B5
N35259890: length 12.7
  TOP w0.102: SLOT1.B6 50.45,77.57 50.6,77.42 50.6,68.71 49.95,68.06 49.95,66.75 50.18,66.52 SR7689.1
N36162932: length 6.1
  TOP w0.102: SR628.2 SR629.1 VCB155.1 25.84,167.75 25.06,166.97 MQ4.1 v1(23.55,166.97)
  BOTTOM w0.102: v1(23.55,166.97) v2(23.55,166.07)
N36226705: length 4.1
  TOP w0.102: v1(46.85,236.64) PC642.1 PR70298.2 44.75,236.16 PU681.2
  BOTTOM w0.102: v1(46.85,236.64) v2(47.62,236.64)
N37223886: length 9.1
  TOP w0.102: XDP2.48 92.63,101.71 v1(92.63,100.81) 92.63,100.33 93.99,98.97 SR7691.1
  BOTTOM w0.102: v1(92.63,100.81) 92.41,100.58 91.44,100.58 v2(91.19,100.84)
N37417388: length 3.6
  TOP w0.102: MQ19.3 227.41,81.86 227.2,82.07 v1(226.52,82.07) 226.02,81.57 R69583.2
  BOTTOM w0.102: v1(226.52,82.07) v2(225.96,81.51)
N37417652: length 5.2
  TOP w0.102: MQ20.3 221.35,108.35 221.72,107.98 222.88,107.98 223.19,107.67 223.19,106.15 223.47,105.87 R69584.2
N39243785: length 4.7
  TOP w0.102: UR69710.1 18.81,142.34 CB4113.1 18.52,141.63 v1(18.63,141.52) 18.63,141.24 18.3,140.9 UU50.4
  BOTTOM w0.102: v1(18.63,141.52) 18.63,142.1 v2(18.24,142.48)
N39829666: length 5.7
  TOP w0.102: M2R45.2 225.36,19.12 SS4.10 225.36,16.67 224.94,16.26 v1(223.49,16.26)
  BOTTOM w0.102: v2(224,16.76) v1(223.49,16.26)
N40204150: length 13.5
  TOP w0.089: PCH.BE26 172.48,40.2 172.12,39.84 172.12,37.28
  TOP w0.102: SR650.2 175.91,31.17 175.91,33.97 176.28,34.34 176.28,34.82 175.92,35.18 v1(175.51,35.18) 175.01,35.18 174.96,35.13 174.27,35.13 172.12,37.28
  BOTTOM w0.102: v2(175.31,36.04) 175.51,35.84 v1(175.51,35.18)
N40660278: length 1.9
  TOP w0.102: U5.1 21.29,146.55 21.29,146.56 AR237.2
N40660280: length 3
  TOP w0.102: U5.8 20.69,149.77 v1(20.92,150) 21.08,150.16 AR238.2
  BOTTOM w0.102: v1(20.92,150) v2(21.5,150.58)
N40692911: length 17.4
  TOP w0.102: HR627.2 188.62,43.55 187.58,43.55 187.13,43.99 v1(184.05,43.99) ; PCH.AP29 v1(174.35,45.47)
  BOTTOM w0.089: v1(174.35,45.47) 174.75,45.06 174.75,44.73 175.14,44.34 175.94,44.34 176.1,44.51 177.82,44.51 v2(178.09,44.24) 178.7,43.63 180.61,43.63 181.39,44.41 183.63,44.41 v1(184.05,43.99)
N40953271: length 23
  TOP w0.102: PU5.1 124.6,97.52 124.36,97.28 PC15.1 123.99,96.65 123.95,96.61 PR124.2 124.46,95.67 124.46,94.87 v1(124.74,94.59) 125.6,93.73 126.49,93.73 126.75,93.47 126.75,91.44 127.14,91.05 130.38,91.05 130.81,91.48 132.97,91.48 133.02,91.43 135.97,91.43 PR115.2 137.22,92.68 138.28,92.68 138.44,92.85 MQ29.3
  BOTTOM w0.102: v1(124.74,94.59) 124.56,94.77 v2(124.56,95.4)
N40953285: length 9.3
  TOP w0.102: M1R40.2 PC152.1 134.71,95.59 133.69,96.61 133.69,97.8 v1(134.21,98.32) ; M1R40.2 136.44,96.01 137.67,96.01 137.79,95.89 MQ29.5 ; M1R40.2 136.3,95.31 MQ29.6
  BOTTOM w0.102: v1(134.21,98.32) v2(134.21,97.54)
N40953629: length 5.7
  TOP w0.102: ECQ13.1 133.06,92.62 132.72,92.96 v1(132.72,94.87) ECC55.1 ECR92.2
  BOTTOM w0.102: v2(132.11,94.39) 132.23,94.39 v1(132.72,94.87)
N41238615: length 105.7
  TOP w0.102: v1(128.92,108.05) 130.12,109.25 134.14,109.25 134.31,109.42 134.63,109.42 PR249.1 134.56,108.71 SR75.2 ; v1(74.88,97.83) 82.43,90.28 94.66,90.28 96.5,88.45 v1(128.2,88.45)
  BOTTOM w0.102: v1(74.88,97.83) 74.88,99.38 76.83,101.33 76.83,103.45 70.39,109.9 v2(70.39,110.56) ; v1(128.2,88.45) 127.75,88.89 127.75,94.09 126.05,95.79 126.05,96.26 127.21,97.42 129.44,97.42 129.82,97.8 129.82,100.51 128.05,102.27 128.05,107.18 v1(128.92,108.05)
N41891685: length 20
  TOP w0.102: v1(187.12,45.19) 187.12,45.3 HR629.2 ; PCH.AU22 170.66,44.83 v1(170.69,44.83)
  BOTTOM w0.102: v1(187.12,45.19) v2(186.39,45.19) 179.8,45.19 179.49,45.5 178.16,45.5 177.43,44.77 175.96,44.77 174.84,45.89 173.93,45.89 173.69,45.64 171.5,45.64 v1(170.69,44.83)
N41919364: length 3.1
  TOP w0.102: XDP2.1 94.13,116.48 94.13,118.03 SR7622.1
N42989797: length 4
  TOP w0.102: FR36.1 130.29,237.25 P458.4
N43045291: length 41.6
  TOP w0.102: HR631.1 136.18,210.12 v1(135.78,209.72) 134.59,208.53 134.59,207.78 122.64,195.83 122.64,183.75 125.75,180.64 126.69,180.64 126.94,180.4 126.94,180.22 127.15,180.01 127.27,180.01 127.79,179.49 127.79,178.99 128.2,178.58 XU1.AC38
  BOTTOM w0.102: v2(136.3,210.24) v1(135.78,209.72)
N43118664: length 6.8
  TOP w0.254: AQ23.1 28.51,13.25 v1(28.07,12.8) 27.6,12.33 25.06,12.33 24.59,11.86 AR263.2
  BOTTOM w0.102: v2(28.07,13.61) v1(28.07,12.8)
N43303512: length 4.4
  TOP w0.102: UCR30.2 117.61,43.6 117.53,43.69 116.89,43.69 116.64,43.94 116.64,45.31 117.59,46.27 Y19.3
N43568527: length 3.7
  TOP w0.102: SLOT3.B12 58.45,36.66 SR7780.1
N43669288: length 3.6
  TOP w0.102: UCR36.1 111.99,28.52 111.85,28.66 111.85,29.43 111.92,29.5 U15.26
N43846197: length 16.3
  TOP w0.102: P24.8 240.16,103.06 240.16,90.17 238.96,88.98 UR69748.1
N44468919: length 4.1
  TOP w0.102: UCR25.2 103.29,28.74 103.43,28.88 UC2.3 103.43,30.61 v1(103.99,31.17)
  BOTTOM w0.102: v2(104.76,31.18) 104,31.18 v1(103.99,31.17)
N44790831: length 4.1
  TOP w0.102: U15.33 115.42,30.84 115.54,30.71 115.75,30.71 116.29,30.17 116.29,29.84 116.97,29.17 117.12,29.17 UCR46.1
N44790838: length 4
  TOP w0.102: U15.32 114.92,30.79 115.22,30.5 115.66,30.5 116.08,30.08 116.08,29.75 116.43,29.4 116.43,29.01 UCR47.1
N44794326: length 5.3
  TOP w0.102: FR37.2 89.03,12.27 87.97,11.21 P_HDDFAN.3
N4299213519: length 5.2
  TOP w0.102: v1(38.4,147.98) 39.5,147.98 40.56,146.91 40.56,145.73 40.67,145.63 U4.11
  BOTTOM w0.102: ST76.1 38.84,147.55 v1(38.4,147.98)
N4299213520: length 6.2
  TOP w0.102: U4.10 40.44,145.13 40.23,145.33 40.23,146.79 39.6,147.42 37.85,147.42 v1(37.74,147.52)
  BOTTOM w0.102: ST77.1 37.57,147.7 v1(37.74,147.52)

## Copper pours and planes (outline as drawn)
+1VSB on TOP (solid shape): 191.88,69.32 191.88,68.81 191.63,68.55 189.42,68.55 189.24,68.73 189.24,69.48 189.31,69.55 191.65,69.55
+1VSB on TOP (solid shape): 200.38,80.01 201.17,80.01 201.93,79.25 201.93,75.74 202.37,75.3 202.37,61.5 202.08,61.21 198.27,61.21 197.74,60.68 196.57,60.68 196.32,60.93 196.32,62.74 197.31,63.73 197.31,73.48 198.91,73.48 198.91,75.11 197.85,75.11 197.6,75.23 197.6,75.8 197.6,75.8 197.36,76.29 197.36,76.3 196.54,77.11 194.79,77.11 193.59,78.3 193.59,81 194.29,81.7 198.69,81.7
+1VSB on TOP (solid shape): 169.77,48.2 170.04,48.04 170.31,48.2 170.55,48.2 170.81,48.04 171.08,48.2 171.32,48.2 171.38,48.12 171.46,48.07 171.47,48.07 171.57,47.97 171.57,47.95 171.62,47.77 171.75,47.62 171.75,47.41 171.61,47.27 170.79,47.27 170.38,46.86 170.38,46.46 170.23,46.3 170,46.3 169.96,46.34 169.95,46.42 169.93,46.5 169.93,46.69 169.13,47.49 169.13,47.76 169.56,48.2
+1VSB on TOP (solid shape): outline of 341 points within 166.95,49.72 174.09,56.39
+1VSB on BOTTOM (solid shape): 172.24,50.39 172.24,48.59 171.4,47.75 169.48,47.75 169.39,47.84 169.39,48.21 169.47,48.29 169.79,48.29 170.15,48.65 170.15,50.24 170.56,50.65 171.98,50.65
+1VSB on VCC (solid shape): outline of 126 points within 166.12,44.07 205.36,76.33
