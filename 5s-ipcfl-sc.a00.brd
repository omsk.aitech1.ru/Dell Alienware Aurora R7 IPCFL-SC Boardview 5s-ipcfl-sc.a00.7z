# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Nets (continued)
PE9_RXN: PCH.G31(PCIE9_RXN/SATA0A_RXN) SLOT3.A17(PERN0)
PE9_RXP: PCH.H31(PCIE9_RXP/SATA0A_RXP) SLOT3.A16(PERP0)
PE9_TXN: PCH.D31(PCIE9_TXN/SATA0A_TXN) SC160.1
PE9_TXN_C: SC160.2 SLOT3.B15(PETN0)
PE9_TXP: PCH.C31(PCIE9_TXP/SATA0A_TXP) SC162.1
PE9_TXP_C: SC162.2 SLOT3.B14(PETP0)
PE10_RXN: PCH.G29(PCIE10_RXN/SATA1A_RXN) SLOT3.A22(PERN1)
PE10_RXP: PCH.E29(PCIE10_RXP/SATA1A_RXP) SLOT3.A21(PERP1)
PE10_TXN: PCH.B31(PCIE10_TXN/SATA1A_TXN) SC158.1
PE10_TXN_C: SC158.2 SLOT3.B20(PETN1)
PE10_TXP: PCH.A32(PCIE10_TXP/SATA1A_TXP) SC164.1
PE10_TXP_C: SC164.2 SLOT3.B19(PETP1)
PE11_RXN: PCH.L31(PCIE11_RXN) SLOT3.A26(PERN2)
PE11_RXP: PCH.K31(PCIE11_RXP) SLOT3.A25(PERP2)
PE11_TXN: PCH.C32(PCIE11_TXN) SC165.1
PE11_TXN_C: SC165.2 SLOT3.B24(PETN2)
PE11_TXP: PCH.B32(PCIE11_TXP) SC161.1
PE11_TXP_C: SC161.2 SLOT3.B23(PETP2)
PE12_RXN: PCH.E33(PCIE12_RXN) SLOT3.A30(PERN3)
PE12_RXP: PCH.G33(PCIE12_RXP) SLOT3.A29(PERP3)
PE12_TXN: PCH.C33(PCIE12_TXN) SC163.1
PE12_TXN_C: SC163.2 SLOT3.B28(PETN3)
PE12_TXP: PCH.B33(PCIE12_TXP) SC159.1
PE12_TXP_C: SC159.2 SLOT3.B27(PETP3)
PE16_A6_SLOT1: SLOT1.A6(JTAG3) XR8.2
PE16_A6_SLOT4: SLOT4.A6(JTAG3) XR16.2
PE16_A8_SLOT1: SLOT1.A8(JTAG5) XR9.2
PE16_A8_SLOT4: SLOT4.A8(JTAG5) XR12.2
PE16_TCK_SLOT1: SLOT1.A5(JTAG2) XR10.1
PE16_TCK_SLOT4: SLOT4.A5(JTAG2) XR14.1
PE16_TRST#_SLOT1: SLOT1.B9(JTAG1) XR5.2
PE16_TRST#_SLOT4: SLOT4.B9(JTAG1) XR13.2
PE17_RXN: PCH.J41(PCIE17_RXN/SATA4_RXN) SS4.43(PERP0/SATA-B-)
PE17_RXP: PCH.K39(PCIE17_RXP/SATA4_RXP) SS4.41(PERN0/SATA-B+)
PE17_TXN: M2C22.2 PCH.E45(PCIE17_TXN/SATA4_TXN)
PE17_TXN1_C: M2C22.1 SS4.47(PETN0/SATA-A-)
PE17_TXP: M2C23.2 PCH.F45(PCIE17_TXP/SATA4_TXP)
PE17_TXP1_C: M2C23.1 SS4.49(PETP0/SATA-A+)
PE18_RXN: PCH.M39(PCIE18_RXN/SATA5_RXN) SS4.29(PERN1)
PE18_RXP: PCH.M41(PCIE18_RXP/SATA5_RXP) SS4.31(PERP1)
PE18_TXN: M2C25.2 PCH.G45(PCIE18_TXN/SATA5_TXN)
PE18_TXN2_C: M2C25.1 SS4.35(PETN1)
PE18_TXP: M2C24.2 PCH.G44(PCIE18_TXP/SATA5_TXP)
PE18_TXP2_C: M2C24.1 SS4.37(PETP1)
PE19_RXN: PCH.P39(PCIE19_RXN/SATA6_RXN) SS4.17(PERN2)
PE19_RXP: PCH.P41(PCIE19_RXP/SATA6_RXP) SS4.19(PERP2)
PE19_TXN: M2C27.2 PCH.H44(PCIE19_TXN/SATA6_TXN)
PE19_TXN3_C: M2C27.1 SS4.23(PETN2)
PE19_TXP: M2C26.2 PCH.H45(PCIE19_TXP/SATA6_TXP)
PE19_TXP3_C: M2C26.1 SS4.25(PETP2)
PE20_RXN: PCH.P38(PCIE20_RXN/SATA7_RXN) SS4.5(PERN3)
PE20_RXP: PCH.P36(PCIE20_RXP/SATA7_RXP) SS4.7(PERP3)
PE20_TXN: M2C29.2 PCH.J43(PCIE20_TXN/SATA7_TXN)
PE20_TXN4_C: M2C29.1 SS4.11(PETN3)
PE20_TXP: M2C28.2 PCH.J44(PCIE20_TXP/SATA7_TXP)
PE20_TXP4_C: M2C28.1 SS4.13(PETP3)
PECI_PCH: HR22.1 PCH.AK4(PECI)
PECI_READY: OR3.2 U104.31(PECI_READY/LVSMB_DAT1)
PECI_SIO: HR22.2 O2R1.1 XU1.G7(PECI)
PLTRST_CPU#: HC5.1 PCH.AK3(PLTRST_PROC#) XU1.E7(RESET#)
PLTRST_PCIE1#: J60.52(PERST0#(O)(0/3.3V)) LC18.1 LR1.2 M2C44.1 M2C48.1 R636.1 SS4.50(PERST#) U4.30(PE_RST#) U10.2(PERSTN) U104.51(PCI_RST_1#/GP026) UC950.1
PM_DOWN: HR27.1 PCH.AH2(PM_DOWN) SR694.1
PM_DOWN_R: HR27.2 XU1.D8(PM_DOWN)
PM_SYNC: SR220.2 XU1.E8(PM_SYNC)
PM_SYNC_R: PCH.AH3(PM_SYNC) SR220.1
PORST#: U4.9(PORST#) UC641.1 UC969.1 UD8869.1(ANODE) UR69692.1
PQ37_S_A: AR235.1 PC132.2 PQ37.2(SOURCE) PR198.2
PQ46_EN_R1: PC133.1 PQ46.2(BASE1) PR249.2
PQ46_EN_R2: PQ46.3(EMITTER2) PR248.2
PQ46_EN_R3: PQ46.4(COLLECTOR2) PR244.1
PQ46_EN_R4: PC274.1 PQ60.1(GATE) PR244.2 PR245.1
PQ54_S_A: AR233.1 PC131.2 PQ54.2(SOURCE) PR137.2
PROC_AUDIO_CLK: SR246.1 XU1.V3(PROC_AUDIO_CLK)
PROC_AUDIO_CLK_R: PCH.AM2(DISPA_BCLK) SR246.2
PROC_AUDIO_SDI: HR28.1 XU1.V2(PROC_AUDIO_SDI)
PROC_AUDIO_SDI_R: HR28.2 PCH.AM3(DISPA_SDO)
PROC_AUDIO_SDO: PCH.AN2(DISPA_SDI) SR245.1
PROC_AUDIO_SDO_R: SR245.2 XU1.U1(PROC_AUDIO_SDO)
PROC_SEL#: PR312.2 XU1.AB36(PROC_SELECT#)
PROCHOT#: C83.1 ECR104.2 HR24.2 HR26.1 PR5822.1 PR5823.2
PROCHOT#_R: HC24.1 HR26.2 XU1.C39(PROCHOT#)
PROCPWRGD: HC23.1 HR86.1 XU1.F8(PROCPWRGD)
PRSENT_SOLT1: M2R40.2 SLOT1.B17(PRSNT2_1#) SLOT1.B31(PRSNT2_2#) SLOT1.B48(PRSNT2_3#) SLOT1.B81(PRSNT2_4#)
PRSENT_SOLT4: M2R44.2 SLOT4.B17(PRSNT2_1#) SLOT4.B31(PRSNT2_2#) SLOT4.B48(PRSNT2_3#) SLOT4.B81(PRSNT2_4#)
PS_ON#: ECR98.1 MQ35.3(DRAIN) P1R2.2
PS_ON#_C: ECR98.2 MQ35.2(GATE) OR69.2 U104.53(PS_ON#/GP030)
PSW_EN#: P215.1 PCH.BG11(GPD7/RSVD) SR375.2
PWRBTN#: AC197.1 O2CB15.1 O3R5.1 PCH.BC5(GPD3/PWRBTN#) SC105.1 SR7630.2 SW1.1 SW1.2 U104.34(PWRBTN#/GP015) UCR47.2 XDP2.41(HOOK1)
RBIAS: LR24.1 U10.10(RBIAS)
REGREF: AC188.1 AU1.3(REGREF)
REMOTE1+: AMB_Q1.1(BASE) AMB_Q1.3(COLLECTOR) O2C4.1 O2C5.1 U104.41(REMOTE1+)
REMOTE1-: AMB_Q1.2(EMITTER) O2C4.2 O2C5.2 U104.42(REMOTE1-)
REMOTE2+: GFX_Q1.1(BASE) GFX_Q1.3(COLLECTOR) O2C1.1 O2C2.1 U104.43(REMOTE2A+/REMOTE2B-)
REMOTE2-: GFX_Q1.2(EMITTER) O2C1.2 O2C2.2 U104.44(REMOTE2A-/REMOTE2B+)
REXT: U4.59(REXT) UR69686.2
REXT_CC: AR247.2 U5.9(REXT)
ROLE_SEL: AR241.1 U5.15(ROLE_SEL)
RTCRST#: P216.1 PCH.BE8(RTCRST#) SC103.1 SR101.2
RTCX1_NO_IO_HS_S20MIL: PCH.BF7(RTCX1) SC6.1 SR44.2 SR45.1
RTCX2_NO_IO_HS_S20MIL: PCH.BG7(RTCX2) SC7.1 SR45.2 Y5.4
S/PDIF_OUT: AC186.1 AR20.1 AU1.48(SPDIF-OUT)
S/PDIF_OUT_B: AR20.2 S/PDIF.1(VIN)
S/PDIF_OUT_R: AC185.2 AR227.2 AR228.2 S/PDIF.5
S_PECI_REQ#: SR7656.1 U104.20((H_CPURST#)GP005/PECI_REQUEST#)
SA_DAC: PC570.1 PR70188.2 PU12.7(VREF1)
SA_SET: PR6603.1 PR6605.2 PU12.4(PINSET1)
SATA2_PCIE3_DET: M2R1.2 PCH.AK33(GPP_F1/SATAXPCIE4/SATAGP4) SS4.69(PEDET)
SATA_RXN0: PCH.G35(PCIE13_RXN/SATA0B_RXN) TC3.1
SATA_RXN0_C: P61.5(RX-) TC3.2
SATA_RXN1: PCH.E37(PCIE14_RXN/SATA1B_RXN) TC11.1
SATA_RXN1_C: P62.5(RX-) TC11.2
SATA_RXN2: PCH.E41(PCIE15_RXN/SATA2_RXN) TC23.1
SATA_RXN2_C: P63.5(RX-) TC23.2
SATA_RXN3: PCH.D42(PCIE16_RXN/SATA3_RXN) TC7.1
SATA_RXN3_C: P64.5(RX-) TC7.2
SATA_RXP0: PCH.E35(PCIE13_RXP/SATA0B_RXP) TC4.1
SATA_RXP0_C: P61.6(RX+) TC4.2
SATA_RXP1: PCH.G37(PCIE14_RXP/SATA1B_RXP) TC12.1
SATA_RXP1_C: P62.6(RX+) TC12.2
SATA_RXP2: PCH.C42(PCIE15_RXP/SATA2_RXP) TC24.1
SATA_RXP2_C: P63.6(RX+) TC24.2
SATA_RXP3: PCH.E43(PCIE16_RXP/SATA3_RXP) TC8.1
SATA_RXP3_C: P64.6(RX+) TC8.2
SATA_TXN0: PCH.C36(PCIE13_TXN/SATA0B_TXN) TC2.1
SATA_TXN0_C: P61.3(TX-) TC2.2
SATA_TXN1: PCH.A37(PCIE14_TXN/SATA1B_TXN) TC10.1
SATA_TXN1_C: P62.3(TX-) TC10.2
SATA_TXN2: PCH.C38(PCIE15_TXN/SATA2_TXN) TC22.1
SATA_TXN2_C: P63.3(TX-) TC22.2
SATA_TXN3: PCH.B39(PCIE16_TXN/SATA3_TXN) TC6.1
SATA_TXN3_C: P64.3(TX-) TC6.2
SATA_TXP0: PCH.B36(PCIE13_TXP/SATA0B_TXP) TC1.1
SATA_TXP0_C: P61.2(TX+) TC1.2
SATA_TXP1: PCH.B37(PCIE14_TXP/SATA1B_TXP) TC9.1
SATA_TXP1_C: P62.2(TX+) TC9.2
SATA_TXP2: PCH.B38(PCIE15_TXP/SATA2_TXP) TC21.1
SATA_TXP2_C: P63.2(TX+) TC21.2
SATA_TXP3: PCH.A39(PCIE16_TXP/SATA3_TXP) TC5.1
SATA_TXP3_C: P64.2(TX+) TC5.2
SENSEA: AR14.1 AR15.1 AR16.1 AR17.1 AU1.13(SENSEA)
SENSEB: AR11.1 AR18.1 AR19.1 AR25.1 AU1.34(SENSEB)
SERIRQ_ESPI: ECR67.1 SR85.2
SIDE-L: AC171.2 AR215.1
SIDE-L_C: AC171.1 AU1.45(SIDE-L)
SIDE-R: AC172.2 AR217.1
SIDE-R_C: AC172.1 AU1.46(SIDE-R)
SIDE_JD: AR18.2 J83.63
SIDESURR_L: AC174.1 AD14.1(ANODE) AL11.2 J83.62
SIDESURR_L_B: AL11.1 AQ16.6 AR215.2 AR221.1
SIDESURR_L_MUTE: AQ16.2 AR201.2
SIDESURR_R: AC173.1 AD13.1(ANODE) AL13.2 J83.65
SIDESURR_R_B: AL13.1 AQ16.3 AR217.2 AR220.1
SIDESURR_R_MUTE: AQ16.5 AR202.2
SIO_PCH_PLTRST#_LED: CR7.2(CATHODE) Q5.6(DRAIN)
SIO_PCH_RSMRST#_LED: CR27.2(CATHODE) Q3.3(DRAIN)
SIO_PECI_R: O2R1.2 SC52.2 U104.30(PECI/LVSMB_CLK1)
SIO_SLP_SUS#: PR189.2 PR191.1 U104.74(SUS3V_ON#/GP076)
SIO_SUSCLK: ECR101.2 SCB70.2 U104.19(CLK32)
SIO_TRST#: OR34.2 U104.124(TRST#)
SKTOCC#: HR631.2 PCH.AD44(GPP_F14) SR7769.2
SLOT1_PRST#: M2R40.1 PCH.BE22(GPP_B5/SRCCLKREQ0#) SR343.2
SLOT2_PRST#: M2R41.1 PCH.BF23(GPP_B10/SRCCLKREQ5#) SR680.2
SLOT2_PRST#_R: M2R41.2 SLOT2.B17(PRSNT2_1#) SLOT2.B31(PRSNT2_2#)
SLOT3_PRST#: M2R43.1 PCH.BG30(GPP_H2/SRCCLKREQ8#) SR7628.2
SLOT3_PRST#_R: M2R43.2 SLOT3.B17(PRSNT2_1#) SLOT3.B31(PRSNT2_2#)
SLOT4_PRST#: M2R44.1 PCH.AR29(GPP_H0/SRCCLKREQ6#) SR7629.2
SLP_S3#: C81.1 MQ19.5(GATE) MQ20.5(GATE) MQ25.5(GATE) MQ29.2(GATE) PCH.BA11(GPD4/SLP_S3#) Q3.2(GATE) U104.121(SLP_S3#)
SLP_S3#_LED: CR26.2(CATHODE) Q3.6(DRAIN)
SLP_S4#: C82.1 PCH.BF13(GPD5/SLP_S4#) PQ10.1(GATE) PR236.1 PR6610.2 PR70298.1 SR75.1 U104.69(SLP_S4#) U104.122(SLP_S5#/GP066)
SLP_S4#_R: PC121.1 PC640679.2 PQ9786.1(GATE) PR235.2 PR70256.2
SLP_S4#_R3: PQ23.3(DRAIN) PR234.2 PR235.1
SLP_S4#_R5: PC13.2 PQ23.1(GATE) PR236.2
SLP_SUS#: PCH.BF10(SLP_SUS#) SCB75.1 U104.71(SLP_SUS#)
SLP_SUS#_CRT_R: PC232.2 PC233.2 PC236.1 PQ31.1(GATE) PQ691.1(GATE) PR187.2 PR188.2 PR191.2
SMB_CLK_MAIN: C2.1 CON_XMM1.141(SCL) CON_XMM2.141(SCL) CON_XMM3.141(SCL) CON_XMM4.141(SCL) D4C5.1 OR60.2 R19.2 XDP2.53(SCL)
SMB_CLK_RESUME: M2C46.1 M2R47.1 OR60.1 PCH.BE38(GPP_C0/SMBCLK) SC85.1 SR250.2 SR7665.1 SR7682.2 SR7684.2 SR7686.2 SR7688.2
SMB_CLK_RESUME_DAC: PC566.1 PU12.5(SCL) SR7665.2
SMB_CLK_RESUME_WLAN: J60.60(I2CCLK(O)(0/3.3)) M2R47.2
SMB_DATA_MAIN: C1.1 CON_XMM1.285(SDA) CON_XMM2.285(SDA) CON_XMM3.285(SDA) CON_XMM4.285(SDA) D4C4.1 OR61.2 R18.2 XDP2.51(SDA)
SMB_DATA_RESUME: M2C47.1 M2R46.1 OR61.1 PCH.BC42(GPP_C1/SMBDATA) SC86.1 SR251.2 SR7664.1 SR7683.2 SR7685.2 SR7687.2 SR7689.2
SMB_DATA_RESUME_DAC: PC567.1 PU12.3(SDA) SR7664.2
SMB_DATA_RESUME_WLAN: J60.58(I2CDATA(IO)(0/3.3)) M2R46.2
SMBALERT#_TLS: PCH.BE41(GPP_C2/SMBALERT#) SR257.2
SML0CLK: PCH.BE37(GPP_C3/SML0CLK) SR252.2
SML0DATA: PCH.BC33(GPP_C4/SML0DATA) SR253.2
SML1_CLK_SIO: PCH.BC43(GPP_C6/SML1CLK) SC72.1 SR254.2 U104.26(SMBCLK2/GP011)
SML1_DATA_SIO: PCH.BF38(GPP_C7/SML1DATA) SC90.1 SR255.2 U104.25(SMBDAT2/GP010)
SPI1_MISO: UC2.2(SO) UCR14.2
SPI1_MISO_C: U15.16(PA6) UCR14.1
SPI1_MOSI: UC2.5(SI) UCR13.2
SPI1_MOSI_C: U15.17(PA7) UCR13.1
SPI1_NSS: UC2.1(CS#) UCR24.2
SPI1_NSS_C: U15.14(PA4) UCR24.1
SPI1_SCK: UC2.6(SCK) UCR15.2
SPI1_SCK_C: U15.15(PA5) UCR15.1
SPI_CLK: E16.9 F3R8.1 SR29.1
SPI_CLK_L500MIL: PCH.BE29(SPI0_CLK) SR29.2
SPI_CS0#: E16.3 F3R4.1 PCH.BF28(SPI0_CS0#)
SPI_CS0#_L500MIL: PCH.BF27(SPI0_MOSI) SR27.2
SPI_CS#: F3U2.1(CE#) U4.7(SPI_CS#)
SPI_DI: F3U2.2(SO) U4.8(SPI_DI)
SPI_IO2: E16.12 F3R3.1 F3R12.2 F3R21.1 SR31.1
SPI_IO2_L500MIL: PCH.BF26(SPI0_IO2) SR31.2
SPI_IO2_XDP: F3R12.1 PD3.1(ANODE)
SPI_IO3: E16.11 F3R14.1 SR30.1
SPI_IO3_L500MIL: PCH.BD27(SPI0_IO3) SR30.2
SPI_MISO: E16.7 F3R10.1 F3R20.1 SR28.1
SPI_MISO_L500MIL: PCH.BE27(SPI0_MISO) SR28.2
SPI_MOSI: E16.5 F3R7.1 F3R13.1 SR27.1
SPI_MOSI_XDP: F3R13.2 SR164.2 XDP2.47(HOOK3)
SPKR: AR3.1 ECR97.1 HC11.1 PCH.AU24(GPP_B14/SPKR) SR366.2
SPKR_B: Q9.1(BASE) R37.2
SPKR_O: CB2.1 P7.2(-) Q9.3(COLLECTOR)
SRTCRST#: PCH.BF8(SRTCRST#) SC102.1 SR102.2
SSD_PRST#: M2R36.1 PCH.BF30(GPP_H3/SRCCLKREQ9#) SR7627.2
SSD_PRST#_R: M2R36.2 SS4.52(CLKREQ#)
SSD_SUSCLK: M2C54.1 M2R33.2 SS4.68(SUSCLK(32KHZ))
SURR-L: AC169.2 AR211.1
SURR-L_C: AC169.1 AU1.39(SURR-L)
SURR-L_MUTE: AQ2.2 AR63.2
SURR-R: AC170.2 AR213.1
SURR-R_C: AC170.1 AU1.41(SURR-R)
SURR-R_MUTE: AQ2.5 AR64.2
SURR_JD: AR17.2 J83.53
SURR_L: AC176.1 AD16.1(ANODE) AL7.2 J83.52
SURR_L_B: AL7.1 AQ2.6 AR211.2 AR224.1
SURR_R: AC175.1 AD15.1(ANODE) AL9.2 J83.55
SURR_R_B: AL9.1 AQ2.3 AR213.2 AR222.1
SYS_PWROK: PCH.AW3(SYS_PWROK) SR7658.1 U104.57(PWR_GOOD_3V/GP033)
SYS_RESET#: PCH.AV3(SYS_RESET#) SR166.2 SR7690.1 SR7691.2 SW2.1 SW2.2
SYS_SWCLK: P311.2(CIRRX) U15.37(PA14)
SYS_SWDIO: P311.3(IRRX) U15.34(PA13)
SYSFAN_PWM: FR1.2 FR2.2 U104.49((THERM_THRESH)GP024/PWM3)
SYSFAN_TACH: FD3.3(ANODE) FR8.2 FR17.2 U104.39(TACH3/GP021)
TACH_B: FD7.1(CATHODE1) FD7.2(CATHODE2) FD10.2(ANODE2) P70.3 P458.3
TBT_DET#: PCH.AV41(GPP_D0) SR443.2 SR7780.2
TEST_EN: U4.31(TEST_EN) UR69705.1
TMIN_SHIFT: O2R10.2 PCH.BA22(GPP_B23/SML1ALERT#/PCHHOT#) SR268.2 U104.33((TMIN_SHIFT)GP014)
TP_CPU_RSVD_L8: HT56.1 XU1.L8(IST_TRIG)
TP_GPP_A14: PCH.BF16(GPP_A14/SUS_STAT#/ESPI_RESET#) ST147.1
TP_SLP_A#: PCH.BE13(GPD6/SLP_A#) ST154.1
TP_SLP_LAN#: PCH.AV11(SLP_LAN#) ST1.1
TP_SLP_S0#: PCH.BE24(GPP_B12/SLP_S0#) ST156.1
TP_SLP_WLAN#: PCH.BA9(GPD9/SLP_WLAN#) ST106.1
U2DM_A: U4.22(U2DM_A) UL62.4 URN131.4(Y)
U2DM_A-: J133.12(D-1) M1U6.4(TMDS_CH2-) M1U6.7(NC2) UL62.3 URN131.3(X)
U2DM_B: U4.18(U2DM_B) UL76.3 URN148.3(X)
U2DM_B_C: J_TYPEC.A7(DN1) J_TYPEC.B7(DN1_1) UL76.4 URN148.4(Y) UU52.4(TMDS_CH2-) UU52.7(NC2)
U2DP_A: U4.23(U2DP_A) UL62.1 URN131.2(Y)
U2DP_A+: J133.13(D+1) M1U6.5(TMDS_CH2+) M1U6.6(NC1) UL62.2 URN131.1(X)
U2DP_B: U4.19(U2DP_B) UL76.2 URN148.1(X)
U2DP_B_C: J_TYPEC.A6(DP1) J_TYPEC.B6(DP1_1) UL76.1 URN148.2(Y) UU52.5(TMDS_CH2+) UU52.6(NC1)
U2FAN_DET: FR37.1 U15.41(PB5)
U2FAN_PCH: PCH.AA44(GPP_G7/FAN_TACH_7) SR7784.2 U15.39(PB3)
U3RXN_A: U4.46(U3RXN_A) UC980.2
U3RXN_A_C: J133.15(SSRX-1) UC980.1 UU39.5(I/O4) UU39.6(N/C1)
U3RXN_B: U4.37(U3RXN_B) U5.2(DA_A)
U3RXP_A: U4.45(U3RXP_A) UC979.2
U3RXP_A_C: J133.16(SSRX+1) UC979.1 UU39.4(I/O3) UU39.7(N/C2)
U3RXP_B: U4.36(U3RXP_B) U5.3(DA_B)
U3TXN_A: U4.43(U3TXN_A) UC32.2
U3TXN_A_CMC: UC32.1 UL77.4 URN149.4(Y)
U3TXN_AMC: J133.18(SSTX-1) UL77.3 URN149.3(X) UU39.2(I/O2) UU39.9(N/C3)
U3TXN_B: U4.40(U3TXN_B) U5.6(DB_A)
U3TXP_A: U4.42(U3TXP_A) UC31.2
U3TXP_A_CMC: UC31.1 UL77.1 URN149.2(Y)
U3TXP_AMC: J133.19(SSTX+1) UL77.2 URN149.1(X) UU39.1(I/O1) UU39.10(N/C4)
U3TXP_B: U4.39(U3TXP_B) U5.7(DB_B)
U4_SPI_CLK: F3U2.6(SCK) U4.5(SPI_CLK) UR69703.2
U4_SPI_DO: F3U2.5(SI) U4.6(SPI_DO) UR69704.2
UART1_RXD: P312.2 U15.31(PA10) UCR12.2
UART1_TXD: P312.3 U15.30(PA9) UCR11.2
UC_I2C_LED_SCL: PCH.AY33(GPP_C17/I2C0_SCL) SR7779.2 U15.21(PB10) UCC14.1
UC_I2C_LED_SDA: PCH.AY45(GPP_C16/I2C0_SDA) SR7778.2 U15.22(PB11) UCC13.1
UC_SPKR: R37.1 U15.29(PA8) UCR39.1
USB2_COMP: PCH.AG3(USB2_COMP) SR60.1
USB2_OC#: CR17.1 TUU2.3(OC#) UR69723.2 UR69724.1
USB2_P1_N_CHARGE: U51.11(DM_IN) UL22.3 URN62.3(X)
USB2_P1_P_CHARGE: U51.10(DP_IN) UL22.2 URN62.1(X)
USB2_P1_STATUS#: MQ19.2(GATE) SC167.1 SR7564.2 U51.9(STATUS#)
USB2_P2_N_CHARGE: U942691.11(DM_IN) UL64.3 URN60.3(X)
USB2_P2_P_CHARGE: U942691.10(DP_IN) UL64.2 URN60.1(X)
USB2_P2_STATUS#: MQ20.2(GATE) SC166.1 SR7565.2 U942691.9(STATUS#)
USB2ID: PCH.AG2(USB2_ID) SR2.1 SR70.2
USB2VBUSSENSE: PCH.AE10(USB2_VBUSSENSE) SR1.1 SR20.2
USB3_RX_N1: PCH.B7(USB3_1_RXN) UC987.1
USB3_RX_N1_C: P24.18 UC987.2 UU22.2(TMDS_CH1+) UU22.9(NC3)
USB3_RX_N2: PCH.C8(USB3_2_SSIC_1_RXN) UC992.1
USB3_RX_N2_C: P24.19 UC992.2 UU22.5(TMDS_CH2+) UU22.6(NC1)
USB3_RX_N3: PCH.B9(USB3_3_SSIC_2_RXN) UC994.1
USB3_RX_N3_C: P150.16 UC994.2 UU43.2(TMDS_CH1+) UU43.9(NC3)
USB3_RX_N4: PCH.E11(USB3_4_RXN) UC995.1
USB3_RX_N4_C: P150.17 UC995.2 UU43.5(TMDS_CH2+) UU43.6(NC1)
USB3_RX_N5: PCH.E13(USB3_5_RXN) UC986.2
USB3_RX_N5_C: J133.25(SSRX-2) UC986.1 UU14.5(TMDS_CH2+) UU14.6(NC1)
USB3_RX_N6: PCH.H15(USB3_6_RXN) UC984.2
USB3_RX_N6_C: J133.45(SSRX-4) UC984.1 UU14.2(TMDS_CH1+) UU14.9(NC3)
USB3_RX_N7: PCH.G15(PCIE1_RXN/USB3_7_RXN) UC982.2
USB3_RX_N7_C: J133.35(SSRX-3) UC982.1 UU53.5(TMDS_CH2+) UU53.6(NC1)
USB3_RX_P1: PCH.A7(USB3_1_RXP) UC988.1
USB3_RX_P1_C: P24.16 UC988.2 UU22.1(TMDS_CH1-) UU22.10(NC4)
USB3_RX_P2: PCH.B8(USB3_2_SSIC_1_RXP) UC991.1
USB3_RX_P2_C: P24.17 UC991.2 UU22.4(TMDS_CH2-) UU22.7(NC2)
USB3_RX_P3: PCH.A9(USB3_3_SSIC_2_RXP) UC993.1
USB3_RX_P3_C: P150.14 UC993.2 UU43.1(TMDS_CH1-) UU43.10(NC4)
USB3_RX_P4: PCH.G11(USB3_4_RXP) UC996.1
USB3_RX_P4_C: P150.15 UC996.2 UU43.4(TMDS_CH2-) UU43.7(NC2)
USB3_RX_P5: PCH.G13(USB3_5_RXP) UC985.2
USB3_RX_P5_C: J133.26(SSRX+2) UC985.1 UU14.4(TMDS_CH2-) UU14.7(NC2)
USB3_RX_P6: PCH.K15(USB3_6_RXP) UC983.2
USB3_RX_P6_C: J133.46(SSRX+4) UC983.1 UU14.1(TMDS_CH1-) UU14.10(NC4)
USB3_RX_P7: PCH.E15(PCIE1_RXP/USB3_7_RXP) UC981.2
USB3_RX_P7_C: J133.36(SSRX+3) UC981.1 UU53.4(TMDS_CH2-) UU53.7(NC2)
USB3_SS_TXN1_C: P24.12 UL90.4 URN163.4(Y) UU26.2(TMDS_CH1+) UU26.9(NC3)
USB3_SS_TXN1_CMC: UC50.2 UL90.3 URN163.3(X)
USB3_SS_TXN2_C: P24.13 UL91.4 URN164.4(Y) UU26.5(TMDS_CH2+) UU26.6(NC1)
USB3_SS_TXN2_CMC: UC53.2 UL91.3 URN164.3(X)
USB3_SS_TXN3_C: P150.10 UL94.4 URN167.4(Y) UU44.2(TMDS_CH1+) UU44.9(NC3)
USB3_SS_TXN3_CMC: UC963.2 UL94.3 URN167.3(X)
USB3_SS_TXN4_C: P150.11 UL95.4 URN168.4(Y) UU44.5(TMDS_CH2+) UU44.6(NC1)
USB3_SS_TXN4_CMC: UC964.2 UL95.3 URN168.3(X)
USB3_SS_TXP1_C: P24.10 UL90.1 URN163.2(Y) UU26.1(TMDS_CH1-) UU26.10(NC4)
USB3_SS_TXP1_CMC: UC51.2 UL90.2 URN163.1(X)
USB3_SS_TXP2_C: P24.11 UL91.1 URN164.2(Y) UU26.4(TMDS_CH2-) UU26.7(NC2)
USB3_SS_TXP2_CMC: UC52.2 UL91.2 URN164.1(X)
USB3_SS_TXP3_C: P150.8 UL94.1 URN167.2(Y) UU44.1(TMDS_CH1-) UU44.10(NC4)
USB3_SS_TXP3_CMC: UC960.2 UL94.2 URN167.1(X)
USB3_SS_TXP4_C: P150.9 UL95.1 URN168.2(Y) UU44.4(TMDS_CH2-) UU44.7(NC2)
USB3_SS_TXP4_CMC: UC959.2 UL95.2 URN168.1(X)
USB3_TX_N1: PCH.D13(USB3_1_TXN) UC50.1
USB3_TX_N2: PCH.B13(USB3_2_SSIC_1_TXN) UC53.1
USB3_TX_N3: PCH.B14(USB3_3_SSIC_2_TXN) UC963.1
USB3_TX_N4: PCH.B15(USB3_4_TXN) UC964.1
USB3_TX_N5: PCH.A16(USB3_5_TXN) UC97.1
USB3_TX_N5_C: J133.28(SSTX-2) UL79.3 URN151.3(X) UU53.2(TMDS_CH1+) UU53.9(NC3)
USB3_TX_N5_CMC: UC97.2 UL79.4 URN151.4(Y)
USB3_TX_N6: PCH.C17(USB3_6_TXN) UC99.1
USB3_TX_N6_C: J133.48(SSTX-4) UL84.3 URN156.3(X) UU40.5(TMDS_CH2+) UU40.6(NC1)
USB3_TX_N6_CMC: UC99.2 UL84.4 URN156.4(Y)
USB3_TX_N7: PCH.A18(PCIE1_TXN/USB3_7_TXN) UC30.1
USB3_TX_N7_C: J133.38(SSTX-3) UL83.3 URN155.3(X) UU40.2(TMDS_CH1+) UU40.9(NC3)
USB3_TX_N7_CMC: UC30.2 UL83.4 URN155.4(Y)
USB3_TX_P1: PCH.C13(USB3_1_TXP) UC51.1
USB3_TX_P2: PCH.A14(USB3_2_SSIC_1_TXP) UC52.1
USB3_TX_P3: PCH.C14(USB3_3_SSIC_2_TXP) UC960.1
USB3_TX_P4: PCH.C15(USB3_4_TXP) UC959.1
USB3_TX_P5: PCH.B16(USB3_5_TXP) UC96.1
USB3_TX_P5_C: J133.29(SSTX+2) UL79.2 URN151.1(X) UU53.1(TMDS_CH1-) UU53.10(NC4)
USB3_TX_P5_CMC: UC96.2 UL79.1 URN151.2(Y)
USB3_TX_P6: PCH.D17(USB3_6_TXP) UC98.1
USB3_TX_P6_C: J133.49(SSTX+4) UL84.2 URN156.1(X) UU40.4(TMDS_CH2-) UU40.7(NC2)
USB3_TX_P6_CMC: UC98.2 UL84.1 URN156.2(Y)
USB3_TX_P7: PCH.B18(PCIE1_TXP/USB3_7_TXP) UC29.1
USB3_TX_P7_C: J133.39(SSTX+3) UL83.2 URN155.1(X) UU40.1(TMDS_CH1-) UU40.10(NC4)
USB3_TX_P7_CMC: UC29.2 UL83.1 URN155.2(Y)
USB3P1_RXN1: U5.24(DA_A1) UC978.2
USB3P1_RXN1_C: J_TYPEC.A10(SSRXN2) UC978.1 UU34.1(I/O1) UU34.10(N/C4)
USB3P1_RXN2: U5.20(DA_A2) UC976.2
USB3P1_RXN2_C: J_TYPEC.B10(SSRXN1) UC976.1 UU10.1(I/O1) UU10.10(N/C4)
USB3P1_RXP1: U5.23(DA_B1) UC977.2
USB3P1_RXP1_C: J_TYPEC.A11(SSRXP2) UC977.1 UU34.2(I/O2) UU34.9(N/C3)
USB3P1_RXP2: U5.19(DA_B2) UC975.2
USB3P1_RXP2_C: J_TYPEC.B11(SSRXP1) UC975.1 UU10.2(I/O2) UU10.9(N/C3)
USB3P1_TXN1: U5.22(DB_A1) UC949.2
USB3P1_TXN1_CMC: UC947.1 UL88.2 URN161.1(X)
USB3P1_TXN1_R: J_TYPEC.A3(SSTXN1) UL88.1 URN161.2(Y) UU10.5(I/O4) UU10.6(N/C1)
USB3P1_TXN2: U5.18(DB_A2) UC947.2
USB3P1_TXN2_CMC: UC949.1 UL86.2 URN159.1(X)
USB3P1_TXN2_R: J_TYPEC.B3(SSTXN2) UL86.1 URN159.2(Y) UU34.5(I/O4) UU34.6(N/C1)
USB3P1_TXP1: U5.21(DB_B1) UC948.2
USB3P1_TXP1_CMC: UC946.1 UL88.3 URN161.3(X)
USB3P1_TXP1_R: J_TYPEC.A2(SSTXP1) UL88.4 URN161.4(Y) UU10.4(I/O3) UU10.7(N/C2)
USB3P1_TXP2: U5.17(DB_B2) UC946.2
USB3P1_TXP2_CMC: UC948.1 UL86.3 URN159.3(X)
USB3P1_TXP2_R: J_TYPEC.B2(SSTXP2) UL86.4 URN159.4(Y) UU34.4(I/O3) UU34.7(N/C2)
USB_CHARGEPWR_EN#: C941402.1 PCH.BF11(GPD0/BATLOW#) R69695.1 SR360.2 U51.5(EN) U942691.5(EN)
USB_OC0#: PCH.AJ43(GPP_E9/USB_OC0#) U51.13(FAULT#) UR69715.2 UR69716.1
USB_OC1#: PCH.AH44(GPP_E10/USB_OC1#) U942691.13(FAULT#) UR5.2 UR6.1
USB_OC2#: PCH.AM39(GPP_E11/USB_OC2#) UR69717.2 UR69718.1 UR69730.2 UU51.3(OC#)
USB_OC3#: PCH.AK42(GPP_E12/USB_OC3#) UR69719.2 UR69720.1 UU50.3(OC#)
USB_OCB4#: CR17.2 PCH.AD43(GPP_F15/USB_OCB4#)
USB_OCB5#: PCH.AC44(GPP_F16/USB_OCB5#) UR69725.1 UR69726.2 UU47.3(OC#)
USBN1: PCH.AH5(USB2N_1) UL66.3 URN138.3(X)
USBN2: PCH.AE5(USB2N_2) UL65.3 URN137.3(X)
USBN3: PCH.AH8(USB2N_3) UL67.3 URN139.3(X)
USBN4: PCH.AE2(USB2N_4) UL68.3 URN140.3(X)
USBN5: PCH.AC2(USB2N_5) UL8.3 URN126.3(X)
USBN6: PCH.AF2(USB2N_6) UL7.3 URN134.3(X)
USBN7: PCH.AB2(USB2N_7) U942691.2(DM_OUT)
USBN8: J60.5(USB_D-) PCH.AM8(USB2N_8)
USBN9: PCH.Y3(USB2N_9) UL74.3 URN143.3(X)
USBN10: PCH.AK8(USB2N_10) UL10.4 URN10.4(Y)
USBN11: PCH.W2(USB2N_11) UL70.3 URN144.3(X)
USBN12: PCH.AD3(USB2N_12) UL9.4 URN9.4(Y)
USBN13: PCH.V3(USB2N_13) U51.2(DM_OUT)
USBN14: PCH.AK11(USB2N_14) UL75.4 URN130.4(Y)
USBP1: PCH.AH7(USB2P_1) UL66.2 URN138.1(X)
USBP2: PCH.AE7(USB2P_2) UL65.2 URN137.1(X)
USBP3: PCH.AH10(USB2P_3) UL67.2 URN139.1(X)
USBP4: PCH.AE3(USB2P_4) UL68.2 URN140.1(X)
USBP5: PCH.AC3(USB2P_5) UL8.2 URN126.1(X)
USBP6: PCH.AF1(USB2P_6) UL7.2 URN134.1(X)
USBP7: PCH.AB1(USB2P_7) U942691.3(DP_OUT)
USBP8: J60.3(USB_D+) PCH.AM7(USB2P_8)
USBP9: PCH.Y2(USB2P_9) UL74.2 URN143.1(X)
USBP10: PCH.AK7(USB2P_10) UL10.1 URN10.2(Y)
USBP11: PCH.W1(USB2P_11) UL70.2 URN144.1(X)
USBP12: PCH.AD2(USB2P_12) UL9.1 URN9.2(Y)
USBP13: PCH.V2(USB2P_13) U51.3(DP_OUT)
USBP14: PCH.AK13(USB2P_14) UL75.1 URN130.2(Y)
UU45_EN: CB4107.1 UR30.2 UU45.4(EN/EN#)
UU47_EN: CB4115.1 UR69711.1 UU47.4(EN/EN#)
UU49_48_EN: CR19.2 TUU2.4(EN/EN#)
UU51_EN: CB4122.1 UR69714.2 UR69729.2 UU51.4(EN/EN#)
UU54_EN: APR112.2 CB4127.1 CB4128.1 U5.31(PWR_EN) UU54.4(EN/EN#)
V_IN: O2CB19.1 O2R2.1 O2R22.2 U104.46(V_IN)
VCORE_EN: PR5859.1 PR70189.2 PR70228.2 PR70238.2
VGT_COMP_A: PC5823.2 PR5851.2 PU581.34(COMPA)
VGT_COMP_R_A: PR5849.2 PR5851.1
VGT_FB_A: PC5821.2 PC5823.1 PR5849.1 PR5850.2 PU581.35(FBA)
VGT_IMON_A: PR5866.2 PU581.22(IMONA)
VGT_IMON_F: PR5866.1 PR5869.2
VGT_IMON_NTC_A: PR5865.1 PRT582.2
VGT_IMON_R2_A: PR5864.2 PR5865.2 PR5869.1
VGT_ISEN1_N_A: PR5807.1 PU581.39(ISENA1N)
VGT_ISEN1_P_A: PC5807.1 PR5813.1 PR5883.1 PU581.38(ISENA1P)
VGT_ISEN1N_A: PC5807.2 PC5808.1 PJP612.2 PR5807.2 PR5813.2
VGT_ISEN1P_A: PJP611.2 PR5883.2
VGT_ISEN2_N_A: PR5877.1 PU581.36(ISENA2N)
VGT_ISEN2_P_A: PC5809.1 PR5808.1 PR5884.1 PU581.37(ISENA2P)
VGT_ISEN2N_A: PC5809.2 PC5810.1 PJP614.2 PR5808.2 PR5877.2
VGT_ISEN2P_A: PJP613.2 PR5884.2
VGT_ISEN3_N_A: PR5809.1 PU581.40(ISENA3N) PU581.41(ISENA3P)
VGT_PWM1_A: PU581.47(PWMA1) PU611.2(PWM)
VGT_PWM1_BOT_C: PR6104.1 PU611.1(BOOT)
VGT_PWM1_BOTR_C: PC6107.1 PR6104.2
VGT_PWM1_HG_D: PR6103.1 PU611.8(UGATE)
VGT_PWM1_HGR_D: PC6103.1 PQ611.4(G) PR6101.2 PR6103.2
VGT_PWM1_LG_D: PC6104.1 PC6105.1 PQ612.4(G) PQ613.4(G) PR6105.2 PU611.5(LGATE)
VGT_PWM1_SN: PC6102.1 PR6106.2
VGT_PWM1_SW_C: PC6101.1 PC6103.2 PC6107.2 PJP611.1 PL611.1 PQ611.1(S_1) PQ611.2(S_2) PQ611.3(S_3) PQ612.5(D) PQ612.6(D_1) PQ612.7(D_2) PQ612.8(D_3) PQ612.9(D_4) PQ612.10(D_5) PQ612.11(D_6) PQ612.12(D_7) PQ612.13(D_8) PQ612.14(D_9) PQ613.5(D) PQ613.6(D_1) PQ613.7(D_2) PQ613.8(D_3) PQ613.9(D_4) PQ613.10(D_5) PQ613.11(D_6) PQ613.12(D_7) PQ613.13(D_8) PQ613.14(D_9) PR6101.1 PR6106.1 PU611.7(PHASE)
VGT_PWM1_VCC_C: PC6108.1 PR6102.2 PU611.4(VCC)
VGT_PWM2_A: PU581.46(PWMA2) PU612.2(PWM)
VGT_PWM2_BOT_C: PR6111.1 PU612.1(BOOT)
VGT_PWM2_BOTR_C: PC6115.1 PR6111.2
VGT_PWM2_HG_D: PR6110.1 PU612.8(UGATE)
VGT_PWM2_HGR_D: PC6111.1 PQ614.4(G) PR6108.2 PR6110.2
VGT_PWM2_LG_D: PC6112.1 PC6113.1 PQ615.4(G) PQ616.4(G) PR6112.2 PU612.5(LGATE)
VGT_PWM2_SN: PC6110.1 PR6113.2
VGT_PWM2_SW_C: PC6109.1 PC6111.2 PC6115.2 PJP613.1 PL612.1 PQ614.1(S_1) PQ614.2(S_2) PQ614.3(S_3) PQ615.5(D) PQ615.6(D_1) PQ615.7(D_2) PQ615.8(D_3) PQ615.9(D_4) PQ615.10(D_5) PQ615.11(D_6) PQ615.12(D_7) PQ615.13(D_8) PQ615.14(D_9) PQ616.5(D) PQ616.6(D_1) PQ616.7(D_2) PQ616.8(D_3) PQ616.9(D_4) PQ616.10(D_5) PQ616.11(D_6) PQ616.12(D_7) PQ616.13(D_8) PQ616.14(D_9) PR6108.1 PR6113.1 PU612.7(PHASE)
VGT_PWM2_VCC_C: PC6116.1 PR6109.2 PU612.4(VCC)
VGT_SET1_A: PR5833.2 PR5841.2 PU581.18(SETA1)
VGT_SET1_R1_A: PR5832.2 PR5833.1
VGT_SET1_R2_A: PR5840.2 PR5841.1
VGT_SET2_A: PR5835.2 PR5838.2 PU581.19(SETA2)
VGT_SET2_R1_A: PR5838.1 PR5839.2
VGT_SET2_R2_A: PR5834.2 PR5835.1
VGT_TON_A: PJP615.1 PR5854.2
VGT_TONSET_A: PR5855.2 PU581.43(TONSETA)
VGT_TONSET_R_A: PC5826.2 PR5854.1 PR5855.1
VGT_TSEN_A: PR5872.2 PR5873.2 PU581.42(TSENA)
VGT_TSEN_R1_A: PR5872.1 PRT584.2
VGT_VSEN_A: PC5821.1 PC5822.1 PC5824.1 PR5848.2 PR5850.1 PU581.33(VSENA)
VIDALERT#: HR20.1 HR33.2 PR5821.2 PR5858.2
VIDSCLK: HR17.2 PR5817.2 PR5820.2
VIDSOUT: HR18.1 HR32.2 PR5818.2 PR5819.2
VPP_PWRGD: PR11.1 PR12.1 PR6607.2 PU7.4(PGOOD)
VREF: AC23.1 AU1.27(VREF)
VRM_ALERT#: PR5858.1 PU581.24(ALERT#)
VRM_COMP_A: PC5816.2 PR5847.2 PU581.11(COMP)
VRM_COMP_R_A: PR5846.2 PR5847.1
VRM_DVD_A: PC5830.1 PR5870.2 PR5875.2 PU581.45(DVD)
VRM_EN_A: PC5828.1 PR5859.2 PR5860.2 PR70231.2 PU581.27(EN)
VRM_EN_DISCHARGE: PQ2.3(DRAIN) PR2.2
VRM_EN_R_A: PR2.1 PR70231.1
VRM_FB_A: PC5816.1 PC5818.2 PR5845.2 PR5846.1 PU581.10(FB)
VRM_IBIAS_A: PR5856.2 PU581.31(IBIAS)
VRM_IMON_A: PR5867.2 PU581.20(IMON)
VRM_IMON_F: PR5867.1 PR5868.2
VRM_IMON_NTC_A: PR5863.1 PRT581.2
VRM_IMON_R2_A: PR5862.2 PR5863.2 PR5868.1
VRM_ISEN1_N_A: PR5811.1 PU581.4(ISEN1N)
VRM_ISEN1_P_A: PC5802.1 PR5801.1 PR5810.1 PU581.5(ISEN1P)
VRM_ISEN1N_A: PC5801.1 PC5802.2 PJP592.2 PR5810.2 PR5811.2
VRM_ISEN1P_A: PJP591.2 PR5801.2
VRM_ISEN2_N_A: PR5803.1 PU581.7(ISEN2N)
VRM_ISEN2_P_A: PC5803.1 PR5802.1 PR5880.1 PU581.6(ISEN2P)
VRM_ISEN2N_A: PC5803.2 PC5804.1 PJP594.2 PR5802.2 PR5803.2
VRM_ISEN2P_A: PJP593.2 PR5880.2
VRM_ISEN3_N_A: PR5805.1 PU581.3(ISEN3N)
VRM_ISEN3_P_A: PC5805.1 PR5804.1 PR5881.1 PU581.2(ISEN3P)
VRM_ISEN3N_A: PC5805.2 PC5806.1 PJP10.2 PR5804.2 PR5805.2
VRM_ISEN3P_A: PJP9.2 PR5881.2
VRM_ISEN4_N_A: PR5815.1 PR5878.1 PU581.8(ISEN4N)
VRM_ISEN4_P_A: PC5811.1 PR5806.1 PR5814.1 PR5878.2 PR5882.1 PU581.9(ISEN4P)
VRM_ISEN4N_A: PC5811.2 PC5812.1 PJP12.2 PR5814.2 PR5815.2
VRM_ISEN4P_A: PJP11.2 PR5882.2
VRM_PWM1_A: PU581.52(PWM1) PU591.2(PWM)
VRM_PWM1_BOT_C: PR5901.1 PU591.1(BOOT)
VRM_PWM1_BOTR_C: PC5901.1 PR5901.2
VRM_PWM1_HG_D: PR5903.1 PU591.8(UGATE)
VRM_PWM1_HGR_D: PC5902.1 PQ591.4(G) PR5903.2 PR5904.2
VRM_PWM1_LG_D: PC5907.1 PC5908.1 PQ592.4(G) PQ593.4(G) PR5906.2 PU591.5(LGATE)
VRM_PWM1_SN: PC5906.1 PR5905.2
VRM_PWM1_SW_C: PC5901.2 PC5902.2 PC5905.1 PJP591.1 PL591.1 PQ591.1(S_1) PQ591.2(S_2) PQ591.3(S_3) PQ592.5(D) PQ592.6(D_1) PQ592.7(D_2) PQ592.8(D_3) PQ592.9(D_4) PQ592.10(D_5) PQ592.11(D_6) PQ592.12(D_7) PQ592.13(D_8) PQ592.14(D_9) PQ593.5(D) PQ593.6(D_1) PQ593.7(D_2) PQ593.8(D_3) PQ593.9(D_4) PQ593.10(D_5) PQ593.11(D_6) PQ593.12(D_7) PQ593.13(D_8) PQ593.14(D_9) PR5904.1 PR5905.1 PU591.7(PHASE)
VRM_PWM1_VCC_C: PC5903.1 PC640684.1 PR5902.2 PU591.4(VCC)
VRM_PWM2_A: PU581.51(PWM2) PU592.2(PWM)
VRM_PWM2_BOT_C: PR5911.1 PU592.1(BOOT)
VRM_PWM2_BOTR_C: PC5915.1 PR5911.2
VRM_PWM2_HG_D: PR5910.1 PU592.8(UGATE)
VRM_PWM2_HGR_D: PC5911.1 PQ594.4(G) PR5908.2 PR5910.2
VRM_PWM2_LG_D: PC5912.1 PC5913.1 PQ595.4(G) PQ596.4(G) PR5912.2 PU592.5(LGATE)
VRM_PWM2_SN: PC5910.1 PR5913.2
VRM_PWM2_SW_C: PC5909.1 PC5911.2 PC5915.2 PJP593.1 PL592.1 PQ594.1(S_1) PQ594.2(S_2) PQ594.3(S_3) PQ595.5(D) PQ595.6(D_1) PQ595.7(D_2) PQ595.8(D_3) PQ595.9(D_4) PQ595.10(D_5) PQ595.11(D_6) PQ595.12(D_7) PQ595.13(D_8) PQ595.14(D_9) PQ596.5(D) PQ596.6(D_1) PQ596.7(D_2) PQ596.8(D_3) PQ596.9(D_4) PQ596.10(D_5) PQ596.11(D_6) PQ596.12(D_7) PQ596.13(D_8) PQ596.14(D_9) PR5908.1 PR5913.1 PU592.7(PHASE)
VRM_PWM2_VCC_C: PC5916.1 PC640685.1 PR5909.2 PU592.4(VCC)
VRM_PWM3_A: PU581.53(PWM3) PU601.2(PWM)
VRM_PWM3_BOT_C: PR604.1 PU601.1(BOOT)
VRM_PWM3_BOTR_C: PC607.1 PR604.2
VRM_PWM3_HG_D: PR603.1 PU601.8(UGATE)
VRM_PWM3_HGR_D: PC603.1 PQ601.4(G) PR601.2 PR603.2
VRM_PWM3_LG_D: PC604.1 PC605.1 PQ602.4(G) PQ603.4(G) PR605.2 PU601.5(LGATE)
VRM_PWM3_SN: PC602.1 PR606.2
VRM_PWM3_SW_C: PC601.1 PC603.2 PC607.2 PJP9.1 PL601.1 PQ601.1(S_1) PQ601.2(S_2) PQ601.3(S_3) PQ602.5(D) PQ602.6(D_1) PQ602.7(D_2) PQ602.8(D_3) PQ602.9(D_4) PQ602.10(D_5) PQ602.11(D_6) PQ602.12(D_7) PQ602.13(D_8) PQ602.14(D_9) PQ603.5(D) PQ603.6(D_1) PQ603.7(D_2) PQ603.8(D_3) PQ603.9(D_4) PQ603.10(D_5) PQ603.11(D_6) PQ603.12(D_7) PQ603.13(D_8) PQ603.14(D_9) PR601.1 PR606.1 PU601.7(PHASE)
VRM_PWM3_VCC_C: PC608.1 PC640687.1 PR602.2 PU601.4(VCC)
VRM_PWM4_A: PR5879.2 PU602.2(PWM)
VRM_PWM4_BOT_C: PR611.1 PU602.1(BOOT)
VRM_PWM4_BOTR_C: PC615.1 PR611.2
VRM_PWM4_HG_D: PR610.1 PU602.8(UGATE)
VRM_PWM4_HGR_D: PC611.1 PQ604.4(G) PR608.2 PR610.2
VRM_PWM4_LG_D: PC612.1 PC613.1 PQ605.4(G) PQ606.4(G) PR612.2 PU602.5(LGATE)
VRM_PWM4_SN: PC610.1 PR613.2
VRM_PWM4_SW_C: PC609.1 PC611.2 PC615.2 PJP11.1 PL602.1 PQ604.1(S_1) PQ604.2(S_2) PQ604.3(S_3) PQ605.5(D) PQ605.6(D_1) PQ605.7(D_2) PQ605.8(D_3) PQ605.9(D_4) PQ605.10(D_5) PQ605.11(D_6) PQ605.12(D_7) PQ605.13(D_8) PQ605.14(D_9) PQ606.5(D) PQ606.6(D_1) PQ606.7(D_2) PQ606.8(D_3) PQ606.9(D_4) PQ606.10(D_5) PQ606.11(D_6) PQ606.12(D_7) PQ606.13(D_8) PQ606.14(D_9) PR608.1 PR613.1 PU602.7(PHASE)
VRM_PWM4_VCC_C: PC616.1 PC640688.1 PR609.2 PU602.4(VCC)
VRM_SET1_A: PR5842.2 PR5843.2 PU581.14(SET1)
VRM_SET1_R1_A: PR5836.2 PR5842.1
VRM_SET1_R2_A: PR5824.2 PR5843.1
VRM_SET2_A: PR5825.2 PR5827.2 PU581.15(SET2)
VRM_SET2_R1_A: PR5825.1 PR5826.2
VRM_SET2_R2_A: PR5827.1 PR5837.2
VRM_SET3_A: PR5829.2 PR5831.2 PU581.17(SET3)
VRM_SET3_R1_A: PR5828.2 PR5829.1
VRM_SET3_R2_A: PR5830.2 PR5831.1
VRM_TON_A: PJP595.1 PR5852.2
VRM_TONSET_A: PR5853.2 PU581.55(TONSET)
VRM_TONSET_R_A: PC5825.2 PR5852.1 PR5853.1
VRM_TSEN_A: PR5871.2 PR5874.2 PU581.1(TSEN)
VRM_TSEN_R1_A: PR5874.1 PRT583.2
VRM_VCC_B: PC5829.1 PR5876.2 PU581.29(VCC)
VRM_VCLK: PR5820.1 PU581.26(VCLK)
VRM_VDIO: PR5819.1 PU581.25(VDIO)
VRM_VR_RDY_A: PC5813.1 PQ9777.1(GATE) PR5816.2 PU581.54(PGOOD) Q5.5(GATE) U104.109((MB_REG_PG)GP057)
VRM_VR_RDY_A_LED: CR25.2(CATHODE) Q5.3(DRAIN)
VRM_VREF_A: PR5826.1 PR5828.1 PR5832.1 PR5836.1 PR5839.1 PR5857.1 PR5862.1 PR5864.1 PRT581.1 PRT582.1 PU581.21(VREF)
VRM_VREF_F: PC5827.1 PR5857.2
VRM_VRHOT#: PR5822.2 PU581.23(VR_HOT#)
VRM_VSEN_A: PC5817.1 PC5818.1 PC5819.1 PR5844.2 PR5845.1 PU581.12(VSEN)
VRP: ACE3.1 AU1.37(VRP)
VTT_DDR_EN: PC486.1 PQ80.1(GATE) PQ115.3(COLLECTOR) PR432.2
VTT_DDR_VCNTL: PC484.1 PR123.2 PU80.6(VCNTL)
WAKE#: ASR7.1 M2R4.2 M2R34.1 PCH.BE9(WAKE#) SC174.1 SLOT1.B11(WAKE#) SLOT2.B11(WAKE#) SLOT3.B11(WAKE#) SLOT4.B11(WAKE#) SR363.2
WIFI_ON/OFF#: J60.56(W_DISABLE#1(O)(0/3.3V)) SR713.2
WLAN_PRST#: M2R54.2 PCH.AY29(GPP_H6/SRCCLKREQ12#) SR678.2
WLAN_PRST_R: J60.53(CLKREQ0#(IO)(0/3.3V)) M2R54.1
WLAN_RXN1: J60.43(PERN0) PCH.L17(PCIE3_RXN/USB3_9_RXN)
WLAN_RXP1: J60.41(PERP0) PCH.K17(PCIE3_RXP/USB3_9_RXP)
WLAN_TXN1: M2C41.2 PCH.B20(PCIE3_TXN/USB3_9_TXN)
WLAN_TXP1: M2C40.2 PCH.C20(PCIE3_TXP/USB3_9_TXP)
XCLK_BIASREF_WSL: PCH.F1(XCLK_BIASREF) SR400.2
XDP2_OBSFN_A0: SR7634.2 XDP2.3(OBSFN_A0)
XDP2_OBSFN_A1: SR154.2 XDP2.5(OBSFN_A1)
XI: U4.51(XI) UC1.1 X1.3
XLINE2_L: AD9.1(ANODE) AL18.1 AQ18.3 AR7.2 AR10.1
XLINE2_R: AD10.1(ANODE) AL17.1 AQ18.6 AR8.2 AR9.1
XMIC2_L: AD12.1(ANODE) AL15.1 AR5.2 AR13.2
XMIC2_L_D: AD1.2(CATHODE2) AR13.1
XMIC2_R: AD11.1(ANODE) AL16.1 AR6.2 AR12.2
XMIC2_R_D: AD1.1(CATHODE1) AR12.1
XMM1_EVENT#: CON_XMM3.78(EVENT_N) D4R1.2
XMM2_EVENT#: CON_XMM1.78(EVENT_N) D4R10.2
XMM3_EVENT#: CON_XMM4.78(EVENT_N) D4R15.2
XMM4_EVENT#: CON_XMM2.78(EVENT_N) D4R24.2
XO: U4.50(XO) UC1.2 X1.1
XSPI_CLK: F3R8.2 F3U1.6(CLK)
XSPI_CS#: E16.4 F3CB1.1 F3R4.2 F3U1.1(CS#)
XSPI_IO2: F3R21.2 F3U1.3(WP#(IO2))
XSPI_IO3: F3R6.1 F3R14.2 F3U1.7(HOLD#/RESET#(IO3))
XSPI_MISO: F3R20.2 F3U1.2(DO(IO1))
XSPI_MOSI: F3R7.2 F3U1.5(DI(IO0))
XTAL_24M_PCH_IN: PCH.E1(XTAL24_IN) SC9.1 SR59.2 SR747.1
XTAL_24M_PCH_OUT: PCH.A5(XTAL24_OUT) SC8.1 SR59.1 Y18.1
Y18_R: SR747.2 Y18.3
N22229907: AC198.1 AQ14.2(EMITTER) AR56.2 AR57.1
N22229995: AC71.1 AR1.2 AR55.1
N22236315: J60.17(MLDIRSENSE(I)) M2R39.1
N22238618: D20.1(ANODE1) SC100.1 SC168.1 SR758.1 SR759.2
N22821452: PCH.AC43(GPP_F18/USB_OC7#) SR129.2
N22824353: PCH.BD15(GPP_A12/BMBUSY#/ISH_GP6/SX_EXIT) SR746.2 SR7656.2
N22834018: PCH.BF9(INTRUDER#) SR364.2
N22999854: HT34.1 XU1.AC40(DDR0_VREF_DQ)
N23001600: HR630.2 XU1.U2(VCCST_PWRGD)
N23059953: SR44.1 Y5.1
N23556498: M2R34.2 SS4.54(PEWAKE#)
N23953325: PCH.BB1(HDA_SDI1) ST128.1
N24344620: PCH.AU19(TP2) ST37.1
N24344621: PCH.AP17(TP1) ST36.1
N27023811: J125.14(CONFIG2) M1R37.1
N27303827: PR5812.1 PU581.49(ENDRV)
N27304232: PR5879.1 PU581.50(PWM4)
N27340129: MQ20.6(DRAIN) R37456.2
N27340146: MQ19.6(DRAIN) R60375.2
N27340213: R60375.1 R60381.1 R69583.1 U942691.16(ILIM_HI)
N27340226: R60374.1 U942691.15(ILIM_LO)
N27340366: R60373.1 U51.15(ILIM_LO)
N27340446: R37456.1 R60385.1 R69584.1 U51.16(ILIM_HI)
N27396902: F3U2.3(WP#) UR195.2
N27412583: PC6805.1 PD1.2(CATHODE) PD2.2(CATHODE) PU681.3(VIN)
N27474150: FD10.1(ANODE1) FR32.2 P70.4
N27670481: AC193.1 P189.3 SR7767.2
N27670502: P189.5 UCB18.1 UF5.2
N27670584: AD23.1(ANODE) P189.7 UCB26.1 UF7.2
N27702633: D4CB87.2 D4R35.2
N28010235: ASR7.2 U4.25(PE_WAKE#)
N30179390: AC186.2 AR228.1
N30429432: PC6501.1 PC6502.1 PCE651.1 PL1.1 PQ651.5(D) PQ651.6(D_1) PQ651.7(D_2) PQ651.8(D_3) PQ651.9(D_4) PQ651.10(D_5) PQ651.11(D_6) PQ651.12(D_7) PQ651.13(D_8) PQ651.14(D_9)
N31341317: H5.1(GND1) H5.2(GND2) H5.3(GND3) H5.4(GND4) H5.5(GND5) H5.6(GND6) H5.7(GND7) H5.8(GND8) P17.1 SR7781.1
N31343191: SR7642.2 XDP2.21(OBSFN_B0)
N31343435: SR7643.2 XDP2.23(OBSFN_B1)
N31617893: SR839.2 U104.13(GP117)
N31617918: OR57.2 U104.72(GP040/SMB_DAT1)
N31617920: OR56.2 U104.70(GP036/SMB_CLK1)
N31618104: ECR104.1 U104.36(PROCHOT_IN#/PROCHOT_OUT#/GP016)
N31618424: OR29.2 U104.126((SLP_M#)GP071/IO_SMI#)
N31618460: ECR67.2 U104.127(SER_IRQ)
N31618714: ECR96.2 U104.68(SUS_WARN#/GP004)
N31619395: OR22.1 U104.119(GP064/A20M)
N31775606: O2Q6.5 O2R3.1 O2R8.1
N31775611: O2Q6.2 O2Q6.3 O2R11.2
N31776343: O2R21.2 PQ9779.1(BASE)
N31824604: PC126.1 PR6610.1 PU7.5(EN)
N32020546: PC661.1 PR6611.2
N32093772: P150.1 UR69747.1
N32303663: P189.1 SR7660.2 SR7776.2 UCB27.1
N32303673: P189.2 SR7659.2 SR7777.2 UCB28.1
N32361839: P216.2 SR7788.1
N32362081: P215.2 SR7787.1
N32532704: P189.6 UCB19.1 UF6.2
N33174972: PQ11.5(GATE) PQ11.6(DRAIN) SR8.2
N33732994: OR59.1 U104.50((FP_CBL_DET#)GP025)
N34397341: D4CB86.2 D4R31.2
N35057076: SLOT3.B5(SMCLK) SR7682.1
N35057079: SLOT3.B6(SMDAT) SR7683.1
N35057128: SLOT2.B5(SMCLK) SR7684.1
N35057131: SLOT2.B6(SMDAT) SR7685.1
N35113534: AC196.1 P189.12 SR7768.2 UCR43.2
N35259136: SLOT4.B5(SMCLK) SR7686.1
N35259139: SLOT4.B6(SMDAT) SR7687.1
N35259888: SLOT1.B5(SMCLK) SR7688.1
N35259890: SLOT1.B6(SMDAT) SR7689.1
N36162932: MQ4.1(GATE) SR628.2 SR629.1 VCB155.1
N36226705: PC642.1 PR70298.2 PU681.2(EN)
N37223886: SR7691.1 XDP2.48(HOOK7/DBR#)
N37417388: MQ19.3(DRAIN) R69583.2
N37417652: MQ20.3(DRAIN) R69584.2
N39243785: CB4113.1 UR69710.1 UU50.4(EN/EN#)
N39829666: M2R45.2 SS4.10(DAS/DSS#)
N40204150: PCH.BE26(GPP_B18/GSPI0_MOSI) SR650.2
N40660278: AR237.2 U5.1(I_SEL0/MUX_EN#)
N40660280: AR238.2 U5.8(I_SEL1/MUX_SEL)
N40692911: HR627.2 PCH.AP29(RSVD_17)
N40953271: MQ29.3(DRAIN) PC15.1 PR115.2 PR124.2 PU5.1(EN)
N40953285: M1R40.2 MQ29.5(GATE) MQ29.6(DRAIN) PC152.1
N40953629: ECC55.1 ECQ13.1(BASE) ECR92.2
N41238615: PR249.1 SR75.2
N41891685: HR629.2 PCH.AU22(RSVD_14)
N41919364: SR7622.1 XDP2.1(GND1)
N42989797: FR36.1 P458.4
N43045291: HR631.1 XU1.AC38(SKTOCC#)
N43118664: AQ23.1(BASE) AR263.2
N43303512: UCR30.2 Y19.3
N43568527: SLOT3.B12(RSVD2) SR7780.1
N43669288: U15.26(PB13) UCR36.1
N43846197: P24.8 UR69748.1
N44468919: UC2.3(WP#) UCR25.2
N44790831: U15.33(PA12) UCR46.1
N44790838: U15.32(PA11) UCR47.1
N44794326: FR37.2 P_HDDFAN.3
N4299213519: ST76.1 U4.11(UART_TX)
N4299213520: ST77.1 U4.10(UART_RX)

Pads without a net: AU1 2 4 18 19 20 31 33; BUMPER1 1; BUMPER2 1; BUMPER3 1; BUMPER4 1; CON4 14 20; CON_XMM1 1 8 19 30 41 47 49 52 54 56 93 100 111 122 133 144 145 192 194 196 197 199 201 205 227 230 234 235 237; CON_XMM2 1 8 19 30 41 47 49 52 54 56 93 100 111 122 133 144 145 192 194 196 197 199 201 205 227 230 234 235 237; CON_XMM3 1 8 19 30 41 47 49 52 54 56 93 100 111 122 133 144 145 192 194 196 197 199 201 205 227 230 234 235 237; CON_XMM4 1 8 19 30 41 47 49 52 54 56 93 100 111 122 133 144 145 192 194 196 197 199 201 205 227 230 234 235 237; E16 1 2; J60 6 16 19 20 21 22 25 26 27 28 31 32 34 38 40 42 44 46 48 59 61 62 64 65 66 67 68 70 71 73; J_TYPEC A8 B8; NOREF#25 1; NOREF#37 1; NOREF#52 1; NOREF#70 1; NOREF#71 1; NOREF#72 1; P61 8 9; P62 8 9; P63 8 9; P64 8 9; P118 5 7 13 14; P217 3; P_HDDFAN 2; PCH AA5 AB44 AB45 AC13 AC35 AC36 AC39 AC41 AE30 AE39 AE42 AE43 AE44 AF17 AF44 AF45 AG17 AH14 AH16 AH35 AH36 AH39 AH43 AK36 AK38 AK44 AL44 AL45 AM35 AM36 AM38 AM43 AN43 AN44 AP24 AP36 AP38 AP41 AP42 AP43 AP44 AR17 AT5 AT8 AT38 AT39 AT41 AT44 AT45 AU2 AU4 AU27 AU31 AU42 AU43 AU44 AV7 AV19 AV22 AV29 AV31 AV39 AV43 AV44 AW2 AW5 AW42 AW43 AY22 AY24 AY27 AY31 AY44 BA6 BA15 BA24 BA27 BA33 BA35 BA39 BA44 BA45 BB7 BB45 BC17 BC45 BD19 BD29 BD31 BD33 BD36 BE17 BE18 BE19 BE23 BE31 BE32 BE33 BE36 BF1 BF18 BF19 BF21 BF22 BF24 BF25 BF31 BF32 BF34 BF36 BF37 BF39 BG2 BG16 BG21 BG25 BG34 BG39 K5 K7 K43 K44 L43 L44 M5 M7 M33 N29 N33 N44 N45 P2 P3 P24 P27 P29 P43 P44 R2 R3 R43 T2 T3 T11 T13 T24 T27 T33 T35 T39 T41 T43 U44 U45 V5 V7 V11 V13 V35 V36 V39 V41 V42 V43 W44 Y7 Y36 Y39 Y41 Y43 Y44; PQ46 5; PU7 7; PU581 30 48; PU591 3; PU592 3; PU601 3; PU602 3; PU611 3; PU612 3; PU681 1 5; SLOT1 A7 A19 A32 A33 A50 A52 A53 A56 A57 A60 A61 A64 A65 A68 A69 A72 A73 A76 A77 A80 A81 B12 B30 B50 B51 B54 B55 B58 B59 B62 B63 B66 B67 B70 B71 B74 B75 B78 B79 B82; SLOT2 A7 A19 A32 B12 B30; SLOT3 A7 A19 A32 B30; SLOT4 A7 A19 A32 A33 A50 A52 A53 A56 A57 A60 A61 A64 A65 A68 A69 A72 A73 A76 A77 A80 A81 B12 B30 B50 B51 B54 B55 B58 B59 B62 B63 B66 B67 B70 B71 B74 B75 B78 B79 B82; SS4 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; U4 3 13 14 16 17 26 27 60 61 63 64; U5 26 27 28; U10 24 25 26 28 40; U15 2 3 4 10 11 12 13 18 19 28 38 40 45 46; U104 5 6 56 61 62 63 64 73 78 79 80 81 84 85 91 105 107 110 112; UU52 1 2 9 10; XDP2 45; XU1 A12 A18 A23 AB35 AB37 AB38 AC37 AJ22 AL25 AL26 AM25 AM26 AN25 AN26 AP25 AP26 AR25 AR26 AT33 AU9 AU10 AU31 AU32 AU33 AV1 AV31 AV32 AV33 AW2 AW31 AW33 AY31 B12 B13 B18 B23 B39 C9 C13 C19 C21 C23 C40 D9 D10 D12 D14 D15 D18 D19 D20 D21 D22 D23 E10 E12 E18 E20 E22 F9 G9 G10 G14 H8 H10 H14 J7 J8 J11 J13 J14 J15 J17 J19 K8 K10 K11 K12 K13 L10 L12; Y5 2 3

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 5681 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 868 vias
v3: diameter 0.762, hole 0.457, TOP to BOTTOM, 689 vias
v4: diameter 0.61, hole 0.305, TOP to BOTTOM, 3 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 129 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1VSB_POWERIN: length 120.5
  TOP w0.102: v1(213.44,38.35) 213.23,38.15 209.75,38.15 209.34,38.57 U104.95 ; PR70249.1 216.83,142.52 v1(216.83,142.09) ; v1(210.24,59.36) 210.24,72.83 213.92,76.51 213.92,88.23 212.64,89.52 212.64,91.12 212.44,91.31 212.44,91.59 v1(211.86,92.18)
  BOTTOM w0.102: v1(210.24,59.36) 209.91,59.03 209.91,57.48 210.45,56.94 210.45,53.02 211.84,51.64 211.84,48.04 213.44,46.44 v1(213.44,38.35) ; v1(216.83,142.09) 218.81,140.11 218.81,134.52 218.19,133.89 217.12,132.83 217.12,132.28 v2(217.68,131.72) 217.68,129.56 217.16,129.04 217.16,127.08 217.88,126.36 217.88,125.2 217.53,124.85 217.53,112.42 215,109.89 215,106.36 215.9,105.47 215.9,103.02 215.32,102.44 215.32,99.48 212.84,97.01 212.84,94.44 211.86,93.45 v1(211.86,92.18)
3VA_ADJ_A: length 6.5
  TOP w0.254: v1(229.62,180.92) 229.25,181.29 PQ33.1 229.25,183.81 229.32,183.88 PC241.1 228.85,184.53 228.77,184.62 PR193.1 227.93,184.62 227.84,184.53 PR192.1
  BOTTOM w0.254: v2(229.62,180.14) v1(229.62,180.92)
3VA_ADJ_C_A: length 16.8
  TOP w0.254: v1(226.59,182.89) 226.66,182.96 PR192.2 ; PJP20.1 v1(225.03,169.24)
  BOTTOM w0.254: v1(226.59,182.89) 226.54,182.84 v2(226.54,181.2) 226.54,172.01 225.03,170.5 v1(225.03,169.24)
3VA_ADJ_R_A: length 2.3
  TOP w0.254: PR193.2 227.98,185.46 227.97,185.45 PR194.2 v1(227.5,186.13)
  BOTTOM w0.102: v2(227.5,185.34) v1(227.5,186.13)
5V_PRSENT: length 11.2
  TOP w0.102: RN25.7 205.17,37.94 v1(205.51,38.27) 205.85,38.27 206.48,37.64 U104.100 ; PQ9779.3 v1(205.03,43.05)
  BOTTOM w0.102: v1(205.51,38.27) 205.52,38.26 206.13,38.26 207.47,39.6 207.47,41.05 205.97,42.55 v2(205.69,42.55) 205.54,42.55 v1(205.03,43.05)
5VDUAL_EN: length 207.5
  TOP w0.102: v1(218.62,100.46) 218.32,100.16 218.32,99.63 219.29,98.65 219.3,98.65 222.75,95.2 222.75,90.21 220.12,87.57 220.12,79.29 223.64,75.77 223.64,70.39 214.05,60.8 214.05,55.3 v1(213.56,54.81) ; PR196.1 232.78,215.73 233.15,215.37 v1(233.15,215.32) ; U104.67 220.54,39.01 219.99,38.46 219.04,38.46 v1(219.01,38.43)
  BOTTOM w0.102: v1(233.15,215.32) 233.15,215.2 233.59,214.76 233.59,214.35 233.17,213.93 232.01,213.93 230.66,212.58 230.66,204.13 229.78,203.25 229.78,191.59 227.55,189.36 227.55,187.75 228.35,186.95 228.35,185.8 228.42,185.73 228.42,184.96 228.32,184.86 228.32,176.24 228.41,176.15 228.41,167.07 226.89,165.54 226.89,150.4 230.67,146.62 230.67,142.05 230.29,141.67 230.29,134.91 v2(229.39,134.01) 228.56,134.01 221.35,126.8 221.35,126.39 223.06,124.68 223.06,121.14 220.43,118.52 220.43,111.47 220.88,111.02 220.88,107.87 218.88,105.88 218.88,100.72 v1(218.62,100.46) ; v1(219.01,38.43) 219.43,38.85 219.43,43.5 219.8,43.86 219.8,47.24 215.57,51.47 214.13,51.47 212.95,52.65 212.95,54.2 v1(213.56,54.81)
+1V_DCPDSW: length 18.6
  TOP w0.203: v1(173.33,41.73) 173.72,41.34 PCH.BC29
  TOP w0.305: SCB122.1 SCB19.1 185.17,34.24 182.49,36.92 v1(178.88,36.92)
  BOTTOM w0.305: v1(173.33,41.73) 173.61,41.45 173.61,41.01 174.51,40.11 v2(174.51,38.99) 174.51,38.67 176.26,36.92 v1(178.88,36.92)
+1V_ST: length 624.4
  TOP w0.152: XU1.V4 122.18,144.74 122.18,144.18 121.92,143.93 121.73,143.93 121.24,143.44 121.24,142.18 121.33,142.09 121.33,141.39 120.93,141
  TOP w0.203: v1(220.17,23.19) 220.24,23.11 O2CB10.1 220.65,22.8 220.65,23.44 220.14,23.95 U104.29 ; XU1.V4 XU1.V5 XU1.V6 ; v1(201.8,18.26) 201.98,18.08 201.98,13.61 202.63,12.96 204.2,12.96 v1(204.87,12.29)
  TOP w0.254: v1(89.98,223.98) 90.14,223.81 PC5814.1 ; v1(99.95,124.1) 99.85,124 99.85,122.11 HR23.1 100.52,121.44 100.52,120.67 100.83,120.36 HR25.2 ; v1(79.48,119.82) 78.33,120.96 v1(78.33,126.16) 80.82,126.16 85.14,130.48 95.78,130.48 99.65,130.48 v1(99.95,130.78) ; PC5814.1 90.14,222.12 90.41,221.86 91.37,221.86 92.08,221.16 92.08,220.37 95.96,216.48 v1(97.38,216.48) ; PC5814.1 PR5823.1 ; v1(101.6,135.64) 101.6,137.26 100.32,138.54 HR9.1 98.17,138.54 97.42,139.3 97.42,139.75 98.01,140.33 HR11.1 ; OR3.1 223.44,21.41 222.99,20.95 221.68,20.95 220.69,19.96 v1(219.63,19.96) ; v1(88.11,205.79) 86.28,205.79 v1(82.96,202.46) ; OR52.1 208.32,48.73 v1(208.53,48.51) ; v1(72.59,146.56) 72.59,140.69 73.63,139.65 v1(77.19,139.65) ; v1(132.13,90.17) 131.88,89.92 96.95,89.92 95.22,91.64 86.83,91.64 77.38,101.09 v1(77.38,102.92) ; v1(82.55,118.36) 82.35,118.16 v1(82.35,112.22) ; v1(203.57,22.97) 202.91,23.64 202.4,23.64 201.17,24.86 201.17,32.62 201.76,33.22 201.76,42.07 v1(202.08,42.39) ; v1(97.38,209.85) 93.93,209.85 v1(93.34,210.44) ; v1(144.48,41.66) 144.84,42.02 SR289.1 SR292.1 149.28,42.43 151.23,42.43 SR287.1 ; v1(90.65,209.63) 90.53,209.5 HR33.1 ; v1(89.61,225.35) 89.17,225.35 PR5817.1 PR5818.1 PR5821.1 ; HR32.1 HR24.1 92.46,209.6 v1(92.43,209.63) ; v1(137.44,36.35) 137.44,32.99 144.68,25.75 145.84,25.75 156.17,15.42 v1(156.17,13.77)
  TOP w0.381: 120.93,141 120.65,140.72 120.65,140.31 119.51,139.17 119.51,119.76 120.78,118.49 126.89,118.49 127.27,118.87 127.86,118.87 128.17,118.57 128.17,117.14 128.58,116.73 HC4.1
  TOP w0.508: v1(133.53,85.37) 133.53,79.84 123.27,69.58 116.72,69.58 108.74,61.61 108.74,53.37 113.66,48.45 118.94,48.45 120.45,46.94 120.45,45.58 121.92,44.11 122.79,44.11 127.56,39.34 v1(127.56,35.33) ; v1(127.76,111.89) 126.77,111.89 126.28,112.38 PQ60.2 127.33,114.43 129.13,114.43 129.57,114.86 PR340.2 130.43,114.86 131.17,115.6 HC3.1 PC272.1 129.01,116.73 HC4.1
  BOTTOM w0.203: v1(219.63,19.96) 219.84,20.17 219.84,22.15 220.17,22.48 v1(220.17,23.19) 219.74,22.76 216.17,22.76 214.95,21.54 212.87,21.54 209.98,18.64 209.98,15.38 208.67,14.07 208.17,14.07 206.38,12.29 v1(204.87,12.29) 200.14,12.29 199.6,12.83 196.98,12.83 196.42,13.4 184.12,13.4 183.32,12.6 182.54,12.6 179.93,12.6 175.55,12.6 175.28,12.6 174.98,12.31 174.54,12.31 172.92,10.69 170.68,10.69 167.7,7.71 162.23,7.71 v1(156.17,13.77)
  BOTTOM w0.254: v1(144.48,41.66) 144.42,41.66 141.76,38.99 140.15,38.99 138.64,37.47 138.64,36.97 138.01,36.35 v1(137.44,36.35) ; v1(78.33,126.16) 78.64,126.47 78.64,138.2 v1(77.19,139.65) ; v1(97.38,216.48) v1(97.38,209.85) ; v1(88.11,205.79) 88.11,207.09 v1(90.65,209.63) v1(92.43,209.63) 92.53,209.63 v1(93.34,210.44) ; v1(82.55,118.36) 81.79,118.36 80.33,119.82 v1(79.48,119.82) ; v1(82.96,202.46) 83.07,202.35 83.07,183.71 80.82,181.46 80.82,177.77 78.79,175.74 78.79,158.62 74.85,154.69 74.85,148.74 72.67,146.56 v1(72.59,146.56) ; v1(77.38,102.92) 80.91,106.45 80.91,109.03 82.35,110.46 v1(82.35,112.22) ; v1(99.95,124.1) v1(99.95,130.78) 99.95,133.99 v1(101.6,135.64) ; v1(203.57,22.97) 203.88,22.66 203.88,20.34 v1(201.8,18.26) ; v1(89.98,223.98) 89.61,224.35 v1(89.61,225.35) ; v1(208.53,48.51) 205.56,45.54 204.34,45.54 202.08,43.28 v1(202.08,42.39)
  BOTTOM w0.508: v1(133.53,85.37) 132.6,85.37 131.81,86.16 131.81,88.87 132.13,89.19 v1(132.13,90.17) v2(132.13,91.21) 132.13,93.33 134.91,96.11 134.91,106.9 129.93,111.89 v1(127.76,111.89) ; v1(137.44,36.35) 130.51,36.35 129.49,35.33 v1(127.56,35.33)
+1VSB: length 251.2
  TOP w0.203: PCH.AA23 v1(170.43,52.6) ; v1(162.34,46.24) PCH.AM5 PCH.AK5
  TOP w0.254: SR165.1 96.62,100.44 v1(96.62,99.26) ; XDP2.44 92.61,103.15 92.61,102.95 93.66,101.89 ; v1(168.49,45.94) 168.49,45.59 PCH.AR19
  TOP w0.279: SR165.1 95.17,101.89 93.66,101.89 ; XDP2.43 86.46,109.3
  TOP w0.457: 147.78,65.94 146.88,65.04 SR400.1 146.19,65.04 145.87,64.72 v1(145.87,64.29)
  TOP w0.508: SCB8.1 187.91,60.2 v1(187.49,59.78) ; v3(196.67,61.32) 195.83,61.32 195.56,61.04 SR43.1 ; v1(154.53,87.43) 154.53,85.44 154.05,84.96 154.05,81.25 149.99,77.19 149.99,67.03 148.89,65.94 147.78,65.94 ; SCB9.1 188.96,55.61 188.69,55.34 SCB11.1 188.02,55.24 v1(187.38,55.24) ; 86.46,109.3 85.05,110.71 v1(83.72,110.71) ; SCB16.1 v1(200.22,59.64) ; v1(130.68,112.19) 131.47,112.98 PC273.1 PR340.1 129.68,112.87 PQ60.3 ; v1(142.32,62.08) 142.32,60.15 v1(145.14,57.33) 145.8,56.67 SR411.1 ; v1(78.14,102.95) 78.14,101.16 82.55,96.75 82.8,96.75 v1(83.39,96.16) 87.41,92.14 95.43,92.14 97.15,90.41 130.67,90.41 131.1,90.84 132.54,90.84 v1(132.96,90.42) 133.65,90.42 133.99,90.75 137.63,90.75 v1(141.36,94.49) ; SR49.1 197.85,69.22
  TOP w0.635: 198.1,75.23 PCE18.1 ; PCE18.1 198.1,73.36 ; PCE18.1 199.04,74.3
  BOTTOM w0.254: 172.75,51.08 172.75,51.04 v1(171.98,50.28) ; v1(162.34,46.24) 162.34,46.06 162.76,45.64 165.46,45.64 166.32,46.51 167.92,46.51 v1(168.49,45.94)
  BOTTOM w0.508: v1(167.16,55.02) 165.98,55.02 164.19,56.81 163.58,56.81 163.03,57.37 161.05,57.37 160.5,56.82 152.08,56.82 151.74,56.48 148.5,56.48 148.36,56.62 145.85,56.62 v1(145.14,57.33) ; v1(132.96,90.42) 132.96,93.27 135.53,95.85 135.53,107.16 130.68,112.01 v1(130.68,112.19) ; v1(145.87,64.29) 143.66,62.08 v1(142.32,62.08) ; v1(83.72,110.71) 81.4,108.39 81.4,106.21 v1(78.14,102.95) ; 171.2,50.11 171.2,51.56 172.24,52.6 v1(172.75,52.6) 172.75,51.08 v1(172.76,51.07) ; v1(96.62,99.26) 96.47,99.11 88.33,99.11 87.52,98.3 85.87,98.3 84.75,97.18 84.75,96.7 84.21,96.16 v1(83.39,96.16) ; v1(154.53,87.43) 154.53,87.42 153.87,86.77 153.08,86.77 151.6,88.24 147.58,88.24 141.36,94.45 v1(141.36,94.49)
  vias: v1(168.24,54.72) v1(169.27,54.39) v1(169.65,47.96) v1(170.43,47.96) v1(171.2,47.96) v3(197.59,61.09) v3(197.71,62) v3(198.8,62.87) v3(199.52,75.56) v3(199.64,74.04) v3(199.69,62.87) v3(200.02,61.62) v3(200.58,62.87) v3(200.66,74.04) v3(200.93,61.62) v3(201.98,61.82)
+1VSB_BOT_C: length 0.7
  BOTTOM w0.254: v2(193.9,93.42) v1(193.17,93.42)
+1VSB_BOTR_C: length 0.7
  BOTTOM w0.254: v2(195.71,93.4) v1(196.42,93.4)
+1VSB_DUAL_IN_CRT_MAIN: length 7.3
  TOP w0.254: Q53.2 Q53.5 215.52,141.22 215.99,141.69 v1(215.99,142.16) 215.85,142.16 215.61,142.41 PR70249.2 215.61,143.47 215.99,143.85 PR70250.2
  BOTTOM w0.254: v2(215.99,141.38) v1(215.99,142.16)
+1VSB_DUAL_IN_CRT_MAIN_R: length 4.8
  TOP w0.254: PR134.1 215.01,142.37 v1(215.14,142.24) 215.14,142.02 214.87,141.76 PR302.2 214.87,140.27 Q53.6
  BOTTOM w0.254: v1(215.14,142.24) 215.39,142.49 v2(215.39,143.31)
+1VSB_DUAL_IN_CRT_MAIN_R3: length 6.3
  TOP w0.254: PR134.2 v1(215.65,144.59) ; v1(217.42,146.05) 217.61,146.24 PR139.1 PC339.1 PQ56.4
  BOTTOM w0.254: v1(217.42,146.05) 217.11,146.05 v2(216.69,145.64) v1(215.65,144.59)
+1VSB_DUAL_IN_CRT_SB_R: length 3.9
  TOP w0.254: v1(216.17,139.23) Q53.3 216.17,137.54 PR305.2 PR135.1
  BOTTOM w0.254: v1(216.17,139.23) 216.18,139.22 v2(216.18,138.4)
+1VSB_DUAL_IN_CRT_SB_R3: length 8.1
  TOP w0.254: PR137.1 214.1,135.39 PR135.2 ; PR137.1 213.37,134.3 PC131.1 ; PR137.1 215.26,135.03 215.94,134.35 PQ54.1 216.27,134.35 216.81,134.9 v1(217.07,134.9)
  BOTTOM w0.102: v2(216.28,134.9) v1(217.07,134.9)
+1VSB_EN_A: length 6.3
  TOP w0.102: v1(188.44,94.49) 188.44,93.04 188.65,92.84 189.4,92.84 PR162.2
  TOP w0.254: PR162.2 PC209.1 190.47,91.47 190.6,91.34 PU9.3
  BOTTOM w0.102: v1(188.44,94.49) 188.89,94.04 v2(188.89,93.87)
+1VSB_FB_A: length 5.1
  TOP w0.254: PU9.4 190.35,90.84 190.34,90.83 v1(190.32,90.83) 189.88,90.83 PR172.1 PC217.2 189.6,89.43 PR175.1
  BOTTOM w0.254: v2(191.49,90.98) 190.49,90.98 190.34,90.83 v1(190.32,90.83)
+1VSB_FB_C_A: length 4.6
  TOP w0.254: v1(188.08,90.8) 188.33,90.55 PR172.2 PC217.1 188.76,89.38 PR173.1
  BOTTOM w0.254: v1(188.08,90.8) 188.58,90.8 189.13,91.35 v2(189.13,91.8)
+1VSB_FB_RC_A: length 20.8
  TOP w0.254: PC218.1 187.43,89.69 v1(187.73,89.38) 188.39,88.72 PR173.2 190.93,86.37 190.93,84.94 192.32,83.56 192.32,77.94 193.65,76.61 195.79,76.61 PJP19.2
  BOTTOM w0.254: v2(187.1,90.02) v1(187.73,89.38)
+1VSB_HG_D: length 13.1
  TOP w0.635: v3(206.25,93.34) 206.25,93.07 PR163.1
  BOTTOM w0.635: v3(206.25,93.34) v2(202.92,93.34) 197.6,93.34 196.44,92.18 v3(194.84,92.18)
+1VSB_HGR_D: length 0.8
  BOTTOM w0.635: v1(205.79,90.47) v2(205.79,91.31)
+1VSB_LG_D: length 22.5
  TOP w0.635: v3(192.02,85.32) 192.02,87.63 192.41,88.01 193.34,88.01 193.95,88.62 193.95,88.98 ; v3(207.9,84.33) 207.65,84.33 PR70291.1
  BOTTOM w0.635: v3(192.02,85.32) 192.9,84.44 v2(200.25,84.44) 205.47,84.44 205.71,84.2 207.77,84.2 v3(207.9,84.33)
+1VSB_LG_SW_D: length 0.7
  BOTTOM w0.102: v2(206.88,85.09) v1(206.14,85.09)
+1VSB_PWRGD: length 9.7
  TOP w0.102: PR170.1 PR167.2 187.13,93.85 186.97,94.02 v1(186.97,94.49) 187.45,94.97 190.55,94.97 191.01,94.51 191.01,92.47 191.13,92.34 PU9.1
  BOTTOM w0.102: v2(186.23,94.49) v1(186.97,94.49)
+1VSB_SN: length 0.7
  BOTTOM w0.508: v1(200.71,82.42) v2(200,82.42)
+1VSB_SW_C: length 6
  TOP w0.635: 196.26,91.35 v3(197.23,91.35) ; 200.53,88.39 199.39,88.39 198.63,89.15 v3(198.63,89.79)
  BOTTOM w0.635: v3(198.63,89.79) v2(197.97,90.45) 197.23,91.19 v3(197.23,91.35)
  vias: v1(194.61,82.58) v1(195.33,82.58) v1(196.11,82.58) v1(196.82,82.55) v1(201.29,88.72) v1(201.96,88.72) v1(206.22,88.11) v1(206.86,88.11)
+1VSB_TRIP: length 1
  BOTTOM w0.508: v1(190.53,93.45) v2(191.54,93.45)
