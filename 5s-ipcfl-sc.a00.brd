# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA2_PCIE3_DET: length 82.2
  TOP w0.102: PCH.AK33 176.33,47.2 v1(176.33,47.14) ; v1(201,46.75) 200.71,46.46 200.71,44.09 199.95,43.33 199.95,30.61 200.23,30.33 200.23,23.7 201.05,22.88 v1(202.94,22.88) ; v1(199.6,17.34) 199.6,11.44 200.84,10.2 v1(200.84,9.25) ; v1(207.77,9.35) M2R1.2 208.55,9.45 209.78,9.45 210.61,10.28 SS4.69
  BOTTOM w0.102: v1(176.33,47.14) 176.78,46.69 178.77,46.69 179.04,46.96 179.04,47.29 179.55,47.8 179.55,48.6 180.08,49.13 183.02,49.13 184.18,47.97 191.81,47.97 192.75,47.04 200.71,47.04 v1(201,46.75) ; v1(200.84,9.25) v2(203.58,9.25) 207.67,9.25 v1(207.77,9.35) ; v1(202.94,22.88) 202.89,22.82 202.89,21.37 199.6,18.08 v1(199.6,17.34)
SATA_RXN0: length 70.6
  TOP w0.102: v1(229.84,60.88) 230.43,61.46 230.95,61.46 TC3.1 ; v1(177.47,58.98) 177.12,59.33 PCH.G35
  BOTTOM w0.102: v1(177.47,58.98) 177.72,59.23 178.69,59.23 179.15,59.69 179.15,62.25 181.92,65.02 182.52,65.02 182.85,65.35 184.27,65.35 185.36,66.44 185.36,68.2 184.63,68.92 184.63,70.35 185.02,70.74 188.62,70.74 190.63,72.75 208.42,72.75 210.68,70.48 213.45,70.48 215.81,68.12 221.99,68.12 228.95,61.16 229.77,61.16 229.84,61.09 v1(229.84,60.88)
SATA_RXN0_C: length 5.1
  TOP w0.102: P61.5 236.17,61.95 235.31,61.95 234.9,61.54 232.52,61.54 TC3.2
SATA_RXN1: length 93.9
  TOP w0.102: PCH.E37 177.92,60.37 178.09,60.54 v1(178.32,60.54) ; TC11.1 231.09,44.46 230.88,44.46 229.62,45.73 229.62,53.47 232.74,56.59 232.74,58.37 v1(233.17,58.8)
  BOTTOM w0.102: v1(233.17,58.8) 232.74,59.24 232.74,60.63 231.55,61.82 231.55,62.09 228.05,65.58 226.98,65.58 222.87,69.7 216.47,69.7 214.1,72.06 211.33,72.06 208.98,74.41 204.21,74.41 201.48,77.14 192.55,77.14 188.79,73.38 184.37,73.38 183.74,72.75 183.74,68.53 184.47,67.81 184.47,66.81 183.9,66.24 182.47,66.24 182.09,65.86 181.53,65.86 178.44,62.76 178.44,60.65 v1(178.32,60.54)
SATA_RXN1_C: length 4.9
  TOP w0.102: TC11.2 232.66,44.46 234.53,44.46 234.81,44.19 236.19,44.19 P62.5
SATA_RXN2: length 94
  TOP w0.102: v1(179.81,59.54) 180.04,59.76 180.04,59.92 PCH.E41 ; TC23.1 230.78,29.55 230.78,29.41 230.67,29.3 230.34,29.3 229.59,30.06 229.59,32.33 231.7,34.45 232.71,34.45 v1(233.15,34.01)
  BOTTOM w0.102: v1(179.81,59.54) 179.81,60 179.93,60.12 180.2,60.12 180.32,60.01 180.32,59.56 180.72,59.16 181.37,59.16 182.84,60.63 182.84,61.28 184.18,62.61 184.71,62.61 187.73,65.63 189.27,65.63 192.86,69.22 207.09,69.22 209.32,66.98 212.1,66.98 214.39,64.69 220.57,64.69 226.52,58.74 226.52,58.31 229.59,55.23 229.59,52.61 231.37,50.84 231.37,37.56 232.46,36.47 232.46,34.51 232.69,34.28 232.88,34.28 v1(233.15,34.01)
SATA_RXN2_C: length 6.5
  TOP w0.102: TC23.2 232.21,29.4 232.89,29.4 235.87,26.42 236.2,26.42 P63.5
SATA_RXN3: length 120.9
  TOP w0.102: v1(181.13,59.79) 180.54,59.79 180.26,60.07 PCH.D42 ; v1(230.6,8.51) 230.7,8.41 230.9,8.41 TC7.1
  BOTTOM w0.102: v1(181.13,59.79) 181.13,60.33 181.5,60.7 181.5,63.74 182.16,64.4 182.86,64.4 183.18,64.72 184.6,64.72 186.04,66.16 186.04,67.93 187.28,69.17 189.57,69.17 191.7,71.3 207.91,71.3 210.18,69.04 212.96,69.04 215.24,66.75 221.42,66.75 228.57,59.6 228.57,59.3 231.65,56.23 231.65,53.47 233.43,51.69 233.43,38.61 235.21,36.82 235.21,25.15 237.74,22.62 237.74,20.57 234.21,17.04 234.21,11.31 231.18,8.28 230.83,8.28 v1(230.6,8.51)
SATA_RXN3_C: length 5.1
  TOP w0.102: TC7.2 232.54,8.42 234.45,8.42 234.65,8.63 236.19,8.63 P64.5
SATA_RXP0: length 70.6
  TOP w0.102: TC4.1 231.06,61.26 230.55,61.26 230.48,61.19 v1(230.48,60.88) ; PCH.E35 177.09,60.07 v1(177.5,59.66)
  BOTTOM w0.102: v1(177.5,59.66) 177.73,59.43 178.6,59.43 178.94,59.77 178.94,62.33 181.84,65.23 182.44,65.23 182.77,65.56 184.19,65.56 185.15,66.53 185.15,68.11 184.43,68.84 184.43,70.43 184.94,70.94 188.54,70.94 190.54,72.95 208.5,72.95 210.76,70.69 213.54,70.69 215.9,68.33 222.07,68.33 229.03,61.37 229.99,61.37 v1(230.48,60.88)
SATA_RXP0_C: length 5.1
  TOP w0.102: TC4.2 232.58,61.34 234.98,61.34 235.39,61.75 236.21,61.75 P61.6
SATA_RXP1: length 93.9
  TOP w0.102: v1(232.53,58.8) 232.53,56.67 229.41,53.55 229.41,45.64 230.8,44.26 231.11,44.26 TC12.1 ; PCH.G37 178.41,59.82 v1(178.41,59.89)
  BOTTOM w0.102: v1(178.41,59.89) 178.74,60.22 178.74,60.71 178.64,60.81 178.64,62.68 181.62,65.66 182.18,65.66 182.56,66.04 183.98,66.04 184.67,66.73 184.67,67.89 183.95,68.61 183.95,72.67 184.46,73.18 188.87,73.18 192.63,76.94 201.4,76.94 204.13,74.21 208.9,74.21 211.25,71.86 214.02,71.86 216.38,69.49 222.78,69.49 226.9,65.38 227.97,65.38 231.34,62 231.34,61.74 232.53,60.55 v1(232.53,58.8)
SATA_RXP1_C: length 4.9
  TOP w0.102: TC12.2 232.64,44.26 234.45,44.26 234.72,43.99 236.19,43.99 P62.6
SATA_RXP2: length 94
  TOP w0.102: PCH.C42 179.88,60.93 v1(179.58,60.63) ; TC24.1 230.73,29.1 230.26,29.1 229.39,29.97 229.39,32.42 231.62,34.65 v1(233.15,34.65)
  BOTTOM w0.102: v1(179.58,60.63) 179.88,60.33 180.29,60.33 180.52,60.09 180.52,59.64 180.8,59.36 181.29,59.36 182.64,60.71 182.64,61.36 184.09,62.81 184.63,62.81 187.65,65.83 189.18,65.83 192.77,69.42 207.17,69.42 209.41,67.18 212.19,67.18 214.47,64.9 220.65,64.9 226.72,58.83 226.72,58.39 229.79,55.32 229.79,52.7 231.57,50.92 231.57,37.64 232.66,36.55 232.66,34.59 232.77,34.48 232.98,34.48 v1(233.15,34.65)
SATA_RXP2_C: length 6.5
  TOP w0.102: P63.6 236.18,26.22 235.78,26.22 232.81,29.19 232.2,29.19 TC24.2
SATA_RXP3: length 121
  TOP w0.102: v1(180.64,60.78) 180.7,60.73 PCH.E43 ; v1(230.6,7.87) 230.86,8.13 231.08,8.13 TC8.1
  BOTTOM w0.102: v1(230.6,7.87) 230.81,8.07 231.26,8.07 234.42,11.23 234.42,16.95 237.95,20.48 237.95,22.71 235.42,25.23 235.42,36.9 233.63,38.69 233.63,51.77 231.85,53.55 231.85,56.31 228.78,59.39 228.78,59.68 221.5,66.95 215.33,66.95 213.04,69.24 210.26,69.24 207.99,71.51 191.62,71.51 189.48,69.37 187.19,69.37 185.84,68.02 185.84,66.24 184.52,64.92 183.1,64.92 182.78,64.6 182.08,64.6 181.3,63.82 181.3,60.78 181.09,60.58 180.85,60.58 v1(180.64,60.78)
SATA_RXP3_C: length 5
  TOP w0.102: TC8.2 232.46,8.22 234.53,8.22 234.74,8.43 236.19,8.43 P64.6
SATA_TXN0: length 71.6
  TOP w0.089: PCH.C36 177.15,61.3 176.99,61.47 176.99,61.61 176.91,61.69 176.91,62.64 177.12,62.86
  TOP w0.102: 177.12,62.86 179.2,64.93 179.2,66.17 180.44,67.41 180.44,68.69 181.53,69.79 183.54,69.79 184.94,71.18 184.94,71.97 v1(184.81,72.1) ; v1(229.01,62.71) 230.04,62.71 230.48,63.15 230.48,64.08 230.69,64.29 231.08,64.29 TC2.1
  BOTTOM w0.102: v1(229.01,62.71) 228.37,62.71 222.27,68.81 216.1,68.81 213.74,71.17 210.96,71.17 208.61,73.52 203.73,73.52 201,76.25 193.09,76.25 188.26,71.42 185.18,71.42 184.96,71.65 184.96,71.94 v1(184.81,72.1)
SATA_TXN0_C: length 5.3
  TOP w0.102: TC2.2 232.63,64.44 234.15,64.44 235.19,65.48 236.29,65.48 P61.3
SATA_TXN1: length 80.3
  TOP w0.102: v1(185.32,70) 185.17,69.85 184.65,69.85 183.9,69.1 181.9,69.1 181.13,68.33 181.13,65.97 177.72,62.57 177.72,62.06 PCH.A37 ; TC10.1 231.17,47.89 230.71,47.89 230.2,48.4 230.2,53.07 231.54,54.41 v1(233.15,54.41)
  BOTTOM w0.102: v1(185.32,70) 185.48,69.84 186.67,69.84 186.91,70.08 189.17,70.08 191.29,72.19 208.28,72.19 210.55,69.93 213.33,69.93 215.61,67.64 221.79,67.64 229.46,59.97 229.46,59.69 232.54,56.62 232.54,54.38 232.68,54.23 232.97,54.23 v1(233.15,54.41)
SATA_TXN1_C: length 4.9
  TOP w0.102: TC10.2 232.64,47.94 235.27,47.94 235.41,47.8 236.19,47.8 P62.3
SATA_TXN2: length 93
  TOP w0.102: TC22.1 230.62,31.17 230.33,31.17 230.07,31.42 230.07,32.11 230.48,32.51 233.15,32.51 v1(233.2,32.56) ; v1(187.57,66.76) 187.34,66.98 187.05,66.98 185.14,65.07 181.19,65.07 178.41,62.3 178.41,61.84 178.46,61.79 178.46,61.44 178.21,61.18 PCH.C38
  BOTTOM w0.102: v1(233.2,32.56) 233.74,32.56 233.84,32.66 233.84,36.16 232.05,37.95 232.05,51.12 230.28,52.9 230.28,55.52 227.2,58.59 227.2,59.03 220.85,65.38 214.68,65.38 212.39,67.67 209.61,67.67 207.37,69.9 192.57,69.9 189.69,67.02 187.83,67.02 v1(187.57,66.76)
SATA_TXN2_C: length 5.7
  TOP w0.102: P63.3 236.19,30.02 233.79,30.02 232.66,31.14 232.15,31.14 TC22.2
SATA_TXN3: length 114.7
  TOP w0.102: TC6.1 231.06,12.43 230.88,12.43 230.63,12.68 230.63,13.46 231.72,14.55 232.79,14.55 v1(232.99,14.76) ; PCH.B39 178.86,61.66 178.97,61.77 178.97,62.15 181.08,64.25 182.29,64.25 v1(182.86,63.68)
  BOTTOM w0.102: v1(232.99,14.76) 233.34,14.76 233.5,14.92 233.5,17.35 237.06,20.9 237.06,22.28 234.53,24.81 234.53,36.49 232.74,38.28 232.74,51.4 230.96,53.18 230.96,55.9 227.89,58.97 227.89,59.31 221.14,66.07 214.96,66.07 212.67,68.35 209.89,68.35 207.66,70.59 192.29,70.59 190.18,68.48 187.56,68.48 186.73,67.64 186.73,65.86 184.08,63.21 183.33,63.21 v1(182.86,63.68)
SATA_TXN3_C: length 4.9
  TOP w0.102: P64.3 236.2,12.23 234.75,12.23 234.57,12.41 232.61,12.41 TC6.2
SATA_TXP0: length 71.6
  TOP w0.089: PCH.B36 177.09,61.76 177.09,62.56 177.23,62.71 177.26,62.71 177.27,62.71
  TOP w0.102: v1(229.01,63.35) 229.13,63.47 229.31,63.47 229.44,63.35 229.44,63.02 229.54,62.92 229.96,62.92 230.28,63.23 230.28,64.16 230.61,64.49 230.92,64.49 TC1.1 ; 177.27,62.71 179.4,64.85 179.4,66.08 180.64,67.33 180.64,68.61 181.62,69.58 183.63,69.58 185.14,71.09 185.14,71.79 v1(185.45,72.1)
  BOTTOM w0.102: v1(229.01,63.35) 228.57,62.92 228.45,62.92 222.36,69.01 216.18,69.01 213.82,71.37 211.05,71.37 208.7,73.72 203.82,73.72 201.09,76.45 193.01,76.45 188.18,71.63 185.27,71.63 185.17,71.73 185.17,71.82 v1(185.45,72.1)
SATA_TXP0_C: length 5.3
  TOP w0.102: P61.2 236.1,65.68 235.1,65.68 234.06,64.64 232.47,64.64 TC1.2
SATA_TXP1: length 80.3
  TOP w0.102: TC9.1 231.04,48.09 230.8,48.09 230.4,48.49 230.4,52.98 231.62,54.2 232.71,54.2 v1(233.15,53.77) ; PCH.B37 177.93,61.6 177.93,62.48 181.33,65.89 181.33,68.24 181.98,68.9 183.98,68.9 184.73,69.65 185.04,69.65 185.32,69.37 v1(185.32,69.37)
  BOTTOM w0.102: v1(185.32,69.37) 185.59,69.63 186.75,69.63 186.99,69.88 189.26,69.88 191.37,71.99 208.2,71.99 210.46,69.72 213.24,69.72 215.53,67.44 221.7,67.44 229.26,59.88 229.26,59.61 232.33,56.53 232.33,54.29 232.6,54.03 232.89,54.03 v1(233.15,53.77)
SATA_TXP1_C: length 4.9
  TOP w0.102: TC9.2 232.66,48.15 235.35,48.15 235.5,48 236.19,48 P62.2
SATA_TXP2: length 92.9
  TOP w0.102: v1(233.2,31.92) 232.81,32.31 230.56,32.31 230.28,32.02 230.28,31.51 230.42,31.37 230.62,31.37 TC21.1 ; v1(187.55,67.39) 187.35,67.19 186.97,67.19 185.06,65.28 181.1,65.28 178.21,62.38 PCH.B38
  BOTTOM w0.102: v1(233.2,31.92) 233.63,32.36 233.83,32.36 234.05,32.58 234.05,36.24 232.26,38.03 232.26,51.2 230.48,52.98 230.48,55.6 227.41,58.67 227.41,59.11 220.94,65.58 214.76,65.58 212.47,67.87 209.69,67.87 207.46,70.1 192.49,70.1 189.61,67.22 187.72,67.22 v1(187.55,67.39)
SATA_TXP2_C: length 5.8
  TOP w0.102: TC21.2 232.19,31.34 232.75,31.34 233.87,30.22 236.19,30.22 P63.2
SATA_TXP3: length 114.7
  TOP w0.102: PCH.A39 178.77,62.04 178.77,62.23 180.99,64.46 182.37,64.46 182.68,64.15 183.03,64.15 v1(183.49,63.68) ; TC5.1 231.09,12.64 230.96,12.64 230.84,12.76 230.84,13.38 231.81,14.35 232.77,14.35 v1(232.99,14.12)
  BOTTOM w0.102: v1(183.49,63.68) 183.76,63.42 183.99,63.42 186.52,65.95 186.52,67.73 187.48,68.68 190.1,68.68 192.2,70.79 207.74,70.79 209.98,68.55 212.76,68.55 215.04,66.27 221.22,66.27 228.09,59.4 228.09,59.05 231.17,55.98 231.17,53.27 232.94,51.49 232.94,38.36 234.73,36.57 234.73,24.89 237.26,22.36 237.26,20.82 233.71,17.26 233.71,14.83 v1(232.99,14.12)
SATA_TXP3_C: length 4.9
  TOP w0.102: P64.2 236.19,12.43 234.83,12.43 234.65,12.61 232.64,12.61 TC5.2
SENSEA: length 10.2
  TOP w0.254: AU1.13 18.75,20.78 v1(19.68,21.72) 19.94,21.97 19.94,24.47 AR17.1 19.01,25.4 AR16.1 AR14.1 AR15.1
  BOTTOM w0.254: v1(19.68,21.72) 19.15,21.18 v2(19.15,21.08)
SENSEB: length 5.9
  TOP w0.254: AR18.1 AR25.1 AR11.1 AR19.1 9.88,13.25 v1(10.46,13.82) AU1.34
  BOTTOM w0.254: v2(11.01,13.27) v1(10.46,13.82)
SERIRQ_ESPI: length 59.6
  TOP w0.102: v1(201.7,32.16) 201.5,31.95 201.5,25 202.42,24.08 ECR67.1 ; SR85.2 162.4,21.23 171.26,21.23 v1(172.11,22.07)
  BOTTOM w0.102: v1(172.11,22.07) 173.61,23.57 174.19,23.57 176.84,26.23 178.9,26.23 180.6,27.93 186.54,27.93 v2(186.94,28.33) 187.71,28.33 188.25,28.87 192.16,28.87 192.47,28.56 195.14,28.56 195.91,29.34 196.72,29.34 198.26,30.87 198.72,30.87 199.29,31.44 199.29,32.77 200.34,33.82 201.13,33.82 201.7,33.25 v1(201.7,32.16)
SIDE-L: length 15.7
  TOP w0.254: AR215.1 5.68,64.33 v1(5.7,64.3) ; AC171.2 6.17,51.93 v1(6.17,55.63)
  BOTTOM w0.254: v1(5.7,64.3) 5.49,64.09 5.49,59.84 5.59,59.75 v2(5.59,59.05) 5.59,58.46 5.52,58.39 5.52,56.27 v1(6.17,55.63)
SIDE-L_C: length 46.6
  TOP w0.254: v1(14.16,15.09) 15.08,15.09 17.25,12.91 AU1.45 ; AC171.1 4.83,47.83 4.51,47.51 4.51,31.99 6.95,29.55 6.95,28.59 8.82,26.72 v1(11.99,26.72)
  BOTTOM w0.254: v1(11.99,26.72) 11.99,25.6 11.48,25.1 11.48,16.93 v2(12.62,15.79) 13.32,15.09 v1(14.16,15.09)
SIDE-R: length 17.5
  TOP w0.254: v1(8.41,63.38) 8.41,64.86 AR217.1
  BOTTOM w0.254: v1(8.41,63.38) 8.55,63.53 v2(9.98,63.53) 10.69,62.81 10.69,61.67 9.73,60.7 9.73,50.89 AC172.2
SIDE-R_C: length 46.2
  TOP w0.254: v1(14.15,15.86) 15.06,15.86 17.75,13.16 AU1.46 ; AC172.1 11.37,47.75 12.51,47.75 13.94,46.32 13.94,40.57 16.59,37.91 16.59,31.62 13.11,28.14 v1(13.11,26.72)
  BOTTOM w0.254: v1(13.11,26.72) 13.11,25.86 12.15,24.9 12.15,17.36 13.66,15.86 v1(14.15,15.86)
SIDE_JD: length 100.2
  TOP w0.254: v1(3.06,86.77) 3.06,88.35 4.04,89.33 4.2,89.33 5.16,90.29 5.16,91.32 6.22,92.38 6.22,105.61 J83.63 ; v1(3.06,84.89) 2.4,84.23 2.4,56.53 2.73,56.2 2.73,24.65 v1(2.82,24.56) ; AR18.2 6.78,11.36 v1(6.73,11.31)
  BOTTOM w0.254: v1(3.06,84.89) v1(3.06,86.77) ; v1(6.73,11.31) 6.73,11.99 v2(6.15,12.57) 5.24,13.48 5.24,18.38 3.7,19.93 3.7,23.69 v1(2.82,24.56)
SIDESURR_L: length 42.9
  TOP w0.254: v1(5.7,70.48) AD14.1 5.7,69.07 5.68,69.05 AC174.1 5.93,68.33 AL11.2 ; J83.62 9.35,101.86 9.35,93.26 v1(10.18,92.43)
  BOTTOM w0.254: v1(5.7,70.48) 5.89,70.67 5.89,72.75 3.45,75.18 3.45,81.82 4.62,82.99 4.62,86.69 6.37,88.44 v2(7.42,88.44) 8.12,88.44 9.71,90.03 9.71,91.96 v1(10.18,92.43)
SIDESURR_L_B: length 8.9
  TOP w0.254: AQ16.6 4.33,62.22 4.15,62.4 4.15,64.59 AR215.2 AR221.1 4.22,66.29 v1(4.06,66.45) 4.06,66.91 AL11.1
  BOTTOM w0.254: v2(5.41,67.34) 4.52,66.45 v1(4.06,66.45)
SIDESURR_L_MUTE: length 4.3
  TOP w0.254: v1(8.18,61.13) AR201.2 6.7,61.92 6.7,62.71 6.86,62.87 AQ16.2
  BOTTOM w0.254: v1(8.18,61.13) 7.73,61.57 v2(7.73,61.82)
SIDESURR_R: length 61.9
  TOP w0.254: v1(10.5,94.01) 10.5,101.44 13.07,104.02 13.07,113.18 12.2,114.05 J83.65 ; AL13.2 8.24,68.33 AC173.1 7.99,68.97 7.86,69.09 AD13.1 8.49,70.23 9.63,70.23 10.1,70.69 10.1,71.95 8.31,73.74 7.03,73.74 3.51,77.25 v1(3.51,83.36)
  BOTTOM w0.254: v1(10.5,94.01) 10.19,94.01 8.7,92.51 8.7,91.41 6.98,89.7 6.19,89.7 5.68,89.19 3.61,87.11 3.61,83.46 v1(3.51,83.36)
SIDESURR_R_B: length 5.5
  TOP w0.254: AL13.1 6.9,66.54 AR220.1 AR217.2 6.76,64.88 v1(6.76,64.36) 6.76,63.78 7.02,63.51 AQ16.3
  BOTTOM w0.254: v2(7.33,64.94) v1(6.76,64.36)
SIDESURR_R_MUTE: length 3.8
  TOP w0.254: AR202.2 6.04,61.66 v1(6.04,62.2) 6.04,62.5 5.67,62.87 AQ16.5
  BOTTOM w0.254: v2(6.07,61.21) 6.04,61.23 v1(6.04,62.2)
SIO_PCH_PLTRST#_LED: length 8.1
  TOP w0.102: Q5.6 104.8,12.97 v1(104.64,12.8) 104.52,12.69 104.52,11.38 104.37,11.23 103.48,11.23 102.64,10.39 101.57,10.39 101.32,10.13 CR7.2
  BOTTOM w0.102: v2(103.78,12.8) 103.78,12.8 v1(104.64,12.8)
SIO_PCH_RSMRST#_LED: length 3.9
  TOP w0.102: CR27.2 96.7,9.78 v1(97.12,10.2) 96.08,11.24 Q3.3
  BOTTOM w0.102: v1(97.12,10.2) 97.13,10.19 v2(97.89,10.19)
SIO_PECI_R: length 5.1
  TOP w0.102: v1(222.76,22.39) O2R1.2 SC52.2 221.16,23.39 220.54,24.01 U104.30
  BOTTOM w0.102: v2(222.23,23.01) 222.46,22.78 222.46,22.69 v1(222.76,22.39)
SIO_SLP_SUS#: length 177.6
  TOP w0.102: v1(229.2,187.46) 228.94,187.72 PR189.2 PR191.1 ; U104.74 217.74,38.88 218.97,37.64 v1(219.01,37.64) ; v1(218.77,99.77) 218.77,99.49 222.97,95.29 222.97,90.12 220.33,87.48 220.33,79.38 223.86,75.86 223.86,70.3 214.26,60.71 214.26,54.85 v1(213.56,54.15)
  BOTTOM w0.102: v1(229.2,187.46) 229.01,187.27 229.01,184.72 228.9,184.62 228.9,176.48 228.99,176.39 228.99,166.36 227.1,164.47 227.1,150.49 230.99,146.6 230.99,142.06 230.5,141.58 230.5,134.43 229.48,133.4 228.39,133.4 221.84,126.85 v2(221.84,126.59) 223.28,125.16 223.28,121.06 220.65,118.43 220.65,111.56 221.09,111.11 221.09,107.78 219.11,105.8 219.11,100.11 v1(218.77,99.77) ; v1(219.01,37.64) 219.48,38.12 219.48,38.39 219.65,38.56 219.65,43.41 220.14,43.9 220.14,47.27 215.68,51.74 214.17,51.74 213.26,52.65 213.26,53.85 v1(213.56,54.15)
SIO_SUSCLK: length 7.5
  TOP w0.102: U104.19 216.14,24.01 216.54,23.61 216.6,23.61 217.47,22.73 217.47,20.82 SCB70.2 ECR101.2 v1(217.2,19.51)
  BOTTOM w0.102: v2(217.96,19.51) v1(217.2,19.51)
SIO_TRST#: length 6.8
  TOP w0.102: v1(209.58,27.69) 209.22,28.04 U104.124 206.58,28.04 205.41,26.87 OR34.2
  BOTTOM w0.102: v1(209.58,27.69) 209.78,27.89 v2(209.78,28.83)
SKTOCC#: length 331.9
  TOP w0.089: PCH.AD44 181.35,50.58 181.59,50.34 182.61,50.34 184.8,52.53 185.22,52.53
  TOP w0.102: v1(212.45,58.09) 212.45,61.86 222.32,71.74 222.32,75.02 216.1,81.24 216.1,87.48 213.55,90.04 213.55,96.64 215.48,98.58 v1(216.36,98.58) ; v1(192.02,56.25) 192.02,56.25 SR7769.2 189.74,55.45 188.98,54.69 187.38,54.69 185.22,52.53 ; v1(137.21,211.68) 136.93,211.4 HR631.2
  BOTTOM w0.102: v1(216.36,98.58) 216.4,98.62 216.4,101.99 216.98,102.57 216.98,105.92 216.08,106.81 216.08,109.42 218.62,111.95 218.62,118.62 221.74,121.74 221.74,124.13 220.03,125.84 220.03,129.04 225.09,134.11 225.09,139.27 227.38,141.55 227.38,142.54 229.35,144.51 229.35,145.94 225.56,149.73 225.56,166.95 224.61,167.9 224.61,170.52 225.73,171.63 225.73,185.31 225.65,185.38 225.65,188.14 225.93,188.41 225.93,189.94 227.51,191.52 227.51,203.89 229.34,205.72 229.34,212.56 229.34,213.88 229.93,214.48 229.93,222.62 224.33,228.22 215.8,228.22 210.3,233.72 209.07,233.72 208.92,233.57 175.78,233.57 169.19,226.98 162.9,226.98 161.66,225.73 147.16,225.73 144.44,223.01 144.44,219.3 138.35,213.22 v2(137.75,213.22) 137.21,212.67 v1(137.21,211.68) ; v1(212.45,58.09) 212.17,58.09 210.41,59.84 206.15,59.84 203.9,57.6 194.55,57.6 193.71,56.76 192.53,56.76 v1(192.02,56.25)
SLOT1_PRST#: length 170.7
  TOP w0.089: PCH.BE22 169.85,39.93 169.85,39.04 168.76,37.95
  TOP w0.102: v1(126.57,42.21) 126.57,41.96 129.64,38.89 129.64,33.91 140.87,22.68 v1(140.87,22.53) ; v1(61.38,47.28) 61.38,49.05 60.3,50.13 60.3,55.07 57.61,57.76 57.61,59.28 58.86,60.53 58.86,62.1 58.52,62.43 58.52,63.14 59.44,64.06 59.44,65.55 63.17,69.29 M2R40.1 ; v1(167.54,29.06) 167.39,29.21 SR343.2 168.02,30.37 168.02,31.25 168.58,31.8 169.72,31.8 171.02,33.1 171.02,33.53 170.62,33.93 170.33,33.93 168.76,35.5 168.76,37.95
  BOTTOM w0.102: v1(126.57,42.21) 125.47,42.21 v2(125.29,42.02) 124.99,41.73 120.54,41.73 119.98,41.17 108.95,41.17 108.06,42.05 105.12,42.05 104.84,42.33 86.42,42.33 82.16,46.59 62.07,46.59 v1(61.38,47.28) ; v1(167.54,29.06) 167.83,28.76 167.83,28.43 166.85,27.44 163.18,27.44 162.68,26.94 161.77,26.94 161.22,26.4 158.3,26.4 158.25,26.35 155.99,26.35 153.64,24 149.88,24 148.99,23.11 141.45,23.11 v1(140.87,22.53)
SLOT2_PRST#: length 247.3
  TOP w0.089: PCH.BF23 170.46,39.68 170.46,39.4 168.97,37.91 168.97,37.78
  TOP w0.102: 168.97,37.78 168.97,35.59 170.25,34.32 170.84,34.32 171.34,33.82 171.34,32.8 171.78,32.36 171.78,31.06 171.59,30.87 SR680.2 171.27,31.47 v1(171.32,31.52) ; M2R41.1 63.75,53.33 v1(62.15,51.73) ; v1(37.77,67.11) 37.77,60.25 36.17,58.65 36.17,38.32 33.46,35.61 v1(30.61,35.61)
  BOTTOM w0.102: v1(37.77,67.11) 42.7,62.18 42.7,59.35 48.3,53.75 58.6,53.75 60.62,51.73 v1(62.15,51.73) ; v1(30.61,35.61) 30.04,35.04 30.04,29.27 v2(42.04,17.27) 42.75,16.56 82.79,16.56 83.64,17.41 83.64,17.71 84.64,18.71 84.64,19.71 85.11,20.18 127.79,20.18 129.34,18.63 131.16,18.63 133.56,21.04 140.48,21.04 140.5,21.05 142.35,22.9 149.11,22.9 149.99,23.78 153.73,23.78 156.08,26.13 158.34,26.13 158.39,26.18 161.46,26.18 162.01,26.73 162.77,26.73 163.27,27.23 167.08,27.23 167.97,28.12 170.33,28.12 171.62,29.41 171.62,31.22 v1(171.32,31.52)
SLOT2_PRST#_R: length 22
  TOP w0.102: SLOT2.B31 77.45,57.38 75.35,55.28 M2R41.2 63.75,56.26 63.45,56.57 SLOT2.B17
SLOT3_PRST#: length 160.4
  TOP w0.089: PCH.BG30 175.37,38.13
  TOP w0.102: v1(89.79,15.49) 89.03,16.26 78.18,16.26 77.17,17.26 77.17,18.46 76.45,19.18 76.45,19.84 74.73,21.57 74.73,22.91 75.44,23.62 75.44,28.91 v1(76.83,30.3) ; v1(62.57,30.3) 63.45,31.18 M2R43.1 ; SR7628.2 182.81,34.62 v1(182.37,35.05) 181.19,36.23 178.52,36.23 176.78,37.97 175.52,37.97 175.37,38.13
  BOTTOM w0.102: v1(182.37,35.05) 182.37,34.26 181.04,32.93 179.02,32.93 177.11,31.03 175.52,31.03 174.5,30.01 174.5,29.3 172.89,27.7 172.05,27.7 171,26.64 168.54,26.64 167.64,25.75 166.69,25.75 165.99,25.05 163.37,25.05 162.76,24.43 161.01,24.43 160.61,24.04 156.59,24.04 154.76,22.21 151.58,22.21 150.53,21.16 143.37,21.16 142.17,19.95 135.17,19.95 132.26,17.05 130.57,17.05 129.65,16.13 90.42,16.13 v1(89.79,15.49) ; v1(62.57,30.3) v2(69.22,30.3) v1(76.83,30.3)
SLOT3_PRST#_R: length 22.2
  TOP w0.102: SLOT3.B31 77.45,36.94 77.22,36.7 68.96,36.7 67.32,35.06 M2R43.2 63.45,35.07 SLOT3.B17
SLOT4_PRST#: length 168.8
  TOP w0.102: v1(173.43,15.54) 173.43,24.73 172.57,25.6 172.57,27.58 172.24,27.91 SR7629.2 172.91,28.37 172.92,28.37 v1(172.95,28.35) ; v1(157.26,15.92) 157.08,15.92 v1(152.09,20.91) ; M2R44.1 61.41,15.45 v1(61.19,15.45) ; PCH.AR29 174.32,44.73 v1(174.32,43.99)
  BOTTOM w0.089: 176.66,38.18 176.27,38.57 176.27,39.64 174.45,41.46 174.45,42.57 173.96,43.06 173.96,43.63 v1(174.32,43.99)
  BOTTOM w0.102: 176.66,38.18 176.88,37.96 179.35,37.96 181.68,35.62 181.68,33.87 180.95,33.15 178.93,33.15 177.02,31.24 175.4,31.24 174.28,30.12 174.28,29.99 172.95,28.65 v1(172.95,28.35) ; v1(173.43,15.54) 173.3,15.42 170.71,15.42 170.23,14.94 170.23,14.05 170.23,13.9 170.23,13.9 170.23,12.35 169.85,11.97 169.85,11.46 167.23,8.84 162.94,8.84 157.81,13.97 v2(157.81,14.86) 157.81,15.37 v1(157.26,15.92) ; v1(61.19,15.45) 61.44,15.69 88.47,15.69 89.09,15.07 90.08,15.07 90.92,15.91 129.74,15.91 130.55,16.72 132.66,16.72 132.75,16.62 133.74,16.62 136.64,19.52 142.35,19.52 143.55,20.73 150.76,20.73 150.94,20.91 v1(152.09,20.91)
SLP_S3#: length 540.6
  TOP w0.102: v1(220.19,101.17) 220.19,98.98 221.31,97.87 223.37,97.87 223.46,97.96 225.11,97.96 225.27,97.79 225.27,90.36 222.33,87.42 222.33,82.39 223.11,81.61 223.11,81.25 223.45,80.91 224.12,80.91 224.6,81.39 v1(225.08,81.39) ; v1(164.29,42.49) 164.31,42.47 164.31,42.45 PCH.BA11 ; v1(223.49,78.94) 224.03,78.41 225.53,78.41 226.11,78.99 227.69,78.99 228.06,79.37 MQ19.5 ; v1(205.5,28.3) 205.1,28.7 C81.1 204.99,29.06 206.2,29.06 206.38,29.24 U104.121 209.78,29.24 210.73,30.19 216.34,30.19 v1(217.25,31.09) ; v1(92.86,9.35) 94.21,10.69 94.21,11 95.53,12.32 Q3.2 ; v1(134.24,99.19) 133.48,98.42 133.48,96.44 135.18,94.74 137.41,94.74 137.79,94.36 MQ29.2 ; v1(220.9,105.28) 222,106.38 MQ20.5 ; v1(222,78.46) 222,78.02 224.07,75.94 224.07,70.21 214.68,60.82 v1(214.68,58.42) ; v1(169.32,105.16) 153.39,105.16 152.3,106.24 143.65,106.24 142.02,107.87 132.87,107.87 v1(132.44,108.31) ; MQ25.5 v1(228.5,155.47) ; v1(159.78,5.47) 161.08,4.17 171.69,4.17 172.65,5.13 172.65,6.73 172.07,7.3 172.07,8.45 173.2,9.57 173.2,9.59 173.34,9.73 173.34,14.14 v1(171.55,15.93) 171.55,16.44 168.24,19.76 162.48,19.76 161.19,18.47 156.26,18.47 149.39,25.33 v1(149.24,25.33) ; v1(209.78,91.57) 209.33,91.12 209.33,90.63 209.54,90.43 209.54,88.56 210.08,88.01 210.08,75.95 v1(210.03,75.9)
  BOTTOM w0.089: 164.29,40.44 164.66,40.81 164.66,42.12 v1(164.29,42.49)
  BOTTOM w0.102: v1(210.03,75.9) 210.88,76.75 210.88,77.08 211.91,78.11 213.89,78.11 214.78,77.22 214.96,77.22 214.96,77.21 215.35,77.21 215.35,77.22 220.75,77.22 v1(222,78.46) 222.48,78.94 v2(222.68,78.94) v1(223.49,78.94) 223.85,79.3 223.85,80.16 v1(225.08,81.39) 226.59,82.91 226.59,85.78 228.49,87.67 229.77,87.67 230.62,88.52 230.62,89.56 233.63,92.57 233.63,100.8 234.52,101.69 234.52,133.4 230.99,136.93 230.99,141.45 231.42,141.88 231.42,146.78 227.77,150.43 227.77,154.75 v1(228.5,155.47) ; v1(205.5,28.3) 204.22,27.02 204.22,26.34 201.5,23.61 201.5,22.4 198.03,18.94 189.09,18.94 187.06,16.9 182.66,16.9 181.94,16.18 179.07,16.18 178.5,16.75 172.38,16.75 v1(171.55,15.93) ; v1(209.78,91.57) 209.96,91.57 210.71,92.31 210.71,93.3 207.29,96.72 206.25,96.72 203.5,99.47 201.76,99.47 200.53,98.24 197.79,98.24 196.57,99.47 193.51,99.47 193.35,99.31 188.62,99.31 187.89,100.04 175.02,100.04 174.57,99.59 172.71,99.59 169.85,102.46 169.85,104.62 v1(169.32,105.16) ; v1(214.68,58.42) 214.68,53.42 220.7,47.4 220.7,47.24 222.22,45.72 222.22,44.65 220.09,42.51 220.09,38.39 219.92,38.22 219.92,37.45 219.28,36.8 219.27,36.8 219.04,36.57 219.04,35.57 218,34.53 218,33.67 217.26,32.94 217.26,31.1 v1(217.25,31.09) ; 164.29,40.44 164.29,37.03 162.22,34.95 162.22,34.1 161.48,33.37 161.48,30.58 158.86,27.95 157.76,27.95 157.08,27.27 154.56,27.27 153.07,25.78 149.68,25.78 v1(149.24,25.33) ; v1(134.24,99.19) 134.47,99.42 134.47,106.73 132.89,108.31 v1(132.44,108.31) ; v1(92.86,9.35) 92.86,8.93 93.34,8.45 94.94,8.45 95.17,8.67 103.76,8.67 103.99,8.9 105.84,8.9 105.99,9.05 106.53,9.6 115.28,9.6 116.04,8.83 120.25,8.83 121.28,7.8 138.44,7.8 142,11.37 153.5,11.37 155.89,8.97 156.45,8.97 159.78,5.64 v1(159.78,5.47) ; v1(220.9,105.28) 220.31,104.69 220.31,102.7 221.03,101.98 221.03,101.75 220.45,101.17 v1(220.19,101.17)
SLP_S3#_LED: length 6.6
  TOP w0.102: CR26.2 98.32,9.73 98.55,9.96 98.62,9.96 99.65,10.98 99.65,12.44 v1(99.35,12.74) 99.12,12.97 Q3.6
  BOTTOM w0.102: v2(100.13,12.79) 100.08,12.74 v1(99.35,12.74)
SLP_S4#: length 886.3
  TOP w0.089: PCH.BF13 165.65,39.76 165.65,38.9 165.48,38.73 165.48,38.01
  TOP w0.102: v1(213.94,99.97) 213.94,97.49 213.33,96.88 213.33,89.95 214.57,88.72 214.57,76.12 211.59,73.15 211.59,57.8 v1(211.3,57.51) ; v1(202.39,26.57) 202.39,27.66 202.93,28.21 204.91,28.21 205.28,27.83 205.7,27.83 206.15,28.28 206.15,28.5 206.49,28.84 U104.122 209.69,28.84 210.82,29.97 216.97,29.97 v1(217.25,30.25) ; 165.48,38.01 165.58,37.91 v1(165.58,36.27) ; v1(44.55,237.11) 44.92,237.48 PR70298.1 ; v1(211.3,54.23) 212.81,54.23 v1(213.83,53.21) ; U104.69 219.74,41.38 220.59,42.23 220.85,42.23 C82.1 221.74,43.12 221.74,43.24 221.92,43.42 221.92,45.35 v1(221.75,45.52) ; PR236.1 54.57,119.6 v1(54.48,119.51) ; v1(214.88,126.29) 214.57,126.61 PR6610.2 ; v1(84.85,11.87) 84.85,14.34 85.2,14.69 91.02,14.69 91.61,15.29 93.39,15.29 95.17,17.07 95.17,17.76 96.17,18.76 96.17,22.33 95.73,22.78 95.73,36.95 104.42,45.65 104.42,62.79 114.35,72.72 119.86,72.72 125.27,78.13 125.27,78.48 126.17,79.38 126.17,83.53 127.17,84.53 127.17,85.32 128.32,86.46 129.11,86.46 v1(130.07,87.43) ; PQ10.1 208.73,220.66 207.75,221.64 207.75,224.54 209.82,226.61 209.82,231.03 210.21,231.42 218.74,231.42 221.62,228.55 221.62,224.82 v1(221.41,224.61) ; SR75.1 132.67,108.71 132.61,108.78 132.17,108.78 v1(131.7,108.31) ; v1(61.29,126.26) 59.36,124.33 59.36,114.92 v1(58.18,113.73) 57.53,113.09 53.22,113.09 49.77,109.64 47,109.64 44.42,107.06 35.83,107.06 23.88,95.11 23.88,62.81 24.3,62.4 24.3,59.68 v1(21.92,57.3) ; v1(151.22,24.64) 156.58,19.28 v1(160.17,19.28)
  BOTTOM w0.102: v1(130.07,87.43) 130.07,94.06 131.17,95.15 132.23,95.15 133.65,96.57 133.65,99.72 133.52,99.86 133.52,100.42 134.24,101.14 134.24,106.65 133.07,107.82 132.18,107.82 v1(131.7,108.31) ; v1(221.41,224.61) 221.7,224.61 222.5,223.8 222.5,221.31 v2(221.97,220.77) 221.61,220.42 221.61,211.56 223.29,209.88 223.29,191.04 223.29,189.8 222.4,188.92 222.4,178.61 221.86,178.07 221.86,172.64 221.18,171.96 221.18,153.48 213.54,145.83 213.54,141.83 214.5,140.87 214.5,139.9 213.77,139.17 213.77,138.2 214.48,137.49 214.48,133.88 215.37,132.99 215.37,129.56 215.7,129.23 215.7,127.1 v1(214.88,126.29) 215.39,125.78 215.39,124.21 216.41,123.19 216.41,112.93 215.98,112.5 213.26,112.5 212.7,111.94 212.7,102.74 213.94,101.5 v1(213.94,99.97) ; v1(213.83,53.21) 214.67,52.37 215.35,52.37 220.36,47.36 220.36,46.91 v1(221.75,45.52) 221.87,45.4 221.87,44.6 219.88,42.6 219.88,38.48 219.7,38.3 219.7,37.53 219.2,37.03 219.2,37.03 218.82,36.66 218.82,35.66 217.78,34.62 217.78,33.76 217.04,33.03 217.04,31.55 216.81,31.32 216.81,30.68 v1(217.25,30.25) ; v1(21.92,57.3) 23.15,56.07 23.15,32.15 28.37,26.93 28.37,25.85 41.82,12.4 50.51,12.4 51.85,11.05 55.01,11.05 55.36,10.7 57.23,10.7 57.62,10.31 74,10.31 74.29,10.6 74.74,10.6 75.61,11.47 75.79,11.47 84.1,11.47 84.5,11.87 v1(84.85,11.87) 85.42,11.87 85.71,11.58 91.51,11.58 92.11,12.18 93.83,12.18 94.14,11.87 104.16,11.87 104.24,11.95 119.68,11.95 119.94,11.69 121.43,11.69 121.58,11.54 134.65,11.54 139.17,16.06 149.34,16.06 149.55,16.27 155.06,16.27 155.34,16.56 155.93,16.56 156.29,16.56 156.29,16.56 156.67,16.56 157.04,16.93 157.22,16.93 157.46,16.93 159.81,19.28 v1(160.17,19.28) 160.54,19.65 167.88,19.65 168.64,18.9 177.81,18.9 179.13,20.22 179.32,20.22 181.09,20.22 182.76,21.89 189.06,21.89 189.5,21.45 198.82,21.45 199.71,22.34 199.71,25.83 200.45,26.57 v1(202.39,26.57) ; v1(61.29,126.26) 60.71,126.26 48.98,137.98 48.98,146.6 46.91,148.67 46.91,160.48 45.62,161.77 45.62,170.94 42.95,173.61 42.95,180.92 43.59,181.56 43.59,194.69 43.62,194.72 43.62,205.63 44.72,206.72 44.72,218.39 42.9,220.21 42.9,221.49 42.67,221.72 42.67,235.23 v1(44.55,237.11) ; v1(54.48,119.51) 54.98,119.51 55.49,119 55.49,116.42 v1(58.18,113.73) ; v1(211.3,54.23) v1(211.3,57.51) ; v1(151.22,24.64) 153.6,24.64 155.74,26.78 155.85,26.78 155.85,26.78 156.17,26.78 156.17,26.78 156.35,26.78 157.2,26.78 157.94,27.52 159.44,27.52 161.53,29.61 161.53,30.01 161.91,30.4 161.91,32.78 163.55,34.42 164.29,34.42 165.1,35.23 165.1,35.56 165.58,36.04 v1(165.58,36.27)
SLP_S4#_R: length 7.9
  TOP w0.102: PQ9786.1 51.63,127.78 51.92,128.07 v1(52.14,128.07) 52.22,127.98 52.22,126.67 53.08,125.82 PC640679.2 53.08,125.19 PR70256.2 53.66,123.88 PR235.2 PC121.1
  BOTTOM w0.102: v1(52.14,128.07) v2(51.36,128.07)
SLP_S4#_R3: length 6
  TOP w0.102: PQ23.3 51.97,121.64 52.5,122.17 v1(52.5,122.4) 52.5,122.86 52.81,123.16 53.78,123.16 PR235.1 54.76,123.7 54.9,123.56 PR234.2
  BOTTOM w0.102: v1(52.5,122.4) 52.43,122.4 v2(51.77,121.74)
SLP_S4#_R5: length 4.6
  TOP w0.102: PR236.2 PC13.2 54.76,121.41 54.04,120.69 PQ23.1 v1(53.75,119.92)
  BOTTOM w0.102: v1(53.75,119.92) 53.75,120.63 v2(53.59,120.78)
SLP_SUS#: length 132
  TOP w0.089: PCH.BF10 164.41,39.71 164.41,38.93 163.97,38.49 163.97,37.97
  TOP w0.102: v1(146.28,24.61) 146.28,24.17 155.68,14.78 v1(155.68,14.3) ; v1(218.94,39.24) U104.71 218.94,41.19 219.71,41.96 SCB75.1 ; 163.97,37.97 163.97,37.91 163.35,37.29 163.35,36.85 161.27,34.77 v1(161.27,34.54)
  BOTTOM w0.102: v1(146.28,24.61) 147.85,24.61 149.32,26.09 152.93,26.09 154.41,27.57 157.03,27.57 157.79,28.33 158.66,28.33 160.17,29.84 160.45,29.84 161.27,30.67 v1(161.27,34.54) ; v1(155.68,14.3) 156.24,14.3 162.57,7.98 167.59,7.98 170.71,11.1 170.71,11.33 171.1,11.71 171.83,11.71 172.47,12.35 172.7,12.35 173.64,13.28 174.58,13.28 174.87,13.58 175.95,13.58 179.11,13.58 182.14,13.58 182.91,13.58 183.71,14.38 188.29,14.38 189.66,15.74 196.86,15.74 v2(197.33,15.27) 197.63,14.97 199.9,14.97 200.84,15.91 202.33,15.91 203.76,17.34 203.76,18.31 205.35,19.9 205.35,21.63 208.39,24.68 212.53,24.68 216.6,28.75 216.6,31.41 216.83,31.64 216.83,33.12 217.56,33.85 217.56,34.71 218.54,35.69 218.54,38.85 v1(218.94,39.24)
SLP_SUS#_CRT_R: length 34
  TOP w0.254: PQ31.1 226.71,191.28 226.71,190.39 PC236.1 PC233.2 227.84,190.25 228.64,189.45 PR188.2 227.99,189.13 v1(227.97,189.1) 227.71,189.1 227.29,188.68 PR191.2 ; PQ691.1 228.91,162.87 229.03,162.99 229.03,163.97 PR187.2 228.51,164.86 228.64,164.98 PC232.2 228.64,166.44 v1(228.51,166.56)
  BOTTOM w0.254: v1(227.97,189.1) 228.65,188.42 v2(228.65,188.37) 228.65,185.91 228.71,185.85 228.71,184.84 228.61,184.74 228.61,176.36 228.7,176.27 228.7,166.76 v1(228.51,166.56)
SMB_CLK_MAIN: length 281.8
  TOP w0.102: v1(211.86,90.65) 212.08,90.44 212.08,89.29 213.27,88.09 213.27,76.66 208.99,72.38 208.99,59.62 209.4,59.22 209.4,58.62 v1(208.99,58.22) ; v1(129.5,88.98) 129.36,89.12 96.61,89.12 94.89,90.84 84.32,90.84 76.2,98.96 v1(76.2,99.47) ; v1(211.43,46.76) 211.72,47.05 214.16,47.05 214.34,46.87 R19.2 C2.1 214.07,44.82 214.03,44.82 213.72,44.5 213.23,44.5 212.79,44.06 212.79,43.33 OR60.2 ; XDP2.53 84.76,107.47 84.3,107.47 84.01,107.76 84.01,108.02 83.53,108.5 v1(83.06,108.5) ; v1(130.91,108.13) 131.52,107.52 141.87,107.52 143.51,105.88 152.15,105.88 153.24,104.8 168.21,104.8 168.59,104.42 v1(169.21,104.42) 169.39,104.42 169.67,104.14 172.5,104.14 D4C5.1 174.42,104.48 175.55,105.61 175.55,105.72 CON_XMM3.141 176.36,105.77 176.47,105.77 176.93,106.22 178.79,106.22 179.36,106.79 180.05,106.79 180.49,106.35 182.92,106.35 183.12,106.15 CON_XMM1.141 184.45,106.15 184.58,106.27 186.66,106.27 187.23,106.84 187.85,106.84 188.47,106.23 189.68,106.23 190.56,105.35 191.29,105.35 191.65,105.7 191.83,105.7 192.27,106.15 CON_XMM4.141 192.54,106.3 195.2,106.3 195.71,106.81 196.85,106.81 197.37,106.29 200.02,106.29 CON_XMM2.141
  BOTTOM w0.102: v1(208.99,58.22) 208.99,57.33 209.89,56.43 209.89,50.63 211,49.53 211,47.19 v1(211.43,46.76) ; v1(169.21,104.42) 168.9,104.1 168.9,102.62 172.48,99.03 174.8,99.03 175.24,99.47 187.65,99.47 191.11,96.01 196.01,96.01 197.69,97.69 200.51,97.69 202.34,95.86 207.28,95.86 210.15,92.99 210.15,92.59 209.8,92.24 209.42,92.24 209.07,91.88 209.07,90.43 209.48,90.02 210.78,90.02 211.41,90.65 v1(211.86,90.65) ; v1(130.91,108.13) 130.91,107.65 133.59,104.98 133.59,104.81 133.59,101.18 133.16,100.75 133.16,99.58 133.3,99.44 133.3,96.82 131.98,95.5 131.02,95.5 129.5,93.99 v1(129.5,88.98) ; v1(83.06,108.5) 82.3,107.73 82.3,105.91 76.2,99.81 v1(76.2,99.47)
SMB_CLK_RESUME: length 435.1
  TOP w0.102: M2R47.1 49.97,117.78 M2C46.1 51.12,118.31 51.63,118.31 51.96,117.98 53.43,117.98 53.9,117.52 53.9,116.28 52.7,115.09 52.05,115.09 49.72,112.75 47.7,112.75 47.19,112.24 v1(47.19,111.96) ; OR60.1 213.63,43.73 v1(214.3,44.4) ; v1(206.98,40.87) 208.85,39 208.85,37.98 v1(209.37,37.47) 209.83,37.01 v1(214.63,37.01) ; v1(50.16,11.33) 50.38,11.54 50.38,12.46 49.96,12.87 49.96,13.93 SR7686.2 49.53,15.16 49.35,15.34 49.35,17.81 50.22,18.68 50.22,19.88 49.73,20.37 49.39,20.37 48.39,21.38 48.39,22.48 47.52,23.34 47.52,26.35 48.97,27.8 48.97,33.09 49.19,33.31 49.19,33.7 SR7682.2 49.53,34.63 49.53,38.38 50.16,39.01 50.16,39.98 48.51,41.63 48.51,42.88 49.15,43.51 49.15,44.65 48.29,45.52 48.29,50.5 49.12,51.33 49.12,52.13 SR7684.2 48.32,52.51 48.11,52.73 48.11,55.68 48.11,55.88 49.15,56.92 49.15,58.88 48.55,59.48 48.55,60.57 48.67,60.69 v1(48.67,61.37) 48.67,61.8 48.54,61.93 48.54,62.97 47.52,63.98 47.52,64.88 48.17,65.53 48.17,65.68 SR7688.2 48.82,66.33 48.82,67.72 50.04,68.94 50.04,75.56 v1(49.71,75.9) ; PCH.BE38 178.36,40.05 178.36,39.24 179.53,38.07 184.8,38.07 184.89,38.16 186.22,38.16 186.78,38.72 SC85.1 188.65,39.32 190.79,39.32 SR250.2 190.68,40.08 v1(190.58,39.98) ; SR7665.1 111.36,54.69 v1(111.32,54.73) ; v1(175.49,22.73) 174.78,22.02 174.78,17.2 174.41,16.83 174.41,10.15 v1(174.78,9.77)
  BOTTOM w0.102: v1(190.58,39.98) 191.39,39.98 191.94,40.52 193.5,40.52 193.88,40.91 202.12,40.91 202.64,41.43 205.96,41.43 206.52,40.87 v1(206.98,40.87) ; v1(214.3,44.4) 214.3,44.27 v2(214.8,43.78) 215.1,43.47 215.1,37.48 v1(214.63,37.01) ; v1(209.37,37.47) 209.28,37.38 209.28,34.89 207.03,32.64 206.33,32.64 205.93,32.23 205.06,32.23 203.18,30.35 201.56,30.35 200.02,28.82 199.16,28.82 196.71,26.37 191.06,26.37 190.56,25.87 181.78,25.87 179.72,23.81 176.99,23.81 175.91,22.73 v1(175.49,22.73) ; v1(174.78,9.77) 173.06,8.05 170.28,8.05 168.44,6.21 161.6,6.21 154.54,13.27 153.33,13.27 151.98,13.27 151.5,13.75 148.57,13.75 147.59,12.78 141.36,12.78 137.4,8.82 121.7,8.82 121.13,9.39 121.13,9.39 120.67,9.85 116.46,9.85 115.67,10.64 106.14,10.64 105.42,9.92 103.56,9.92 103.34,9.7 103.28,9.69 96.09,9.69 95.23,10.55 92.36,10.55 92.27,10.46 83.19,10.46 82.32,9.6 74.71,9.6 74.37,9.26 58.37,9.26 58.1,8.98 52.51,8.98 v1(50.16,11.33) ; v1(111.32,54.73) 110.86,55.2 73.29,55.2 71.44,57.05 64.3,57.05 63.45,57.9 63.45,58.45 62.71,59.18 51.16,59.18 50.5,59.85 50.5,61.01 49.87,61.63 48.93,61.63 v1(48.67,61.37) ; v1(49.71,75.9) 49.28,76.33 49.28,78.65 48.36,79.57 48.36,83.59 49.28,84.51 49.28,97.78 48.19,98.87 48.19,110.97 v1(47.19,111.96)
SMB_CLK_RESUME_DAC: length 11.7
  TOP w0.102: v1(120.78,55.81) 120.68,55.71 PC566.1 120.02,55.04 119.79,54.81 119.23,54.81 118.88,54.47 PU12.5 ; v1(113.89,55.02) 113.57,54.69 SR7665.2
  BOTTOM w0.102: v1(120.78,55.81) 116.37,55.81 115.57,55.02 v2(114.71,55.02) v1(113.89,55.02)
SMB_CLK_RESUME_WLAN: length 9.3
  TOP w0.102: J60.60 42.17,116.76 42.3,116.89 45.21,116.89 v1(45.42,117.09) 45.72,117.09 46.02,116.79 47.26,116.79 48.55,118.08 M2R47.2
  BOTTOM w0.102: v2(46.18,116.64) 45.92,116.64 45.47,117.09 v1(45.42,117.09)
SMB_DATA_MAIN: length 287.1
  TOP w0.102: v1(211.86,91.39) 212.28,90.97 212.28,89.37 213.47,88.18 213.47,76.57 209.19,72.29 209.19,59.71 209.6,59.3 209.6,58.54 209.45,58.39 v1(209.45,57.73) ; v1(211.46,47.5) 211.7,47.25 214.25,47.25 215.13,46.38 R18.2 C1.1 214.77,44.73 214.77,44.2 214.57,44 214.57,43.38 OR61.2 ; v1(128.93,88.51) 128.53,88.92 96.53,88.92 94.8,90.64 84.23,90.64 75.79,99.09 v1(75.56,99.09) ; v1(130.15,108.13) 130.96,107.31 141.79,107.31 143.42,105.68 152.07,105.68 153.15,104.6 168.13,104.6 168.75,103.97 169.06,103.97 v1(169.37,103.67) 169.63,103.94 172.58,103.94 D4C4.1 173.99,103.67 175.73,105.41 176.4,105.41 177.01,106.02 178.87,106.02 179,106.15 CON_XMM3.285 180.39,106.15 180.39,106.14 182.84,106.14 183.48,105.5 184.02,105.5 184.46,105.94 184.54,105.94 184.64,106.05 186.87,106.05 186.97,106.15 CON_XMM1.285 187.67,106.03 189.59,106.03 190.47,105.14 191.38,105.14 191.73,105.5 192.65,105.5 193.2,106.05 193.36,106.05 193.38,106.05 193.44,106.05 195.46,106.05 195.56,106.15 CON_XMM4.285 196.83,106.15 196.89,106.08 199.3,106.08 199.89,105.5 200.43,105.5 200.87,105.94 201.19,105.94 201.4,106.15 CON_XMM2.285 ; XDP2.51 85.16,107.77 84.69,107.77 84.53,107.93 v1(84.53,107.94)
  BOTTOM w0.102: v1(209.45,57.73) 209.45,57.16 210.1,56.51 210.1,50.72 211.22,49.6 211.22,47.73 v1(211.46,47.5) ; v1(75.56,99.09) 75.56,99.46 82.09,105.99 82.09,108.12 82.89,108.92 83.56,108.92 v1(84.53,107.94) ; v1(128.93,88.51) 128.93,89.12 129.3,89.49 129.3,94.07 130.93,95.71 131.89,95.71 133.1,96.91 133.1,99.36 132.96,99.5 132.96,100.83 133.38,101.26 133.38,104.89 v1(130.15,108.13) ; v1(211.86,91.39) 210.69,90.22 209.56,90.22 209.27,90.51 209.27,91.8 209.51,92.04 209.93,92.04 210.35,92.46 210.35,93.07 207.36,96.06 202.44,96.06 200.61,97.89 197.6,97.89 195.92,96.21 191.2,96.21 187.72,99.69 175.17,99.69 174.72,99.24 172.57,99.24 169.11,102.69 169.11,103.42 v1(169.37,103.67)
SMB_DATA_RESUME: length 437.3
  TOP w0.089: v1(179.58,40.87) 179.9,40.87 PCH.BC42
  TOP w0.102: v1(187.3,36.91) 187.45,36.75 SC86.1 188.68,37.39 189.6,37.39 190.55,38.34 v1(190.55,38.84) 191.17,38.84 SR251.2 ; SR7664.1 111.02,55.64 110.65,55.27 v1(110.65,54.75) ; v1(50.04,76.58) 50.24,76.38 50.24,68.86 49.05,67.67 49.05,66.33 SR7689.2 48.7,65.41 48.34,65.41 47.73,64.8 47.73,64.07 48.74,63.05 48.74,62.03 49.43,61.34 v1(49.43,61.16) 48.75,60.49 48.75,59.6 49.35,59 49.35,56.8 48.31,55.76 48.31,53.07 48.42,52.96 49.21,52.96 SR7685.2 49.33,52.18 49.33,51.25 48.49,50.41 48.49,45.6 49.35,44.74 49.35,43.43 48.72,42.79 48.72,41.71 50.37,40.06 50.37,38.93 49.73,38.3 49.73,34.43 SR7683.2 49.17,33.01 49.17,27.71 47.73,26.26 47.73,23.52 48.64,22.61 48.64,21.41 49.48,20.57 49.81,20.57 50.42,19.96 50.42,18.59 49.56,17.73 49.56,15.46 SR7687.2 50.16,13.88 50.16,12.98 50.65,12.5 50.65,11.1 v1(50.14,10.59) ; v1(47.9,112.24) 48.19,112.53 49.79,112.53 52.11,114.86 52.76,114.86 54.1,116.2 54.1,117.6 53.52,118.19 52.04,118.19 51.71,118.52 51.02,118.52 M2C47.1 50.19,118.95 50.14,119 M2R46.1 ; v1(207,40.11) 207.46,40.11 208.64,38.93 v1(208.64,37.44) 209.28,36.79 214.08,36.79 v1(214.63,36.25) ; v1(215.26,44.4) 215.06,44.2 OR61.1 ; v1(172.8,7.62) 174.21,9.03 174.21,16.94 174.57,17.31 174.57,22.57 v1(174.74,22.73)
  BOTTOM w0.102: v1(174.74,22.73) 175.19,23.19 176.06,23.19 176.88,24.02 179.64,24.02 181.69,26.07 190.48,26.07 190.97,26.57 196.63,26.57 199.08,29.02 199.94,29.02 201.48,30.56 203.1,30.56 204.98,32.44 205.84,32.44 206.25,32.84 206.95,32.84 209.08,34.97 209.08,37 v1(208.64,37.44) ; v1(187.3,36.91) 184.3,39.9 180.14,39.9 179.58,40.46 179.58,40.86 v1(179.58,40.87) ; v1(215.26,44.4) 215.3,44.36 215.3,36.92 v1(214.63,36.25) ; v1(207,40.11) 205.88,41.22 202.73,41.22 202.2,40.7 193.97,40.7 v2(193.27,40.01) 192.97,40.3 192.02,40.3 v1(190.55,38.84) ; v1(172.8,7.62) 170.14,7.62 168.52,6.01 161.52,6.01 154.45,13.07 153.25,13.07 153.25,13.07 151.9,13.07 151.41,13.55 148.65,13.55 147.67,12.57 141.44,12.57 137.48,8.61 121.62,8.61 120.93,9.3 120.58,9.64 116.38,9.64 115.58,10.44 106.22,10.44 105.5,9.72 103.65,9.72 103.42,9.49 95.85,9.49 94.99,10.35 92.45,10.35 92.36,10.26 83.27,10.26 82.4,9.4 74.79,9.4 74.45,9.05 58.46,9.05 58.18,8.78 51.95,8.78 v1(50.14,10.59) ; v1(50.04,76.58) 49.48,77.14 49.48,78.74 48.56,79.66 48.56,83.5 49.48,84.42 49.48,97.87 48.39,98.96 48.39,111.05 47.9,111.54 v1(47.9,112.24) ; v1(49.43,61.16) 50.04,61.16 50.27,60.93 50.27,59.79 51.08,58.98 62.59,58.98 63.25,58.33 63.25,57.81 64.21,56.85 71.36,56.85 73.21,54.99 110.41,54.99 v1(110.65,54.75)
SMB_DATA_RESUME_DAC: length 10.9
  TOP w0.102: PU12.3 118.23,52.28 117.78,52.73 116.01,52.73 PC567.1 115.65,53.74 116.18,54.27 v1(116.18,54.91) 115.7,54.91 114.97,55.64 SR7664.2
  BOTTOM w0.102: v1(116.18,54.91) 116.31,55.04 v2(117.3,55.04)
SMB_DATA_RESUME_WLAN: length 11.1
  TOP w0.102: M2R46.2 48.36,118.53 48.36,118.2 47.17,117.01 46.19,117.01 45.36,117.83 v1(45.29,117.83) 44.58,117.12 41.96,117.12 41.67,116.83 J60.58
  BOTTOM w0.102: v1(45.29,117.83) 45.29,118.85 v2(45.42,118.97)
SMBALERT#_TLS: length 16.1
  TOP w0.089: PCH.BE41 180.43,40.43 v1(180.47,40.4)
  TOP w0.102: SR257.2 v1(194.36,38.05)
  BOTTOM w0.089: v1(180.47,40.4) 180.74,40.12 183.51,40.12
  BOTTOM w0.102: v1(194.36,38.05) 193.5,38.05 193.36,38.19 189.39,38.19 188.72,38.86 v2(187.71,38.86) 186.84,38.86 185.58,40.12 183.51,40.12
SML0CLK: length 18.4
  TOP w0.089: v1(177.17,39.06) 177.17,39.38 177.27,39.69 177.27,39.78 177.29,40.08 PCH.BE37
  TOP w0.102: v1(190.68,37.11) 191.25,37.11 SR252.2
  BOTTOM w0.089: 182.07,37.35 181,38.42 179.79,38.42 179.15,39.06 v1(177.17,39.06)
  BOTTOM w0.102: v1(190.68,37.11) 190.68,36.37 190.4,36.09 186.39,36.09 185.2,37.29 184.99,37.29 v2(184.53,36.83) 184.01,37.35 182.07,37.35
SML0DATA: length 18.4
  TOP w0.102: v1(176.38,41.83) 176.38,41.79 PCH.BC33 ; SR253.2 v1(190.2,36.55)
  BOTTOM w0.089: 182.06,37.63 179.71,39.98 178.23,39.98 v1(176.38,41.83)
  BOTTOM w0.102: 182.06,37.63 182.23,37.63 v2(182.58,37.97) 182.98,37.57 185.25,37.57 186.48,36.34 189.99,36.34 v1(190.2,36.55)
SML1_CLK_SIO: length 75.9
  TOP w0.089: PCH.BC43 180.77,40.97 v1(181.12,40.97)
  TOP w0.102: v1(187.16,39.97) 187.38,39.75 SC72.1 188.71,40.41 191,40.41 SR254.2 191.99,40.54 192.65,40.54 193.37,39.82 193.37,37.64 193.5,37.51 193.5,36.35 192.21,35.06 192.06,35.06 190.3,33.3 190.3,27.29 191.48,26.11 191.48,16.92 v1(193.65,14.75) ; v1(218.54,26.47) 218.54,26.04 218.94,25.64 U104.26
  BOTTOM w0.089: v1(181.12,40.97) 183.51,40.97
  BOTTOM w0.102: v1(218.54,26.47) 218.54,26.2 214.96,22.62 214.64,22.3 212.52,22.3 206.54,16.31 206.54,15.7 203.9,13.06 200.48,13.06 199.95,13.6 197.39,13.6 196.02,14.97 193.87,14.97 v1(193.65,14.75) ; v1(187.16,39.97) v2(186.4,40.73) 186.16,40.97 183.51,40.97
SML1_DATA_SIO: length 79.3
  TOP w0.089: PCH.BF38 178.07,39.13 179.23,37.97
  TOP w0.102: SC90.1 187.41,37.81 v1(187.15,38.07) ; U104.25 218.54,25.75 217.95,26.34 v1(217.95,27) ; 179.59,37.8 179.41,37.8 179.23,37.97 ; v1(190.7,37.74) 190.92,37.74 SR255.2 ; v1(192.87,14.75) 192.87,15.25 191.27,16.84 191.27,26.03 190.09,27.21 190.09,33.38 191.98,35.27 192.13,35.27 193.08,36.22 v1(193.08,37.16)
  TOP w0.121: 179.59,37.8 186.87,37.8 v1(187.15,38.07)
  BOTTOM w0.102: v1(217.95,27) 217.95,25.9 214.76,22.71 214.76,22.71 214.55,22.5 212.42,22.5 206.33,16.41 206.33,15.78 203.82,13.27 200.57,13.27 200.02,13.81 197.46,13.81 196.11,15.17 193.28,15.17 v1(192.87,14.75) ; v1(193.08,37.16) 193.08,37.57 192.9,37.74 v1(190.7,37.74) 190.53,37.57 v2(189.28,37.57) 187.66,37.57 v1(187.15,38.07)
SPI1_MISO: length 10.8
  TOP w0.102: UC2.2 v1(102.16,31.1) 102.16,31.68 104.04,33.56 104.04,36.45 104.44,36.86 UCR14.2
  BOTTOM w0.102: v2(102.9,31.18) 102.83,31.1 v1(102.16,31.1)
SPI1_MISO_C: length 2.5
  TOP w0.102: UCR14.1 108.43,36.86 108.84,37.27 U15.16
SPI1_MOSI: length 4.6
  TOP w0.102: v1(104.7,33.85) UC2.5 105.45,35.65 105.77,35.97 UCR13.2
  BOTTOM w0.102: v2(105.41,33.85) v1(104.7,33.85)
SPI1_MOSI_C: length 2.7
  TOP w0.102: UCR13.1 108.13,35.97 108.93,36.77 U15.17
SPI1_NSS: length 10.9
  TOP w0.102: UC2.1 v1(100.89,31.11) 100.89,32.77 102.77,34.65 102.77,36.73 103.49,37.45 103.49,38.07 UCR24.2
  BOTTOM w0.102: v2(100.14,31.22) 100.24,31.11 v1(100.89,31.11)
SPI1_NSS_C: length 8.5
  TOP w0.102: U15.14 107.66,38.27 106.83,39.09 105.67,39.09 v1(105.56,38.98) 105.27,38.68 UCR24.1
  BOTTOM w0.102: v2(102.64,39.04) 102.92,38.76 105.34,38.76 v1(105.56,38.98)
SPI1_SCK: length 5
  TOP w0.102: UCR15.2 104.1,37.35 103.43,36.68 UC2.6 v1(103.43,33.85)
  BOTTOM w0.102: v2(102.65,33.84) 102.66,33.85 v1(103.43,33.85)
SPI1_SCK_C: length 11.9
  TOP w0.102: UCR15.1 105.29,37.8 v1(106.04,38.54) 106.77,38.54 107.54,37.77 U15.15
  BOTTOM w0.102: v1(106.04,38.54) 102.85,38.54 102.44,38.54 102.41,38.57 100.89,38.57 100.52,38.94 v2(99.84,38.94)
SPI_CLK: length 34.5
  TOP w0.102: SR29.1 180.87,30.6 187.78,23.69 F3R8.1 187.6,21.39 187.38,21.39 183.08,17.09 183.08,14.15 181.81,12.88 181.56,12.88 181.38,13.06 181.38,13.54 181.18,13.74 181.03,13.74 180.8,13.51 180.8,8.14 E16.9
SPI_CLK_L500MIL: length 12.3
  TOP w0.089: 174.78,37.97 173.54,39.21 173.23,39.62 173.23,39.81 173.27,39.94 PCH.BE29
  TOP w0.102: 174.78,37.97 176.43,36.32 176.65,36.32 177.36,35.61 179.59,35.61 v1(180.56,34.64) 180.87,34.33 SR29.2
  BOTTOM w0.102: v2(180.69,33.89) 180.69,34.51 v1(180.56,34.64)
SPI_CS0#: length 52
  TOP w0.102: E16.3 185.99,7.33 185.99,7.86 186.21,8.08 187.43,8.08 187.73,8.38 187.73,9.26 F3R4.1 187.3,12.3 187.45,12.45 187.7,12.45 187.83,12.32 187.83,11.08 187.95,10.96 188.22,10.96 188.34,11.08 188.34,13.34 188.65,13.65 188.65,23.71 182.75,29.6 182.75,29.85 182.88,29.97 183.13,29.97 184.4,28.7 184.66,28.7 184.78,28.82 184.78,28.96 183.26,30.48 182.29,30.48 182.14,30.63 182.14,33.74 179.84,36.04 178.13,36.04 177.24,36.93 176.09,36.93 174.86,38.16 174.85,38.16 173.71,39.3 173.71,39.51 PCH.BF28
SPI_CS0#_L500MIL: length 10.9
  TOP w0.102: SR27.2 178.13,34.52 178.08,34.57 v1(177.47,34.57) 177.17,34.87 177.17,34.96 175.66,36.47 174.75,36.47 174.17,37.06 174.17,37.54 173.84,37.87 173.35,37.87 172.79,38.44 172.79,39.36 172.99,39.8 PCH.BF27
  BOTTOM w0.102: v1(177.47,34.57) 177.47,35.03 177.57,35.13 v2(177.57,35.53)
SPI_CS#: length 51.5
  TOP w0.102: v1(41.4,152.63) 43.61,150.42 43.61,144.27 42.97,143.63 U4.7 ; v1(37.01,185.53) 37.01,185.52 37.72,184.81 F3U2.1
  BOTTOM w0.102: v1(41.4,152.63) 39.99,154.04 39.99,155.69 38.99,156.69 38.99,158.32 37.58,159.73 37.58,163.25 35.23,165.6 35.23,168.61 v2(34.56,169.27) 34.28,169.56 34.28,176.64 36.47,178.84 36.47,182.3 37.01,182.83 v1(37.01,185.53)
SPI_DI: length 53
  TOP w0.102: 38.99,183.32 38.99,184.38 37.11,186.26 v1(36.93,186.26) ; U4.8 42.86,144.13 43.26,144.53 43.26,150.03 v1(41.4,151.89)
  BOTTOM w0.102: v1(41.4,151.89) 38.63,154.66 38.63,158.17 37.22,159.58 37.22,163.11 34.14,166.19 v2(34.14,167.41) 33.92,167.63 33.92,176.8 36.09,178.97 36.09,182.42 36.4,182.72 36.4,185.72 v1(36.93,186.26)
SPI_IO2: length 37.9
  TOP w0.102: SR31.1 178.83,30.99 178.83,30.97 183.54,26.26 183.54,23.41 F3R21.1 182.33,22.52 182.22,22.4 182.22,22.09 176.5,16.37 v1(176.5,16.24) 175.59,15.33 175.59,11.88 176.7,10.77 176.7,8.86 F3R3.1 176.2,8.37 176.2,6.83 175.17,5.8 F3R12.2 175.87,4.85 176.13,4.59 E16.12
  BOTTOM w0.102: v2(175.77,16.24) v1(176.5,16.24)
SPI_IO2_L500MIL: length 11.8
  TOP w0.102: PCH.BF26 172.38,39.68 172.38,37.34 174.09,35.64 v1(174.6,35.64) 174.78,35.81 175.67,35.81 176.61,34.87 176.61,34.34 177.19,33.76 SR31.2
  BOTTOM w0.102: v1(174.6,35.64) 174.6,35.38 175.51,34.47 v2(176.2,34.47)
SPI_IO2_XDP: length 289
  TOP w0.102: v1(156.51,3.96) 157.43,3.04 172.52,3.04 F3R12.1 ; v1(110.85,31.34) 108.2,28.7 108.2,26.59 109.97,24.83 116.52,24.83 117.17,24.17 117.17,23.67 118.44,22.4 118.44,18.97 119.32,18.09 119.32,17.47 120.19,16.6 123.11,16.6 125.59,14.12 129.07,14.12 136.75,6.44 144.47,6.44 145.01,5.91 149.46,5.91 150.14,5.22 150.14,4.61 150.87,3.87 154.17,3.87 v1(155.35,5.05) ; v1(28.5,54.97) 29.52,54.97 34.77,60.22 34.77,75.56 39.24,80.03 39.24,87.36 40.34,88.46 40.34,89.68 48.22,97.56 48.22,101.37 50.7,103.85 52.17,103.85 52.82,104.5 69.79,104.5 71.97,106.68 78.95,106.68 80.56,105.07 81.78,105.07 85.72,101.13 85.72,97.75 86.72,96.76 87.55,96.76 PD3.1
  BOTTOM w0.102: v1(28.5,54.97) 27.98,54.44 27.98,49.82 31.52,46.28 31.52,44.12 v2(32.87,42.77) 34.7,40.94 35.74,40.94 44.28,32.4 60.09,32.4 60.8,31.7 64.05,31.7 64.37,32.02 88.91,32.02 89.63,31.3 89.76,31.17 97.02,31.17 97.78,30.4 109.91,30.4 v1(110.85,31.34) ; v1(156.51,3.96) 156.51,3.96 155.42,5.05 v1(155.35,5.05)
SPI_IO3: length 34.5
  TOP w0.102: E16.11 177.25,7.13 178.53,8.41 179.43,8.41 180.31,9.3 180.31,13.71 181.28,14.68 182.3,14.68 182.6,14.99 182.6,17.29 187.25,21.94 187.25,23.54 187.13,23.66 F3R14.1 186.18,24.3 186.18,24.61 179.96,30.83 SR30.1
SPI_IO3_L500MIL: length 11.9
  TOP w0.102: PCH.BD27 172.72,40.77 v1(173.08,41.12) ; v1(178.46,35.03) 178.46,34.91 179.34,34.04 179.35,34.04 SR30.2
  BOTTOM w0.089: 174.52,38.03 173.98,38.57 173.98,39.66 v2(173.28,40.36)
  BOTTOM w0.102: 174.52,38.03 176.26,36.28 177.52,36.28 178.46,35.35 v1(178.46,35.03) ; v1(173.08,41.12) 173.28,40.92 v2(173.28,40.36)
SPI_MISO: length 37
  TOP w0.102: v1(185.85,18.9) 185.73,18.9 183.57,16.74 183.57,12.83 182.52,11.79 182.52,9.25 182.13,8.85 F3R10.1 181.46,7.82 181.25,7.61 E16.7 ; v1(182.73,18.59) 183.26,18.59 186.33,21.67 186.33,23.52 186.19,23.66 F3R20.1 185.85,24.61 179.04,31.42 SR28.1
  BOTTOM w0.102: v1(185.85,18.9) 183.79,18.9 183.48,18.59 v1(182.73,18.59)
SPI_MISO_L500MIL: length 13
  TOP w0.102: PCH.BE27 172.75,40.16 172.74,40.12 172.74,39.71 172.57,39.35 172.57,38.09 173.05,37.62 173.05,37.41 v1(174.18,36.28) 175.53,36.28 176.91,34.9 176.91,34.47 177.63,33.74 177.63,33.16 177.8,32.99 178.6,32.99 SR28.2
  BOTTOM w0.102: v2(173.91,37.19) 173.91,36.55 v1(174.18,36.28)
