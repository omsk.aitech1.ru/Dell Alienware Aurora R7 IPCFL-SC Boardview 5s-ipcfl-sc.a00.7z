# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Nets (continued)
+3P3VSB: AR229.1 E16.8 ECR105.1 F3CB3.1 F3CB4.1 F3R3.2 F3R6.2 F3R10.2 F3U1.8(VCC) J60.2(3.3V_2) J60.4(3.3V_1) J60.72(3.3V_3) J60.74(3.3V_4) M2C1.1 M2C2.1 M2C3.1 M2C4.1 M2C5.1 M2C6.1 M2C49.1 M2C50.1 MQ23.2(SOURCE) O2CB11.1 O2R20.1 OR22.2 OR29.1 OR35.2 OR53.2 OR56.1 OR57.1 OR65.1 P217.2 PC231.1 PC640679.1 PCH.AP5(VCCPRIM_3P3_1) PCH.BC15(VCCHDA) PCH.BC20(VCCRTCPRIM_3P3) PCH.BC31(VCCPGPPA) PCH.BD45(VCCPGPPD_1) PCH.BE40(VCCPGPPBCH_1) PCH.BE44(VCCPGPPD_3) PCH.BE45(VCCPGPPD_2) PCH.BF3(VCCPRIM_3P3_3) PCH.BF42(VCCPGPPBCH_2) PCH.BG3(VCCPRIM_3P3_2) PCH.BG4(VCCPRIM_3P3_4) PCH.BG41(VCCSPI_1) PCH.BG42(VCCSPI_3) PCH.BG43(VCCSPI_2) PD1.1(ANODE) PQ691.3(DRAIN) PQ9786.2(SOURCE) PR162.1 PR167.1 PR234.1 PR341.1 PR432.1 PR6506.1 PR70196.1 PR70213.1 PR70244.1 PR70245.1 PR70256.1 R27.1 R31.1 R69686.1 R69687.1 RFC117.1 RN23.2(4) RN23.4 RN23.6(4) RN23.8(4) RN24.2(4) RN24.4 RN24.6(4) RN24.8(4) RN25.2(4) RN25.4 RN25.6(4) RN25.8(4) RN26.2(4) RN26.4 RN26.6(4) RN26.8(4) SC172.1 SCB3.1 SCB10.1 SCB21.1 SCB25.1 SCB28.1 SCB30.1 SCB118.1 SCB120.1 SLOT1.B10(3.3VAUX) SLOT2.B10(3.3VAUX) SLOT3.B10(3.3VAUX) SLOT4.B10(3.3VAUX) SR14.2 SR15.1 SR20.1 SR54.2 SR70.1 SR115.1 SR129.1 SR250.1 SR251.1 SR252.1 SR253.1 SR254.1 SR255.1 SR256.1 SR257.1 SR268.1 SR275.1 SR277.1 SR278.1 SR370.1 SR443.1 SR678.1 SR839.1 SR7696.1 SR7697.1 SR7698.1 SR7702.1 SR7705.1 SR7706.1 SR7707.1 SR7748.1 SR7769.1 SR7778.1 SR7779.1 U104.27(V3_S5) UF6.1 XC89.1 XC93.1 XC131.1
+BAT_R: D20.2(ANODE2) SR100.2
+BATT: D20.3(CATHODE) O2CB7.1 PCH.BC22(VCCRTC) SC101.1 SCB29.1 SCB35.1 SR101.1 SR102.1 SR364.1 U104.21(VBAT)
+CPUIO_DRV_D: PC155.1 PR127.1 PR128.1 PR129.1 PU5.5(DRV)
+CPUIO_DRVR_D: PC153.2 PQ19.4(G) PR127.2
+CPUIO_FB_A: PC155.2 PC158.2 PC160.2 PR132.2 PR133.1 PR312.1 PU5.3(FB)
+CPUIO_FBR_A: PC160.1 PR130.2 PR132.1 PR313.1
+CPUIO_RC1: PC158.1 PR128.2
+CPUIO_RC2: PC159.1 PR129.2
+CPUIO_SS: PC154.1 PU5.4(SS)
+USB_TYPEC: J_TYPEC.A4(VBUS_2) J_TYPEC.A9(VBUS_1) J_TYPEC.B4(VBUS_3) J_TYPEC.B9(VBUS_4) TUC21.1 TUC22.1 TUCE1.1 UU54.1(OUT)
+VCORE: PC1.1 PC2.1 PC3.1 PC4.1 PC5.1 PC6.1 PC606.1 PC614.1 PC5904.1 PC5914.1 PC6201.1 PC6202.1 PC6203.1 PC6204.1 PC6205.1 PC6206.1 PC6207.1 PC6208.1 PC6209.1 PC6210.1 PC6211.1 PC6212.1 PC6213.1 PC6214.1 PC6215.1 PC6216.1 PC6217.1 PC6218.1 PC6219.1 PC6220.1 PC6237.1 PC6238.1 PC6239.1 PC6240.1 PC640625.1 PC640626.1 PC640627.1 PC640628.1 PC640629.1 PC640630.1 PC640689.1 PC640690.1 PC640691.1 PC640692.1 PCE6201.1 PCE6202.1 PCE6203.1 PCE6204.1 PCE6205.1 PCE6211.1 PJP10.1 PJP12.1 PJP592.1 PJP594.1 PL591.2 PL592.2 PL601.2 PL602.2 PR621.2 PT41.1 PT42.1 PT43.1 PT44.1 PT45.1 PT46.1 PT47.1 PT48.1 PT49.1 PT50.1 XU1.A25(VCC_1) XU1.A26(VCC_2) XU1.A27(VCC_3) XU1.A28(VCC_4) XU1.A29(VCC_5) XU1.A30(VCC_6) XU1.AJ11(VCC_7) XU1.AJ12(VCC_8) XU1.AJ13(VCC_9) XU1.AJ14(VCC_10) XU1.AJ15(VCC_11) XU1.AJ16(VCC_12) XU1.AJ17(VCC_13) XU1.AJ18(VCC_14) XU1.AJ19(VCC_15) XU1.AJ20(VCC_16) XU1.AJ21(VCC_17) XU1.AJ25(VCC1) XU1.AJ26(VCC2) XU1.AJ27(VCC3) XU1.AJ28(VCC4) XU1.AJ29(VCC5) XU1.AK21(VCC6) XU1.B25(VCC_19) XU1.B27(VCC_20) XU1.B29(VCC_21) XU1.B31(VCC_22) XU1.B32(VCC_23) XU1.B33(VCC_24) XU1.B34(VCC_25) XU1.B35(VCC_26) XU1.B36(VCC_27) XU1.B37(VCC_28) XU1.C25(VCC_29) XU1.C26(VCC_30) XU1.C27(VCC_31) XU1.C28(VCC_32) XU1.C29(VCC_33) XU1.C30(VCC_34) XU1.C32(VCC_35) XU1.C34(VCC_36) XU1.C36(VCC_37) XU1.D25(VCC_38) XU1.D27(VCC_39) XU1.D29(VCC_40) XU1.D31(VCC_41) XU1.D32(VCC_42) XU1.D33(VCC_43) XU1.D34(VCC_44) XU1.D35(VCC_45) XU1.D36(VCC_46) XU1.E24(VCC_47) XU1.E25(VCC_48) XU1.E26(VCC_49) XU1.E27(VCC_50) XU1.E28(VCC_51) XU1.E29(VCC_52) XU1.E30(VCC_53) XU1.E32(VCC_54) XU1.E34(VCC_55) XU1.E36(VCC_56) XU1.F23(VCC_57) XU1.F24(VCC_58) XU1.F25(VCC_59) XU1.F27(VCC_60) XU1.F29(VCC_61) XU1.F31(VCC_62) XU1.F32(VCC_63) XU1.F33(VCC_64) XU1.F34(VCC_65) XU1.F35(VCC7) XU1.F37(VCC8) XU1.G23(VCC_66) XU1.G24(VCC_67) XU1.G25(VCC_68) XU1.G26(VCC_69) XU1.G27(VCC_70) XU1.G28(VCC_71) XU1.G29(VCC_72) XU1.G30(VCC_73) XU1.G32(VCC_74) XU1.G34(VCC9) XU1.G35(VCC10) XU1.H22(VCC_75) XU1.H23(VCC_76) XU1.H25(VCC_77) XU1.H27(VCC_78) XU1.H29(VCC_79) XU1.H31(VCC_80) XU1.H32(VCC_81) XU1.H33(VCC11) XU1.H34(VCC12) XU1.J21(VCC_82) XU1.J22(VCC_83) XU1.J23(VCC_84) XU1.J24(VCC_85) XU1.J25(VCC_86) XU1.J26(VCC_87) XU1.J27(VCC_88) XU1.J28(VCC_89) XU1.J29(VCC_90) XU1.J30(VCC_91) XU1.J31(VCC_92) XU1.J33(VCC14) XU1.J35(VCC16) XU1.K16(VCC_93) XU1.K18(VCC_94) XU1.K20(VCC_95) XU1.K21(VCC_96) XU1.K23(VCC_97) XU1.K25(VCC_98) XU1.K27(VCC_99) XU1.K29(VCC_100) XU1.K31(VCC_101) XU1.K32(VCC13) XU1.K34(VCC17) XU1.L14(VCC_102) XU1.L15(VCC_103) XU1.L16(VCC_104) XU1.L17(VCC_105) XU1.L18(VCC_106) XU1.L19(VCC_107) XU1.L20(VCC_108) XU1.L21(VCC_109) XU1.L22(VCC_110) XU1.L23(VCC_111) XU1.L24(VCC_112) XU1.L25(VCC_113) XU1.L26(VCC_114) XU1.L27(VCC_115) XU1.L28(VCC_116) XU1.L29(VCC_117) XU1.L30(VCC_118) XU1.L31(VCC15) XU1.L33(VCC19) XU1.M13(VCC_119) XU1.M14(VCC_120) XU1.M16(VCC_121) XU1.M18(VCC_122) XU1.M20(VCC_123) XU1.M22(VCC_124) XU1.M24(VCC_125) XU1.M26(VCC_126) XU1.M28(VCC_127) XU1.M30(VCC_128) XU1.M32(VCC18)
+VCORE_SENSE+_A: PJP621.1 PR621.1 PR5844.1
+VCORE_SENSE-_A: PC5815.1 PC5819.2 PJP622.1 PR622.1 PU581.13(RGND)
+VTT_DDR: CON_XMM1.77(VTT<1>) CON_XMM1.221(VTT<0>) CON_XMM2.77(VTT<1>) CON_XMM2.221(VTT<0>) CON_XMM3.77(VTT<1>) CON_XMM3.221(VTT<0>) CON_XMM4.77(VTT<1>) CON_XMM4.221(VTT<0>) D4CB1.1 D4CB2.1 D4CB5.1 D4CB6.1 D4CB9.1 D4CB10.1 D4CB13.1 D4CB14.1 PC481.1 PU80.4(VOUT) RFC101.1 RFC103.1 RFC106.1 RFC109.1
+VTT_DDR_REF: PC485.1 PQ80.3(DRAIN) PR125.2 PR126.1 PU80.3(REFEN)
A1142_CLKREQ#: PCH.BA19(GPP_B7/SRCCLKREQ2#) SR749.1
ALL_SYS_PWRGD: ECQ12.3(COLLECTOR) ECR90.2 PR70238.1
AQ11_B: AQ11.1(BASE) AR50.2
AQ13_B: AQ11.2(EMITTER) AQ13.1(BASE) AQ23.2(EMITTER) AR53.2
AQ13_E: AQ13.2(EMITTER) AR1.1
AQ14_B: AQ14.1(BASE) AR55.2 AR56.1
ASM1142_RXN: PCH.E17(PCIE2_RXN/USB3_8_RXN) UC944.2
ASM1142_RXN_C: U4.57(PTX0N) UC944.1
ASM1142_RXP: PCH.G17(PCIE2_RXP/USB3_8_RXP) UC943.2
ASM1142_RXP_C: U4.56(PTX0P) UC943.1
ASM1142_SMI#: PCH.AP7(GPP_I0/DDPB_HPD0) U4.2(SMI#) UR69695.2
ASM1142_TXN: PCH.B19(PCIE2_TXN/USB3_8_TXN) UC87.2
ASM1142_TXN_C: U4.54(PRX0N) UC87.1
ASM1142_TXP: PCH.C19(PCIE2_TXP/USB3_8_TXP) UC86.2
ASM1142_TXP_C: U4.53(PRX0P) UC86.1
ATX_PWRGD: O2CB12.1 P1R4.2 U104.123(PWRGD_PS)
ATX_PWRGD_PWRCORD: CON4.8(PWR0K) EC22.1 P1R1.2 P1R4.1 PR115.1
AZ_BITCLK: AC22.1 AU1.6(BCLK) SC81.1 SR243.1
AZ_RST#: AR50.1 AU1.11(RESET#) SC80.1 SR244.1
AZ_SDATA_IN0: AR2.1 PCH.BA2(HDA_SDI0)
AZ_SDATA_IN_R: AR2.2 AU1.8(SDATA-IN)
AZ_SDATA_OUT: AU1.5(SDATA-OUT) SC83.1 SR241.1
AZ_SYNC: AU1.10(SYNC) SC82.1 SR242.1
BAT: CON_CBAT.1(+) SR100.1
BEEP: AC1.2 AU1.12(BEEP)
BEEP_R: AC1.1 AC2.1 AR3.2 AR4.1
BOARD_ID_D0: PCH.AC42(GPP_F19/EDP_VDDEN) SR712.1 SR7696.2
BOARD_ID_D1: PCH.AE35(GPP_F20/EDP_BKLTEN) SR711.1 SR7697.2
BOARD_ID_D2: PCH.AE36(GPP_F21/EDP_BKLTCTL) SR545.1 SR7698.2
BPM_0: SR7642.1 XU1.D16(BPM#[0])
BPM_1: SR7643.1 XU1.D17(BPM#[1])
BRT_PWM#: AC195.1 AD22.1(ANODE) P189.11 SR7678.1 U104.2(GP000/PWM4) U104.24(GREEN#/GP007)
BT_ON/OFF#: J60.54(RESERVED/W_DISABLE#2(O)(0/3.3V)) SR714.2
BUZZ: P7.1(+) R36.2
CA_DET: M1R5.2 MQ8.2(GATE) MQ8.3(DRAIN) MQ10.2(GATE) MQ10.5(GATE)
CAP1: C85.1 U104.128(CAP1)
CASE_OPEN_DET#: C93.1 PQ9787.3(DRAIN) U15.25(PB12) UCR31.1 UCR34.2 UCR44.1
CASE_OPEN_DET#_SMI: PCH.BD13(GPD1/ACPRESENT) UCR31.2
CATERR#: C5.1 HR25.1 Q4.1(BASE) XU1.D13(CATERR#)
CC1: J_TYPEC.B5(CC2) U5.13(CC1) U5.14(DFP_CC1)
CC2: J_TYPEC.A5(CC1) U5.10(DFP_CC2) U5.11(CC2)
CC_VCONN: CB4129.1 FC13.1 M2R52.2 PC640682.1 U5.12(VCONN)
CC_VCONN_EN: AR243.1 U5.30(VCONN_EN)
CEN_B: AC178.1 AD18.1(ANODE) AL3.2 J83.42
CEN_JD: AR19.2 J83.43
CEN_MUTE: AQ1.2 AR61.2
CEN_R: AL3.1 AQ1.6 AR205.1 AR207.2
CENTER: AC167.2 AR207.1
CENTER_C: AC167.1 AU1.43(CENTER)
CFAN_PWM1_4P: FC5.1 FD8.1(ANODE1) FR28.1 P29.4
CFAN_PWM_4P: FC2.1 FD1.1(ANODE1) FR2.1 P461.4
CFAN_TACH: FC3.1 FD1.2(ANODE2) FD3.1(CATHODE1) FD3.2(CATHODE2) FR17.1 P461.3
CFAN_TACH1: FC6.1 FD8.2(ANODE2) FD9.1(CATHODE1) FD9.2(CATHODE2) FR29.1 P29.3
CHARGING_CTRL1: PCH.Y35(GPP_G20) U51.6(CTL1) U942691.6(CTL1)
CHARGING_CTRL2: PCH.AC30(GPP_G21) U51.7(CTL2) U942691.7(CTL2)
CHARGING_CTRL3: PCH.R45(GPP_G22) U51.8(CTL3) U942691.8(CTL3)
CI_EN#: OR70.2 P17.2 U15.27(PB14)
CK_24M_BCK: PCH.G2(CLKOUT_CPUNSSC_P) XU1.K9(CLK24P)
CK_24M_BCK#: PCH.G1(CLKOUT_CPUNSSC_N) XU1.J9(CLK24N)
CK_100M_ASM1142: PCH.G7(CLKOUT_PCIE_P2) U4.48(PE_CLKP)
CK_100M_ASM1142#: PCH.H7(CLKOUT_PCIE_N2) U4.49(PE_CLKN)
CK_100M_BCK: PCH.H1(CLKOUT_CPUBCLK_P) XU1.W5(BCLKP)
CK_100M_BCK#: PCH.H2(CLKOUT_CPUBCLK_N) XU1.W4(BCLKN)
CK_100M_LAN: PCH.E4(CLKOUT_PCIE_P4) U10.33(REFCLK_P)
CK_100M_LAN#: PCH.E3(CLKOUT_PCIE_N4) U10.32(REFCLK_N)
CK_100M_M2_A1: J60.47(REFCLKP0) PCH.U2(CLKOUT_PCIE_P12)
CK_100M_M2_A1#: J60.49(REFCLKN0) PCH.U1(CLKOUT_PCIE_N12)
CK_100M_M2_M: PCH.M1(CLKOUT_PCIE_P9) SS4.55(REFCLKP)
CK_100M_M2_M#: PCH.M2(CLKOUT_PCIE_N9) SS4.53(REFCLKN)
CK_100M_PCIE: PCH.J2(CLKOUT_CPUPCIBCLK_P) XU1.W1(PCI_BCLKP)
CK_100M_PCIE#: PCH.J3(CLKOUT_CPUPCIBCLK_N) XU1.W2(PCI_BCLKN)
CK_100M_PE4#_2: PCH.C5(CLKOUT_PCIE_N5) SLOT2.A14(REFCLK-)
CK_100M_PE4#_3: PCH.Y10(CLKOUT_PCIE_N8) SLOT3.A14(REFCLK-)
CK_100M_PE4_2: PCH.C6(CLKOUT_PCIE_P5) SLOT2.A13(REFCLK+)
CK_100M_PE4_3: PCH.Y11(CLKOUT_PCIE_P8) SLOT3.A13(REFCLK+)
CK_100M_PE16: PCH.P7(CLKOUT_PCIE_P0) SLOT1.A13(REFCLK+)
CK_100M_PE16#: PCH.P5(CLKOUT_PCIE_N0) SLOT1.A14(REFCLK-)
CK_100M_PE16#_1: PCH.T8(CLKOUT_PCIE_N6) SLOT4.A14(REFCLK-)
CK_100M_PE16_1: PCH.T7(CLKOUT_PCIE_P6) SLOT4.A13(REFCLK+)
CK_100M_XDP: PCH.L3(CLKOUT_ITPXDP_P) XDP2.40(ITPCLK/HOOK4)
CK_100M_XDP#: PCH.L2(CLKOUT_ITPXDP_N) XDP2.42(ITPCLK#/HOOK5)
CLKOUT_LPC0: SC141.1 SCB68.2 SR92.1 U104.16(PCICLK)
CLKOUT_LPC0_ESPI_CLK: PCH.BE15(GPP_A9/CLKOUT_LPC0/ESPI_CLK) SR92.2
CLKOUT_LPC1: ECR103.1 P118.12 SC147.1 SCB121.2 SR745.1
CLKOUT_LPC1_CLK_R: PCH.AY17(GPP_A10/CLKOUT_LPC1) SR745.2
CLKOUT_LPC1_R: ECR103.2 SCB69.2 U104.7(CLOCKI)
CON_I2C_LED_SCL: SR7776.1 U15.42(PB6) UCR28.2
CON_I2C_LED_SDA: SR7777.1 U15.43(PB7) UCR29.2
CPU_12V: O2Q6.6 OR37.1 U104.108((PWR2_PRSNT)GP056)
CPU_DDI3_AUXN: M1C13.1 XU1.C11(DDI3_AUXN)
CPU_DDI3_AUXP: M1C12.1 XU1.B11(DDI3_AUXP)
CPU_VIDALERT#: HR20.2 XU1.E39(VIDALERT#)
CPU_VIDSCLK: HR17.1 XU1.E38(VIDSCK)
CPU_VIDSOUT: HR18.2 XU1.E40(VIDSOUT)
CPU_VREF_CA_A: D4CB87.1 D4R34.1 XU1.AB40(DDR_VREF_CA)
CPU_VREF_CA_A_R: CON_XMM1.146(VREFCA) CON_XMM3.146(VREFCA) D4C3.1 D4C8.1 D4C21.1 D4C22.1 D4R32.1 D4R33.2 D4R34.2
CPU_VREF_CA_B: D4CB86.1 D4R30.1 XU1.AC39(DDR1_VREF_DQ)
CPUFAN_PWM: FR32.1 FR33.2 U104.47(GP022/PWM1)
CPUFAN_TACH: FD7.3(ANODE) FR35.2 U104.37(TACH1/GP017)
CPUPWRGD: HR86.2 PCH.AL2(PROCPWRGD)
CR7_LED: CR7.1(ANODE) R31.2
CR9_R: CR9.1(ANODE) Q4.3(COLLECTOR) R25.2
CR25_R: CR25.1(ANODE) R27.2
CR26_R: CR26.1(ANODE) R69686.2
CR27_R: CR27.1(ANODE) R69687.2
DCPRTC: PCH.BC27(DCPRTC) SCB36.1
DDPD_HPD: MQ15.2(SOURCE) PCH.AP8(GPP_I2/DDPD_HPD2)
DDPD_HPD_F: J125.18(HOT_PLUG_DETECT) MQ15.3(DRAIN) MR41.1
DDR_VREF_CA_B_R: CON_XMM2.146(VREFCA) CON_XMM4.146(VREFCA) D4C13.1 D4C18.1 D4C23.1 D4C24.1 D4R20.1 D4R21.2 D4R30.2
DDR_VTT_CNTL: PR381.2 XU1.AC36(DDR_VTT_CNTL)
DDR_VTT_CNTL_R: PQ115.1(BASE) PR381.1
DEBUGMODE[0]: LR23.1 U10.5(DEBUGMODE[0])
DET_FIX#: PCH.Y42(GPP_G6/FAN_TACH6) SR673.2 SR7767.1 UCR46.2
DET_OPEN#: PCH.BC11(GPD11/LANPHYPC) PQ9787.1(GATE) SR7768.1 UCR44.2 UCR48.2
DET_PUMP_FAN#: FR36.2 PCH.T44(GPP_G3/FAN_TACH_3) SR7714.2
DEVSLP: APR13.1 PCH.AG41(GPP_F6/DEVSLP4)
DEVSLP_SSD_SLEEP_MODE: APR13.2 SS4.38(DEVSLP)
DIAG_LED#: AC194.1 AD21.1(ANODE) P189.10 SR7677.1 U104.23(YELLOW#/GP006)
DMI_RXN0: PCH.D27(DMI_TXN0) XU1.Y4(DMI_RXN[0])
DMI_RXN1: PCH.B27(DMI_TXN1) XU1.AA5(DMI_RXN[1])
DMI_RXN2: PCH.B28(DMI_TXN2) XU1.AB3(DMI_RXN[2])
DMI_RXN3: PCH.C29(DMI_TXN3) XU1.AC5(DMI_RXN[3])
DMI_RXP0: PCH.C27(DMI_TXP0) XU1.Y3(DMI_RXP[0])
DMI_RXP1: PCH.A28(DMI_TXP1) XU1.AA4(DMI_RXP[1])
DMI_RXP2: PCH.C28(DMI_TXP2) XU1.AB4(DMI_RXP[2])
DMI_RXP3: PCH.B29(DMI_TXP3) XU1.AC4(DMI_RXP[3])
DMI_TXN0: PCH.L27(DMI_RXN0) XU1.AC1(DMI_TXN[0])
DMI_TXN1: PCH.E24(DMI_RXN1) XU1.AD2(DMI_TXN[1])
DMI_TXN2: PCH.G27(DMI_RXN2) XU1.AE1(DMI_TXN[2])
DMI_TXN3: PCH.L29(DMI_RXN3) XU1.AF3(DMI_TXN[3])
DMI_TXP0: PCH.N27(DMI_RXP0) XU1.AC2(DMI_TXP[0])
DMI_TXP1: PCH.G24(DMI_RXP1) XU1.AD3(DMI_TXP[1])
DMI_TXP2: PCH.E26(DMI_RXP2) XU1.AE2(DMI_TXP[2])
DMI_TXP3: PCH.K29(DMI_RXP3) XU1.AF2(DMI_TXP[3])
DONGLE_CTRL_AUX_DN: M1C13.2 MQ10.4(SOURCE)
DONGLE_CTRL_AUX_DP: M1C12.2 MQ10.1(SOURCE)
DP_3P3V_PWR_FUSE: M1F1.1 MQ4.3(DRAIN) PR641.1
DP_AUXN_DP_OUT: J125.17(AUX_CH_N) M1R8.2 MQ10.3(DRAIN) MQ12.6(DRAIN)
DP_AUXP_DP_OUT: J125.15(AUX_CH_P) M1R11.1 MQ10.6(DRAIN) MQ12.4(SOURCE)
DP_CAD_PIN13: J125.13(CONFIG1) M1C35.1 M1D1.1(ANODE) M1R36.1 MQ8.5(GATE)
DP_DDPD_CTRL: M1R4.2 MQ8.6(DRAIN) MQ12.2(GATE) MQ12.5(GATE)
DP_TXN0_RD_OUT: SC65.2 XU1.A14(DDI3_TXN[0])
DP_TXN1_RD_OUT: SC67.2 XU1.B15(DDI3_TXN[1])
DP_TXN2_RD_OUT: SC69.2 XU1.A16(DDI3_TXN[2])
DP_TXN3_RD_OUT: SC153.2 XU1.B17(DDI3_TXN[3])
DP_TXP0_RD_OUT: SC64.2 XU1.B14(DDI3_TXP[0])
DP_TXP1_RD_OUT: SC66.2 XU1.C15(DDI3_TXP[1])
DP_TXP2_RD_OUT: SC68.2 XU1.B16(DDI3_TXP[2])
DP_TXP3_RD_OUT: SC152.2 XU1.C17(DDI3_TXP[3])
DRAM_RESET#: D4R3.1 PCH.BD10(DRAM_RESET#) SC121.1 SR659.2
DRAM_RESET#_R: CON_XMM1.58(RESET_N) CON_XMM2.58(RESET_N) CON_XMM3.58(RESET_N) CON_XMM4.58(RESET_N) D4C1.1 D4R3.2
DUAL_POWER_DISCHARGE: MQ24.2(GATE) MQ24.5(GATE) PQ10.3(DRAIN) PR512.2
EAPD: AR263.1 AU1.47(EAPD/SPDIFI)
ET_PWRBTN#: AD20.1(ANODE) O3R5.2 P189.4
EXP1_TXN0_C: SLOT1.B15(HSON0) XC2.2
EXP1_TXN1_C: SLOT1.B20(HSON1) XC4.2
EXP1_TXN2_C: SLOT1.B24(HSON2) XC6.2
EXP1_TXN3_C: SLOT1.B28(HSON3) XC8.2
EXP1_TXN4_C: SLOT1.B34(HSON4) XC10.2
EXP1_TXN5_C: SLOT1.B38(HSON5) XC12.2
EXP1_TXN6_C: SLOT1.B42(HSON6) XC14.2
EXP1_TXN7_C: SLOT1.B46(HSON7) XC16.2
EXP1_TXN8_C: SLOT4.B15(HSON0) XC113.2
EXP1_TXN9_C: SLOT4.B20(HSON1) XC115.2
EXP1_TXN10_C: SLOT4.B24(HSON2) XC117.2
EXP1_TXN11_C: SLOT4.B28(HSON3) XC119.2
EXP1_TXN12_C: SLOT4.B34(HSON4) XC121.2
EXP1_TXN13_C: SLOT4.B38(HSON5) XC123.2
EXP1_TXN14_C: SLOT4.B42(HSON6) XC125.2
EXP1_TXN15_C: SLOT4.B46(HSON7) XC127.2
EXP1_TXP0_C: SLOT1.B14(HSOP0) XC1.2
EXP1_TXP1_C: SLOT1.B19(HSOP1) XC3.2
EXP1_TXP2_C: SLOT1.B23(HSOP2) XC5.2
EXP1_TXP3_C: SLOT1.B27(HSOP3) XC7.2
EXP1_TXP4_C: SLOT1.B33(HSOP4) XC9.2
EXP1_TXP5_C: SLOT1.B37(HSOP5) XC11.2
EXP1_TXP6_C: SLOT1.B41(HSOP6) XC13.2
EXP1_TXP7_C: SLOT1.B45(HSOP7) XC15.2
EXP1_TXP8_C: SLOT4.B14(HSOP0) XC112.2
EXP1_TXP9_C: SLOT4.B19(HSOP1) XC114.2
EXP1_TXP10_C: SLOT4.B23(HSOP2) XC116.2
EXP1_TXP11_C: SLOT4.B27(HSOP3) XC118.2
EXP1_TXP12_C: SLOT4.B33(HSOP4) XC120.2
EXP1_TXP13_C: SLOT4.B37(HSOP5) XC122.2
EXP1_TXP14_C: SLOT4.B41(HSOP6) XC124.2
EXP1_TXP15_C: SLOT4.B45(HSOP7) XC126.2
EXP_RXN0: SLOT1.A17(HSIN0) XU1.B7(PEG_RXN[0])
EXP_RXN1: SLOT1.A22(HSIN1) XU1.C6(PEG_RXN[1])
EXP_RXN2: SLOT1.A26(HSIN2) XU1.D5(PEG_RXN[2])
EXP_RXN3: SLOT1.A30(HSIN3) XU1.E4(PEG_RXN[3])
EXP_RXN4: SLOT1.A36(HSIN4) XU1.F5(PEG_RXN[4])
EXP_RXN5: SLOT1.A40(HSIN5) XU1.G4(PEG_RXN[5])
EXP_RXN6: SLOT1.A44(HSIN6) XU1.H5(PEG_RXN[6])
EXP_RXN7: SLOT1.A48(HSIN7) XU1.J4(PEG_RXN[7])
EXP_RXN8: SLOT4.A17(HSIN0) XU1.K5(PEG_RXN[8])
EXP_RXN9: SLOT4.A22(HSIN1) XU1.L4(PEG_RXN[9])
EXP_RXN10: SLOT4.A26(HSIN2) XU1.M5(PEG_RXN[10])
EXP_RXN11: SLOT4.A30(HSIN3) XU1.N4(PEG_RXN[11])
EXP_RXN12: SLOT4.A36(HSIN4) XU1.P5(PEG_RXN[12])
EXP_RXN13: SLOT4.A40(HSIN5) XU1.R4(PEG_RXN[13])
EXP_RXN14: SLOT4.A44(HSIN6) XU1.T5(PEG_RXN[14])
EXP_RXN15: SLOT4.A48(HSIN7) XU1.U4(PEG_RXN[15])
EXP_RXP0: SLOT1.A16(HSIP0) XU1.B8(PEG_RXP[0])
EXP_RXP1: SLOT1.A21(HSIP1) XU1.C7(PEG_RXP[1])
EXP_RXP2: SLOT1.A25(HSIP2) XU1.D6(PEG_RXP[2])
EXP_RXP3: SLOT1.A29(HSIP3) XU1.E5(PEG_RXP[3])
EXP_RXP4: SLOT1.A35(HSIP4) XU1.F6(PEG_RXP[4])
EXP_RXP5: SLOT1.A39(HSIP5) XU1.G5(PEG_RXP[5])
EXP_RXP6: SLOT1.A43(HSIP6) XU1.H6(PEG_RXP[6])
EXP_RXP7: SLOT1.A47(HSIP7) XU1.J5(PEG_RXP[7])
EXP_RXP8: SLOT4.A16(HSIP0) XU1.K6(PEG_RXP[8])
EXP_RXP9: SLOT4.A21(HSIP1) XU1.L5(PEG_RXP[9])
EXP_RXP10: SLOT4.A25(HSIP2) XU1.M6(PEG_RXP[10])
EXP_RXP11: SLOT4.A29(HSIP3) XU1.N5(PEG_RXP[11])
EXP_RXP12: SLOT4.A35(HSIP4) XU1.P6(PEG_RXP[12])
EXP_RXP13: SLOT4.A39(HSIP5) XU1.R5(PEG_RXP[13])
EXP_RXP14: SLOT4.A43(HSIP6) XU1.T6(PEG_RXP[14])
EXP_RXP15: SLOT4.A47(HSIP7) XU1.U5(PEG_RXP[15])
EXP_TXN0: XC2.1 XU1.A6(PEG_TXN[0])
EXP_TXN1: XC4.1 XU1.B5(PEG_TXN[1])
EXP_TXN2: XC6.1 XU1.C4(PEG_TXN[2])
EXP_TXN3: XC8.1 XU1.D3(PEG_TXN[3])
EXP_TXN4: XC10.1 XU1.E2(PEG_TXN[4])
EXP_TXN5: XC12.1 XU1.F3(PEG_TXN[5])
EXP_TXN6: XC14.1 XU1.G2(PEG_TXN[6])
EXP_TXN7: XC16.1 XU1.H3(PEG_TXN[7])
EXP_TXN8: XC113.1 XU1.J2(PEG_TXN[8])
EXP_TXN9: XC115.1 XU1.K3(PEG_TXN[9])
EXP_TXN10: XC117.1 XU1.L2(PEG_TXN[10])
EXP_TXN11: XC119.1 XU1.M3(PEG_TXN[11])
EXP_TXN12: XC121.1 XU1.N2(PEG_TXN[12])
EXP_TXN13: XC123.1 XU1.P3(PEG_TXN[13])
EXP_TXN14: XC125.1 XU1.R1(PEG_TXN[14])
EXP_TXN15: XC127.1 XU1.T3(PEG_TXN[15])
EXP_TXP0: XC1.1 XU1.A5(PEG_TXP[0])
EXP_TXP1: XC3.1 XU1.B4(PEG_TXP[1])
EXP_TXP2: XC5.1 XU1.C3(PEG_TXP[2])
EXP_TXP3: XC7.1 XU1.D2(PEG_TXP[3])
EXP_TXP4: XC9.1 XU1.E1(PEG_TXP[4])
EXP_TXP5: XC11.1 XU1.F2(PEG_TXP[5])
EXP_TXP6: XC13.1 XU1.G1(PEG_TXP[6])
EXP_TXP7: XC15.1 XU1.H2(PEG_TXP[7])
EXP_TXP8: XC112.1 XU1.J1(PEG_TXP[8])
EXP_TXP9: XC114.1 XU1.K2(PEG_TXP[9])
EXP_TXP10: XC116.1 XU1.L1(PEG_TXP[10])
EXP_TXP11: XC118.1 XU1.M2(PEG_TXP[11])
EXP_TXP12: XC120.1 XU1.N1(PEG_TXP[12])
EXP_TXP13: XC122.1 XU1.P2(PEG_TXP[13])
EXP_TXP14: XC124.1 XU1.R2(PEG_TXP[14])
EXP_TXP15: XC126.1 XU1.T2(PEG_TXP[15])
F1_U3_SENSE#: PCH.AC33(GPP_G4/FAN_TACH_4) SR671.2 UR69748.2
F2_U3_SENSE#: PCH.AA43(GPP_G0/FAN_TACH_0) SR667.2 UR69747.2
F_AUDIO_DET#: AC72.1 AD8.2(CATHODE) AR229.2 O2R5.1 P23.4
FDT_OVRD#: P217.1 SQ1.3(COLLECTOR) SR240.1
FRAME#_ESPI: P118.10 SR84.1 U104.12(LFRAME#)
FRONT-L: ACE5.2 AR212.2
FRONT-L_C: ACE5.1 AU1.35(FRONT-L)
FRONT-L_MUTE: AQ17.5 AR200.2
FRONT-R: ACE6.2 AR214.2
FRONT-R_C: ACE6.1 AU1.36(FRONT-R)
FRONT-R_MUTE: AQ17.2 AR199.2
FRONT_JD: AR14.2 J83.23
FRONT_L: AC181.1 AD4.1(ANODE) AL8.1 J83.22
FRONT_L_B: AL8.2 AQ17.6 AR212.1 AR226.1
FRONT_R: AC182.1 AD5.1(ANODE) AL10.1 J83.25
FRONT_R_B: AL10.2 AQ17.3 AR214.1 AR225.1
GFX_PWM: FR28.2 FR30.2 U104.48(GP023/PWM2)
GFX_TACH: FD9.3(ANODE) FR29.2 FR31.2 U104.38(TACH2/GP020)
GP042: O2R20.2 U104.76(GP042)
GP043: RN24.7(3) U104.96(DCD1#/GP043)
GP044: RN24.5(3) U104.97(DSR1#/GP044)
GP045: RN24.3 U104.98(RXD1/GP045)
GP046: RN24.1(3) U104.99(RTS1#/GP046)
GP050: RN25.5(3) U104.101(CTS1#/GP050)
GP051: RN25.3 U104.102(DTR1#/GP051)
GP052: RN25.1(3) U104.103(RI1#/GP052)
GP054: OR35.1 U104.106(GP054)
GP105: OR53.1 U104.87(GP105)
GP107: RN26.7(3) U104.89(GP107)
GP125: RN26.5(3) U104.92(GP125)
GP126: RN26.3 U104.93(GP126)
GP127: RN26.1(3) U104.94(SUS_ACK_EN#/GP127)
GPIO_BOOT0: PCH.AM44(GPP_D21) SR7748.2 UCR19.2
GPIO_BOOT0_C: U15.44(BOOT0) UCR19.1 UCR23.1
GPIO_NRST: PCH.AM42(GPP_D22) UCR22.1
GPIO_NRST_C: P311.4(GND) U15.7(NRST) UCC3.1 UCR3.2 UCR22.2 UCR45.1
GPP_A6_SERIRQ: PCH.BC13(GPP_A6/SERIRQ/ESPI_CS1#) SR85.1 SR738.2
GPP_C5: PCH.BC35(GPP_C5/SML0ALERT#) SR256.2
GPP_H12: PCH.BF33(GPP_H12/SML2ALERT#) SR370.2 SR371.1
GPU_RST#: SLOT1.A11(PWRGD) SLOT2.A11(PERST#) SLOT3.A11(PERST#) SLOT4.A11(PWRGD) U104.52(PCI_RST_2#/GP027) XC33.1 XC35.1 XC92.1 XC128.1
GSPI1_MOSI: PCH.AR24(GPP_B22/GSPI1_MOSI) SR15.2
H7_SCREW: H7.2(GND1) H7.3(GND2) H7.4(GND3) H7.5(GND4) H7.6(GND5) H7.7(GND6) H7.8(GND7) H7.9(GND8) HC31.1
H8_SCREW: H8.2(GND1) H8.3(GND2) H8.4(GND3) H8.5(GND4) H8.6(GND5) H8.7(GND6) H8.8(GND7) H8.9(GND8) HC30.1
H_CFG0: HR36.1 XDP2.9(OBSDATA_A0) XU1.H15(CFG[0])
H_CFG1: XDP2.11(OBSDATA_A1) XU1.F15(CFG[1])
H_CFG2: HR615.1 XDP2.15(OBSDATA_A2) XU1.F16(CFG[2])
H_CFG3: SR7622.2 SR7717.2 XDP2.17(OBSDATA_A3) XU1.H16(CFG[3])
H_CFG4: HR616.1 XDP2.27(OBSDATA_B0) XU1.F19(CFG[4])
H_CFG5: HR617.1 XDP2.29(OBSDATA_B1) XU1.H18(CFG[5])
H_CFG6: HR618.1 XDP2.33(OBSDATA_B2) XU1.G21(CFG[6])
H_CFG7: XDP2.35(OBSDATA_B3) XU1.H20(CFG[7])
H_CFG8: HR626.1 XDP2.10(OBSDATA_C0) XU1.G16(CFG[8])
H_CFG9: HR29.2 HR619.1 XDP2.12(OBSDATA_C1) XU1.E16(CFG[9])
H_CFG10: HR620.1 XDP2.16(OBSDATA_C2) XU1.F17(CFG[10])
H_CFG11: XDP2.18(OBSDATA_C3) XU1.H17(CFG[11])
H_CFG12: HR621.1 XDP2.28(OBSDATA_D0) XU1.G20(CFG[12])
H_CFG13: HR622.1 XDP2.30(OBSDATA_D1) XU1.F20(CFG[13])
H_CFG14: XDP2.34(OBSDATA_D2) XU1.F21(CFG[14])
H_CFG15: XDP2.36(OBSDATA_D3) XU1.H19(CFG[15])
H_CFG16: XDP2.6(OBSFN_C1) XU1.E14(CFG[16])
H_CFG17: XDP2.4(OBSFN_C0) XU1.F14(CFG[17])
H_CFG18: XDP2.24(OBSFN_D1) XU1.G18(CFG[18])
H_CFG19: XDP2.22(OBSFN_D0) XU1.F18(CFG[19])
H_CFG_RCOMP: HR31.1 XU1.M11(CFG_RCOMP)
H_DISP_RCOMP: HR6.2 XU1.M9(DISP_RCOMP)
H_PEG_RCOMP: HR4.2 XU1.L7(PEG_RCOMP)
H_PRDY#: HT45.1 SR153.1 XU1.B10(PROC_PRDY#)
H_PREQ#: HR11.2 HT46.1 SR7635.1 XU1.B9(PROC_PREQ#)
H_TCK: HR15.1 HT49.1 PCH.AP3(JTAGX) SR292.2 XDP2.57(TCK0) XU1.F11(PROC_TCK)
H_TDI: HT48.1 PCH.AP2(JTAG_TDI) SR287.2 XDP2.56(TDI) XU1.G12(PROC_TDI)
H_TDO: HR9.2 HT47.1 PCH.AN3(JTAG_TDO) XDP2.52(TDO) XU1.H13(PROC_TDO)
H_THMTRIP#: HR23.2 SR367.2 XU1.D11(THERMTRIP#)
H_THMTRIP#_R: PCH.AH4(THRMTRIP#) SC146.1 SR367.1
H_TMS: HT50.1 PCH.AP4(JTAG_TMS) SR289.2 XDP2.58(TMS) XU1.F13(PROC_TMS)
H_TRIGIN: SR281.2 XU1.D1(PROC_TRIGIN)
H_TRIGOUT: HR78.2 PCH.AJ2(PCH_TRIGIN)
H_TRIGOUT_R: HR78.1 XU1.B3(PROC_TRIGOUT)
H_TRST#: HR14.1 HT51.1 SR280.1 XDP2.54(TRSTN) XU1.F12(PROC_TRST#)
H_VCCPLL_OC: HC27.1 HR70.1 XU1.AJ9(VCCPLL_OC)
HD_LED#: PCH.AJ44(GPP_E8/SATALED#) PQ11.2(GATE) SR7.2
HDA_AZRST#_L500MIL: PCH.BC1(HDA_RST#) SR244.2
HDA_BITCLK_24MHZ_L500MIL: PCH.BB3(HDA_BCLK) SR243.2
HDA_SDO_L500MIL: PCH.BC3(HDA_SDO) SR240.2 SR241.2
HDA_SYNC_L500MIL: PCH.BG6(HDA_SYNC) SR242.2
HDD&SSD_LED+: CR15.1(ANODE) SR17.2
HDD&SSD_LED-: CR15.2(CATHODE) M2R45.1 PQ11.3(DRAIN)
I2C_LED_SCL: PCH.AW44(GPP_C19/I2C1_SCL) SR278.2 SR7660.1
I2C_LED_SDA: PCH.AY35(GPP_C18/I2C1_SDA) SR277.2 SR7659.1
ILM_SEL: PCH.R44(GPP_G23) SR7701.1
ILM_SEL_C: SR7676.2 SR7701.2 U51.4(ILIM_SEL) U942691.4(ILIM_SEL)
INTRU_PS_ON#: MQ35.5(GATE) MQ35.6(DRAIN) OR68.2 UCR36.2
ITP_PMODE: PCH.AR2(ITP_PMODE) SR165.2 XDP2.46(HOOK6/RESET#)
JDREF: AR26.1 AU1.40(JDREF)
KBRST#_ESPI: SR4.2 U104.118(GP063/KBDRST#)
KBRST#_ESPI_R: PCH.AU15(GPP_A0/RCIN#/ESPI_ALERT1#) SC70.1 SR4.1 SR87.2
KCLK: RN23.7(3) U104.113(KCLK)
KDAT: RN23.5(3) U104.114(KDAT)
LAD0_ESPI_IO0: C414.1 PCH.AR15(GPP_A1/LAD0/ESPI_IO0) SR80.1
LAD0_ESPI_IO1: C415.1 PCH.AY15(GPP_A2/LAD1/ESPI_IO1) SR81.1
LAD0_ESPI_IO2: C416.1 PCH.AV17(GPP_A3/LAD2/ESPI_IO2) SR82.1
LAD0_ESPI_IO3: C417.1 PCH.BE14(GPP_A4/LAD3/ESPI_IO3) SR83.2
LAD_ESPI0: P118.2 SR80.2 U104.8(LAD0)
LAD_ESPI1: P118.4 SR81.2 U104.9(LAD1)
LAD_ESPI2: P118.6 SR82.2 U104.10(LAD2)
LAD_ESPI3: P118.8 SR83.1 U104.11(LAD3)
LAN_ACT#: J9.L1(LED1) LC8.1 LC44.1 U10.38(LED[0]) UD8881.2(CATHODE)
LAN_CLKREQ#: PCH.BD22(GPP_B9/SRCCLKREQ4#) SR18.1
LAN_CLKREQ#_R: LR2.2 U10.4(CLKREQN)
LAN_CTR: J9.R1(VCC) LC12.1
LAN_LED1: LC7.1 LR9.1 MQ18.1(GATE) U10.39(LED[1])
LAN_LED1_R: J9.L3(LED3) LR5.2 MQ18.3(DRAIN) UD8878.2(CATHODE)
LAN_LED2: LC6.1 LR4.1 LR10.1 U10.23(LED[2])
LAN_LED2_R: J9.L4(LED4) LR4.2 UD8880.1(ANODE)
LAN_MDI0_N: J9.R3(TD1-) M1U8.2(TMDS_CH1+) M1U8.9(NC3) U10.12(TRXN0)
LAN_MDI0_P: J9.R2(TD1+) M1U8.1(TMDS_CH1-) M1U8.10(NC4) U10.11(TRXP0)
LAN_MDI1_N: J9.R5(TD2-) M1U8.5(TMDS_CH2+) M1U8.6(NC1) U10.15(TRXN1)
LAN_MDI1_P: J9.R4(TD2+) M1U8.4(TMDS_CH2-) M1U8.7(NC2) U10.14(TRXP1)
LAN_MDI2_N: J9.R7(TD3-) M1U9.2(TMDS_CH1+) M1U9.9(NC3) U10.18(TRXN2)
LAN_MDI2_P: J9.R6(TD3+) M1U9.1(TMDS_CH1-) M1U9.10(NC4) U10.17(TRXP2)
LAN_MDI3_N: J9.R9(TD5+) M1U9.5(TMDS_CH2+) M1U9.6(NC1) U10.21(TRXN3)
LAN_MDI3_P: J9.R8(TD4+) M1U9.4(TMDS_CH2-) M1U9.7(NC2) U10.20(TRXP3)
LAN_RXN: LC10.1 PCH.E19(PCIE4_RXN/USB3_10_RXN)
LAN_RXN_C: LC10.2 U10.29(TX_N)
LAN_RXP: LC9.1 PCH.G19(PCIE4_RXP/USB3_10_RXP)
LAN_RXP_C: LC9.2 U10.30(TX_P)
LAN_TXN: LC48.1 PCH.B21(PCIE4_TXN/USB3_10_TXN)
LAN_TXN_C: LC48.2 U10.36(RX_N)
LAN_TXP: LC47.1 PCH.A21(PCIE4_TXP/USB3_10_TXP)
LAN_TXP_C: LC47.2 U10.35(RX_P)
LAN_WAKE#: LR6.1 PCH.BE10(GPD2/LAN_WAKE#) SR365.2
LAN_XTAL_IN: LC4.1 U10.7(XTLO) Y10.1
LAN_XTAL_OUT: LR22.1 U10.8(XTLI)
LAN_Y4_25M: LC5.1 LR22.2 Y10.3
LANWAKE_N: LR6.2 U10.3(WAKEN)
LED_CTRL: PCH.BB44(GPP_D2) SR7702.2 SR7703.1
LED_CTRL_1_C: J9.L2(LED2) LR3.1 UD8879.2(CATHODE)
LED_CTRL_R1: MQ22.1(GATE) SC170.1 SR7703.2
LED_CTRL_R2: MQ22.3(DRAIN) SR7704.1 SR7705.2
LED_CTRL_R3: MQ23.1(GATE) SC171.1 SC172.2 SR7704.2 SR7706.2
LFE: AC168.2 AR208.1
LFE_B: AC177.1 AD17.1(ANODE) AL5.2 J83.45
LFE_C: AC168.1 AU1.44(LFE)
LFE_MUTE: AQ1.5 AR62.2
LFE_R: AL5.1 AQ1.3 AR206.1 AR208.2
LFRAME#_ESPI_CS0#: PCH.BF14(GPP_A5/LFRAME#/ESPI_CS0#) SR84.2
LINE1-L: AC165.2 AR209.2
LINE1-L_C: AC165.1 AU1.23(LINE1-L)
LINE1-R: AC166.2 AR210.2
LINE1-R_C: AC166.1 AU1.24(LINE1-R)
LINE1_JD: AR15.2 J83.33
LINE1_L: AC179.1 AD19.1(ANODE) AL4.1 J83.32
LINE1_L_B: AL4.2 AR209.1
LINE1_R: AC180.1 AD3.1(ANODE) AL6.1 J83.35
LINE1_R_B: AL6.2 AR210.1
LINE2-L: ACE7.2 AR7.1
LINE2-L_C: ACE7.1 AU1.14(LINE2-L)
LINE2-L_MUTE: AQ18.5 AR204.2
LINE2-R: ACE4.2 AR8.1
LINE2-R_C: ACE4.1 AU1.15(LINE2-R)
LINE2-R_MUTE: AQ18.2 AR203.2
LINE2_JD: AR25.2 P23.10
LINE2_L_C: AC74.1 AL18.2 P23.9
LINE2_R_C: AC75.1 AL17.2 P23.5
LP1+: J10.23(2P+) M1U4.2(TMDS_CH1+) M1U4.9(NC3) UL66.1 URN138.2(Y)
LP1-: J10.22(2P-) M1U4.1(TMDS_CH1-) M1U4.10(NC4) UL66.4 URN138.4(Y)
LP2+: J10.13(1P+) M1U4.5(TMDS_CH2+) M1U4.6(NC1) UL65.1 URN137.2(Y)
LP2-: J10.12(1P-) M1U4.4(TMDS_CH2-) M1U4.7(NC2) UL65.4 URN137.4(Y)
LP3+: J10.33(3P+) M1U5.2(TMDS_CH1+) M1U5.9(NC3) UL67.1 URN139.2(Y)
LP3-: J10.32(3P-) M1U5.1(TMDS_CH1-) M1U5.10(NC4) UL67.4 URN139.4(Y)
LP4+: J10.43(4P+) M1U5.5(TMDS_CH2+) M1U5.6(NC1) UL68.1 URN140.2(Y)
LP4-: J10.42(4P-) M1U5.4(TMDS_CH2-) M1U5.7(NC2) UL68.4 URN140.4(Y)
LP5+: J9.U3 M1U3.5(TMDS_CH2+) M1U3.6(NC1) UL8.1 URN126.2(Y)
LP5-: J9.U2 M1U3.4(TMDS_CH2-) M1U3.7(NC2) UL8.4 URN126.4(Y)
LP6+: J9.U7 M1U3.2(TMDS_CH1+) M1U3.9(NC3) UL7.1 URN134.2(Y)
LP6-: J9.U6 M1U3.1(TMDS_CH1-) M1U3.10(NC4) UL7.4 URN134.4(Y)
LP7+: P24.5 UL64.1 URN60.2(Y) UU4.5(TMDS_CH2+) UU4.6(NC1)
LP7-: P24.7 UL64.4 URN60.4(Y) UU4.4(TMDS_CH2-) UU4.7(NC2)
LP9+: P150.2 UL74.1 URN143.2(Y) UU5.1(TMDS_CH1-) UU5.10(NC4)
LP9-: P150.4 UL74.4 URN143.4(Y) UU5.2(TMDS_CH1+) UU5.9(NC3)
LP10+: J133.43(D+4) M1U7.1(TMDS_CH1-) M1U7.10(NC4) UL10.2 URN10.1(X)
LP10-: J133.42(D-4) M1U7.2(TMDS_CH1+) M1U7.9(NC3) UL10.3 URN10.3(X)
LP11+: P150.3 UL70.1 URN144.2(Y) UU5.4(TMDS_CH2-) UU5.7(NC2)
LP11-: P150.5 UL70.4 URN144.4(Y) UU5.5(TMDS_CH2+) UU5.6(NC1)
LP12+: J133.33(D+3) M1U6.2(TMDS_CH1+) M1U6.9(NC3) UL9.2 URN9.1(X)
LP12-: J133.32(D-3) M1U6.1(TMDS_CH1-) M1U6.10(NC4) UL9.3 URN9.3(X)
LP13+: P24.4 UL22.1 URN62.2(Y) UU4.2(TMDS_CH1+) UU4.9(NC3)
LP13-: P24.6 UL22.4 URN62.4(Y) UU4.1(TMDS_CH1-) UU4.10(NC4)
LP14+: J133.23(D+2) M1U7.4(TMDS_CH2-) M1U7.7(NC2) UL75.2 URN130.1(X)
LP14-: J133.22(D-2) M1U7.5(TMDS_CH2+) M1U7.6(NC1) UL75.3 URN130.3(X)
M_CHA_ACT#: CON_XMM1.62(ACT_N) CON_XMM3.62(ACT_N) XU1.AU24(DDR0_MA[15]/DDR0_CAA[8]/DDR0_AC)
M_CHA_ALERT#: CON_XMM1.208(ALERT_N) CON_XMM3.208(ALERT_N) XU1.AT23(DDR0_ALERT#)
M_CHA_BA0: CON_XMM1.81(BA0) CON_XMM3.81(BA0) XU1.AY13(DDR0_BA[0]/DDR0_CAB[4]/DDR0_BA[)
M_CHA_BA1: CON_XMM1.224(BA1) CON_XMM3.224(BA1) XU1.AV15(DDR0_BA[1]/DDR0_CAB[6]/DDR0_BA[)
M_CHA_BG0: CON_XMM1.63(BG0) CON_XMM3.63(BG0) XU1.AW23(DDR0_BA[2]/DDR0_CAA[5]/DDR0_BG[)
M_CHA_BG1: CON_XMM1.207(BG1) CON_XMM3.207(BG1) XU1.AV23(DDR0_MA[14]/DDR0_CAA[9]/DDR0_BG)
M_CHA_CKE0: CON_XMM3.60(CKE0) XU1.AY24(DDR0_CKE[0])
M_CHA_CKE1: CON_XMM3.203(CKE1) XU1.AW24(DDR0_CKE[1])
M_CHA_CKE2: CON_XMM1.60(CKE0) XU1.AV24(DDR0_CKE[2])
M_CHA_CKE3: CON_XMM1.203(CKE1) XU1.AV25(DDR0_CKE[3])
M_CHA_CLK0: CON_XMM3.74(CK0P) XU1.AW18(DDR0_CKP[0])
M_CHA_CLK0#: CON_XMM3.75(CK0N) XU1.AV18(DDR0_CKN[0])
M_CHA_CLK1: CON_XMM3.218(CK1P) XU1.AW17(DDR0_CKP[1])
M_CHA_CLK1#: CON_XMM3.219(CK1N) XU1.AY17(DDR0_CKN[1])
M_CHA_CLK2: CON_XMM1.74(CK0P) XU1.AW16(DDR0_CKP[2])
M_CHA_CLK2#: CON_XMM1.75(CK0N) XU1.AV16(DDR0_CKN[2])
M_CHA_CLK3: CON_XMM1.218(CK1P) XU1.AT16(DDR0_CKP[3])
M_CHA_CLK3#: CON_XMM1.219(CK1N) XU1.AU16(DDR0_CKN[3])
M_CHA_CS#0: CON_XMM3.84(S0_N) XU1.AW12(DDR0_CS#[0])
M_CHA_CS#1: CON_XMM3.89(S1_N) XU1.AU11(DDR0_CS#[1])
M_CHA_CS#2: CON_XMM1.84(S0_N) XU1.AV13(DDR0_CS#[2])
M_CHA_CS#3: CON_XMM1.89(S1_N) XU1.AV10(DDR0_CS#[3])
M_CHA_DQ0: CON_XMM1.148(DQ5) CON_XMM3.148(DQ5) XU1.AE38(DDR0_DQ[0])
M_CHA_DQ1: CON_XMM1.3(DQ4) CON_XMM3.3(DQ4) XU1.AE37(DDR0_DQ[1])
M_CHA_DQ2: CON_XMM1.12(DQ2) CON_XMM3.12(DQ2) XU1.AG38(DDR0_DQ[2])
M_CHA_DQ3: CON_XMM1.157(DQ3) CON_XMM3.157(DQ3) XU1.AG37(DDR0_DQ[3])
M_CHA_DQ4: CON_XMM1.150(DQ1) CON_XMM3.150(DQ1) XU1.AE39(DDR0_DQ[4])
M_CHA_DQ5: CON_XMM1.5(DQ0) CON_XMM3.5(DQ0) XU1.AE40(DDR0_DQ[5])
M_CHA_DQ6: CON_XMM1.10(DQ6) CON_XMM3.10(DQ6) XU1.AG39(DDR0_DQ[6])
M_CHA_DQ7: CON_XMM1.155(DQ7) CON_XMM3.155(DQ7) XU1.AG40(DDR0_DQ[7])
M_CHA_DQ8: CON_XMM1.14(DQ12) CON_XMM3.14(DQ12) XU1.AJ38(DDR0_DQ[8])
M_CHA_DQ9: CON_XMM1.159(DQ13) CON_XMM3.159(DQ13) XU1.AJ37(DDR0_DQ[9])
M_CHA_DQ10: CON_XMM1.168(DQ11) CON_XMM3.168(DQ11) XU1.AL38(DDR0_DQ[10])
M_CHA_DQ11: CON_XMM1.21(DQ14) CON_XMM3.21(DQ14) XU1.AL37(DDR0_DQ[11])
M_CHA_DQ12: CON_XMM1.16(DQ8) CON_XMM3.16(DQ8) XU1.AJ40(DDR0_DQ[12])
M_CHA_DQ13: CON_XMM1.161(DQ9) CON_XMM3.161(DQ9) XU1.AJ39(DDR0_DQ[13])
M_CHA_DQ14: CON_XMM1.23(DQ10) CON_XMM3.23(DQ10) XU1.AL39(DDR0_DQ[14])
M_CHA_DQ15: CON_XMM1.166(DQ15) CON_XMM3.166(DQ15) XU1.AL40(DDR0_DQ[15])
M_CHA_DQ16: CON_XMM1.25(DQ20) CON_XMM3.25(DQ20) XU1.AN38(DDR0_DQ[16]/DDR0_DQ[32])
M_CHA_DQ17: CON_XMM1.27(DQ16) CON_XMM3.27(DQ16) XU1.AN40(DDR0_DQ[17]/DDR0_DQ[33])
M_CHA_DQ18: CON_XMM1.179(DQ19) CON_XMM3.179(DQ19) XU1.AR38(DDR0_DQ[18]/DDR0_DQ[34])
M_CHA_DQ19: CON_XMM1.32(DQ22) CON_XMM3.32(DQ22) XU1.AR37(DDR0_DQ[19]/DDR0_DQ[35])
M_CHA_DQ20: CON_XMM1.170(DQ21) CON_XMM3.170(DQ21) XU1.AN39(DDR0_DQ[20]/DDR0_DQ[36])
M_CHA_DQ21: CON_XMM1.172(DQ17) CON_XMM3.172(DQ17) XU1.AN37(DDR0_DQ[21]/DDR0_DQ[37])
M_CHA_DQ22: CON_XMM1.34(DQ18) CON_XMM3.34(DQ18) XU1.AR39(DDR0_DQ[22]/DDR0_DQ[38])
M_CHA_DQ23: CON_XMM1.177(DQ23) CON_XMM3.177(DQ23) XU1.AR40(DDR0_DQ[23]/DDR0_DQ[39])
M_CHA_DQ24: CON_XMM1.183(DQ25) CON_XMM3.183(DQ25) XU1.AW37(DDR0_DQ[24]/DDR0_DQ[40])
M_CHA_DQ25: CON_XMM1.36(DQ28) CON_XMM3.36(DQ28) XU1.AU38(DDR0_DQ[25]/DDR0_DQ[41])
M_CHA_DQ26: CON_XMM1.190(DQ27) CON_XMM3.190(DQ27) XU1.AV35(DDR0_DQ[26]/DDR0_DQ[42])
M_CHA_DQ27: CON_XMM1.188(DQ31) CON_XMM3.188(DQ31) XU1.AW35(DDR0_DQ[27]/DDR0_DQ[43])
M_CHA_DQ28: CON_XMM1.181(DQ29) CON_XMM3.181(DQ29) XU1.AU37(DDR0_DQ[28]/DDR0_DQ[44])
M_CHA_DQ29: CON_XMM1.38(DQ24) CON_XMM3.38(DQ24) XU1.AV37(DDR0_DQ[29]/DDR0_DQ[45])
M_CHA_DQ30: CON_XMM1.43(DQ30) CON_XMM3.43(DQ30) XU1.AT35(DDR0_DQ[30]/DDR0_DQ[46])
M_CHA_DQ31: CON_XMM1.45(DQ26) CON_XMM3.45(DQ26) XU1.AU35(DDR0_DQ[31]/DDR0_DQ[47])
M_CHA_DQ32: CON_XMM1.97(DQ32) CON_XMM3.97(DQ32) XU1.AY8(DDR0_DQ[32]/DDR1_DQ[0])
M_CHA_DQ33: CON_XMM1.240(DQ37) CON_XMM3.240(DQ37) XU1.AW8(DDR0_DQ[33]/DDR1_DQ[1])
M_CHA_DQ34: CON_XMM1.104(DQ34) CON_XMM3.104(DQ34) XU1.AV6(DDR0_DQ[34]/DDR1_DQ[2])
M_CHA_DQ35: CON_XMM1.249(DQ35) CON_XMM3.249(DQ35) XU1.AU6(DDR0_DQ[35]/DDR1_DQ[3])
M_CHA_DQ36: CON_XMM1.95(DQ36) CON_XMM3.95(DQ36) XU1.AU8(DDR0_DQ[36]/DDR1_DQ[4])
M_CHA_DQ37: CON_XMM1.242(DQ33) CON_XMM3.242(DQ33) XU1.AV8(DDR0_DQ[37]/DDR1_DQ[5])
M_CHA_DQ38: CON_XMM1.102(DQ38) CON_XMM3.102(DQ38) XU1.AW6(DDR0_DQ[38]/DDR1_DQ[6])
M_CHA_DQ39: CON_XMM1.247(DQ39) CON_XMM3.247(DQ39) XU1.AY6(DDR0_DQ[39]/DDR1_DQ[7])
M_CHA_DQ40: CON_XMM1.251(DQ45) CON_XMM3.251(DQ45) XU1.AY4(DDR0_DQ[40]/DDR1_DQ[8])
M_CHA_DQ41: CON_XMM1.108(DQ40) CON_XMM3.108(DQ40) XU1.AV4(DDR0_DQ[41]/DDR1_DQ[9])
M_CHA_DQ42: CON_XMM1.115(DQ42) CON_XMM3.115(DQ42) XU1.AT1(DDR0_DQ[42]/DDR1_DQ[10])
M_CHA_DQ43: CON_XMM1.113(DQ46) CON_XMM3.113(DQ46) XU1.AT2(DDR0_DQ[43]/DDR1_DQ[11])
M_CHA_DQ44: CON_XMM1.253(DQ41) CON_XMM3.253(DQ41) XU1.AV3(DDR0_DQ[44]/DDR1_DQ[12])
M_CHA_DQ45: CON_XMM1.106(DQ44) CON_XMM3.106(DQ44) XU1.AW4(DDR0_DQ[45]/DDR1_DQ[13])
M_CHA_DQ46: CON_XMM1.260(DQ43) CON_XMM3.260(DQ43) XU1.AT4(DDR0_DQ[46]/DDR1_DQ[14])
M_CHA_DQ47: CON_XMM1.258(DQ47) CON_XMM3.258(DQ47) XU1.AT3(DDR0_DQ[47]/DDR1_DQ[15])
M_CHA_DQ48: CON_XMM1.262(DQ53) CON_XMM3.262(DQ53) XU1.AP2(DDR0_DQ[48]/DDR1_DQ[32])
M_CHA_DQ49: CON_XMM1.271(DQ51) CON_XMM3.271(DQ51) XU1.AM4(DDR0_DQ[49]/DDR1_DQ[33])
M_CHA_DQ50: CON_XMM1.117(DQ52) CON_XMM3.117(DQ52) XU1.AP3(DDR0_DQ[50]/DDR1_DQ[34])
M_CHA_DQ51: CON_XMM1.126(DQ50) CON_XMM3.126(DQ50) XU1.AM3(DDR0_DQ[51]/DDR1_DQ[35])
M_CHA_DQ52: CON_XMM1.264(DQ49) CON_XMM3.264(DQ49) XU1.AP4(DDR0_DQ[52]/DDR1_DQ[36])
M_CHA_DQ53: CON_XMM1.124(DQ54) CON_XMM3.124(DQ54) XU1.AM2(DDR0_DQ[53]/DDR1_DQ[37])
M_CHA_DQ54: CON_XMM1.119(DQ48) CON_XMM3.119(DQ48) XU1.AP1(DDR0_DQ[54]/DDR1_DQ[38])
M_CHA_DQ55: CON_XMM1.269(DQ55) CON_XMM3.269(DQ55) XU1.AM1(DDR0_DQ[55]/DDR1_DQ[39])
M_CHA_DQ56: CON_XMM1.128(DQ60) CON_XMM3.128(DQ60) XU1.AK3(DDR0_DQ[56]/DDR1_DQ[40])
M_CHA_DQ57: CON_XMM1.280(DQ63) CON_XMM3.280(DQ63) XU1.AH1(DDR0_DQ[57]/DDR1_DQ[41])
M_CHA_DQ58: CON_XMM1.275(DQ57) CON_XMM3.275(DQ57) XU1.AK4(DDR0_DQ[58]/DDR1_DQ[42])
M_CHA_DQ59: CON_XMM1.135(DQ62) CON_XMM3.135(DQ62) XU1.AH2(DDR0_DQ[59]/DDR1_DQ[43])
M_CHA_DQ60: CON_XMM1.282(DQ59) CON_XMM3.282(DQ59) XU1.AH4(DDR0_DQ[60]/DDR1_DQ[44])
M_CHA_DQ61: CON_XMM1.273(DQ61) CON_XMM3.273(DQ61) XU1.AK2(DDR0_DQ[61]/DDR1_DQ[45])
M_CHA_DQ62: CON_XMM1.137(DQ58) CON_XMM3.137(DQ58) XU1.AH3(DDR0_DQ[62]/DDR1_DQ[46])
M_CHA_DQ63: CON_XMM1.130(DQ56) CON_XMM3.130(DQ56) XU1.AK1(DDR0_DQ[63]/DDR1_DQ[47])
M_CHA_DQS0: CON_XMM1.153(DQS0P) CON_XMM3.153(DQS0P) XU1.AF38(DDR0_DQSP[0])
M_CHA_DQS0#: CON_XMM1.152(DQS0N) CON_XMM3.152(DQS0N) XU1.AF39(DDR0_DQSN[0])
M_CHA_DQS1: CON_XMM1.164(DQS1P) CON_XMM3.164(DQS1P) XU1.AK38(DDR0_DQSP[1])
M_CHA_DQS1#: CON_XMM1.163(DQS1N) CON_XMM3.163(DQS1N) XU1.AK39(DDR0_DQSN[1])
M_CHA_DQS2: CON_XMM1.175(DQS2P) CON_XMM3.175(DQS2P) XU1.AP38(DDR0_DQSP[2]/DDR0_DQSP[4])
M_CHA_DQS2#: CON_XMM1.174(DQS2N) CON_XMM3.174(DQS2N) XU1.AP39(DDR0_DQSN[2]/DDR0_DQSN[4])
M_CHA_DQS3: CON_XMM1.186(DQS3P) CON_XMM3.186(DQS3P) XU1.AV36(DDR0_DQSP[3]/DDR0_DQSP[5])
M_CHA_DQS3#: CON_XMM1.185(DQS3N) CON_XMM3.185(DQS3N) XU1.AU36(DDR0_DQSN[3]/DDR0_DQSN[5])
M_CHA_DQS4: CON_XMM1.245(DQS4P) CON_XMM3.245(DQS4P) XU1.AV7(DDR0_DQSP[4]/DDR1_DQSP[0])
M_CHA_DQS4#: CON_XMM1.244(DQS4N) CON_XMM3.244(DQS4N) XU1.AW7(DDR0_DQSN[4]/DDR1_DQSN[0])
M_CHA_DQS5: CON_XMM1.256(DQS5P) CON_XMM3.256(DQS5P) XU1.AU2(DDR0_DQSP[5]/DDR1_DQSP[1])
M_CHA_DQS5#: CON_XMM1.255(DQS5N) CON_XMM3.255(DQS5N) XU1.AU3(DDR0_DQSN[5]/DDR1_DQSN[1])
M_CHA_DQS6: CON_XMM1.267(DQS6P) CON_XMM3.267(DQS6P) XU1.AN2(DDR0_DQSP[6]/DDR1_DQSP[4])
M_CHA_DQS6#: CON_XMM1.266(DQS6N) CON_XMM3.266(DQS6N) XU1.AN3(DDR0_DQSN[6]/DDR1_DQSN[4])
M_CHA_DQS7: CON_XMM1.278(DQS7P) CON_XMM3.278(DQS7P) XU1.AJ2(DDR0_DQSP[7]/DDR1_DQSP[5])
M_CHA_DQS7#: CON_XMM1.277(DQS7N) CON_XMM3.277(DQS7N) XU1.AJ3(DDR0_DQSN[7]/DDR1_DQSN[5])
M_CHA_MAA0: CON_XMM1.79(A0) CON_XMM3.79(A0) XU1.AW15(DDR0_MA[0]/DDR0_CAB[9]/DDR0_MA[)
M_CHA_MAA1: CON_XMM1.72(A1) CON_XMM3.72(A1) XU1.AU18(DDR0_MA[1]/DDR0_CAB[8]/DDR0_MA[)
M_CHA_MAA2: CON_XMM1.216(A2) CON_XMM3.216(A2) XU1.AU17(DDR0_MA[2]/DDR0_CAB[5]/DDR0_MA[)
M_CHA_MAA3: CON_XMM1.71(A3) CON_XMM3.71(A3) XU1.AV19(DDR0_MA[3])
M_CHA_MAA4: CON_XMM1.214(A4) CON_XMM3.214(A4) XU1.AT19(DDR0_MA[4])
M_CHA_MAA5: CON_XMM1.213(A5) CON_XMM3.213(A5) XU1.AU20(DDR0_MA[5]/DDR0_CAA[0]/DDR0_MA[)
M_CHA_MAA6: CON_XMM1.69(A6) CON_XMM3.69(A6) XU1.AV20(DDR0_MA[6]/DDR0_CAA[2]/DDR0_MA[)
M_CHA_MAA7: CON_XMM1.211(A7) CON_XMM3.211(A7) XU1.AU21(DDR0_MA[7]/DDR0_CAA[4]/DDR0_MA[)
M_CHA_MAA8: CON_XMM1.68(A8) CON_XMM3.68(A8) XU1.AT20(DDR0_MA[8]/DDR0_CAA[3]/DDR0_MA[)
M_CHA_MAA9: CON_XMM1.66(A9) CON_XMM3.66(A9) XU1.AT22(DDR0_MA[9]/DDR0_CAA[1]/DDR0_MA[)
M_CHA_MAA10: CON_XMM1.225(A10) CON_XMM3.225(A10) XU1.AY14(DDR0_MA[10]/DDR0_CAB[7]/DDR0_MA)
M_CHA_MAA11: CON_XMM1.210(A11) CON_XMM3.210(A11) XU1.AU22(DDR0_MA[11]/DDR0_CAA[7]/DDR0_MA)
M_CHA_MAA12: CON_XMM1.65(A12) CON_XMM3.65(A12) XU1.AV22(DDR0_MA[12]/DDR0_CAA[6]/DDR0_MA)
M_CHA_MAA13: CON_XMM1.232(A13) CON_XMM3.232(A13) XU1.AV12(DDR0_MA[13]/DDR0_CAB[0]/DDR0_MA)
M_CHA_MAA14: CON_XMM1.228(A14_WE_N) CON_XMM3.228(A14_WE_N) XU1.AV14(DDR0_WE#/DDR0_CAB[2]/DDR0_MA[14)
M_CHA_MAA15: CON_XMM1.86(A15_CAS_N) CON_XMM3.86(A15_CAS_N) XU1.AY11(DDR0_CAS#/DDR0_CAB[1]/DDR0_MA[1)
M_CHA_MAA16: CON_XMM1.82(A16_RAS_N) CON_XMM3.82(A16_RAS_N) XU1.AW13(DDR0_RAS#/DDR0_CAB[3]/DDR0_MA[1)
M_CHA_ODT0: CON_XMM3.87(ODT0) XU1.AW11(DDR0_ODT[0])
M_CHA_ODT1: CON_XMM3.91(ODT1) XU1.AU14(DDR0_ODT[1])
M_CHA_ODT2: CON_XMM1.87(ODT0) XU1.AU12(DDR0_ODT[2])
M_CHA_ODT3: CON_XMM1.91(ODT1) XU1.AY10(DDR0_ODT[3])
M_CHA_PAR: CON_XMM1.222(PAR) CON_XMM3.222(PAR) XU1.AY15(DDR0_PAR)
M_CHB_ACT#: CON_XMM2.62(ACT_N) CON_XMM4.62(ACT_N) XU1.AU28(DDR1_MA[15]/DDR1_CAA[8]/DDR1_AC)
M_CHB_ALERT#: CON_XMM2.208(ALERT_N) CON_XMM4.208(ALERT_N) XU1.AY25(DDR1_ALERT#)
M_CHB_BA0: CON_XMM2.81(BA0) CON_XMM4.81(BA0) XU1.AL18(DDR1_BA[0]/DDR1_CAB[4]/DDR1_BA[)
M_CHB_BA1: CON_XMM2.224(BA1) CON_XMM4.224(BA1) XU1.AM18(DDR1_BA[1]/DDR1_CAB[6]/DDR1_BA[)
M_CHB_BG0: CON_XMM2.63(BG0) CON_XMM4.63(BG0) XU1.AW28(DDR1_BA[2]/DDR1_CAA[5]/DDR1_BG[)
M_CHB_BG1: CON_XMM2.207(BG1) CON_XMM4.207(BG1) XU1.AY28(DDR1_MA[14]/DDR1_CAA[9]/DDR1_BG)
M_CHB_CKE0: CON_XMM4.60(CKE0) XU1.AY29(DDR1_CKE[0])
M_CHB_CKE1: CON_XMM4.203(CKE1) XU1.AV29(DDR1_CKE[1])
M_CHB_CKE2: CON_XMM2.60(CKE0) XU1.AW29(DDR1_CKE[2])
M_CHB_CKE3: CON_XMM2.203(CKE1) XU1.AU29(DDR1_CKE[3])
M_CHB_CLK0: CON_XMM4.74(CK0P) XU1.AM20(DDR1_CKP[0])
M_CHB_CLK0#: CON_XMM4.75(CK0N) XU1.AM21(DDR1_CKN[0])
M_CHB_CLK1: CON_XMM4.218(CK1P) XU1.AP22(DDR1_CKP[1])
M_CHB_CLK1#: CON_XMM4.219(CK1N) XU1.AP21(DDR1_CKN[1])
M_CHB_CLK2: CON_XMM2.74(CK0P) XU1.AN20(DDR1_CKP[2])
M_CHB_CLK2#: CON_XMM2.75(CK0N) XU1.AN21(DDR1_CKN[2])
M_CHB_CLK3: CON_XMM2.218(CK1P) XU1.AP19(DDR1_CKP[3])
M_CHB_CLK3#: CON_XMM2.219(CK1N) XU1.AP20(DDR1_CKN[3])
M_CHB_CS#0: CON_XMM4.84(S0_N) XU1.AP17(DDR1_CS#[0])
M_CHB_CS#1: CON_XMM4.89(S1_N) XU1.AN15(DDR1_CS#[1])
M_CHB_CS#2: CON_XMM2.84(S0_N) XU1.AN17(DDR1_CS#[2])
M_CHB_CS#3: CON_XMM2.89(S1_N) XU1.AM15(DDR1_CS#[3])
M_CHB_DQ0: CON_XMM2.3(DQ4) CON_XMM4.3(DQ4) XU1.AD34(DDR1_DQ[0]/DDR0_DQ[16])
M_CHB_DQ1: CON_XMM2.148(DQ5) CON_XMM4.148(DQ5) XU1.AD35(DDR1_DQ[1]/DDR0_DQ[17])
M_CHB_DQ2: CON_XMM2.12(DQ2) CON_XMM4.12(DQ2) XU1.AG35(DDR1_DQ[2]/DDR0_DQ[18])
M_CHB_DQ3: CON_XMM2.157(DQ3) CON_XMM4.157(DQ3) XU1.AH35(DDR1_DQ[3]/DDR0_DQ[19])
M_CHB_DQ4: CON_XMM2.150(DQ1) CON_XMM4.150(DQ1) XU1.AE35(DDR1_DQ[4]/DDR0_DQ[20])
M_CHB_DQ5: CON_XMM2.5(DQ0) CON_XMM4.5(DQ0) XU1.AE34(DDR1_DQ[5]/DDR0_DQ[21])
M_CHB_DQ6: CON_XMM2.10(DQ6) CON_XMM4.10(DQ6) XU1.AG34(DDR1_DQ[6]/DDR0_DQ[22])
M_CHB_DQ7: CON_XMM2.155(DQ7) CON_XMM4.155(DQ7) XU1.AH34(DDR1_DQ[7]/DDR0_DQ[23])
M_CHB_DQ8: CON_XMM2.159(DQ13) CON_XMM4.159(DQ13) XU1.AK35(DDR1_DQ[8]/DDR0_DQ[24])
M_CHB_DQ9: CON_XMM2.161(DQ9) CON_XMM4.161(DQ9) XU1.AL35(DDR1_DQ[9]/DDR0_DQ[25])
M_CHB_DQ10: CON_XMM2.21(DQ14) CON_XMM4.21(DQ14) XU1.AK32(DDR1_DQ[10]/DDR0_DQ[26])
M_CHB_DQ11: CON_XMM2.166(DQ15) CON_XMM4.166(DQ15) XU1.AL32(DDR1_DQ[11]/DDR0_DQ[27])
M_CHB_DQ12: CON_XMM2.14(DQ12) CON_XMM4.14(DQ12) XU1.AK34(DDR1_DQ[12]/DDR0_DQ[28])
M_CHB_DQ13: CON_XMM2.16(DQ8) CON_XMM4.16(DQ8) XU1.AL34(DDR1_DQ[13]/DDR0_DQ[29])
M_CHB_DQ14: CON_XMM2.23(DQ10) CON_XMM4.23(DQ10) XU1.AK31(DDR1_DQ[14]/DDR0_DQ[30])
M_CHB_DQ15: CON_XMM2.168(DQ11) CON_XMM4.168(DQ11) XU1.AL31(DDR1_DQ[15]/DDR0_DQ[31])
M_CHB_DQ16: CON_XMM2.170(DQ21) CON_XMM4.170(DQ21) XU1.AP35(DDR1_DQ[16]/DDR0_DQ[48])
M_CHB_DQ17: CON_XMM2.25(DQ20) CON_XMM4.25(DQ20) XU1.AN35(DDR1_DQ[17]/DDR0_DQ[49])
M_CHB_DQ18: CON_XMM2.32(DQ22) CON_XMM4.32(DQ22) XU1.AN32(DDR1_DQ[18]/DDR0_DQ[50])
M_CHB_DQ19: CON_XMM2.177(DQ23) CON_XMM4.177(DQ23) XU1.AP32(DDR1_DQ[19]/DDR0_DQ[51])
M_CHB_DQ20: CON_XMM2.27(DQ16) CON_XMM4.27(DQ16) XU1.AN34(DDR1_DQ[20]/DDR0_DQ[52])
M_CHB_DQ21: CON_XMM2.172(DQ17) CON_XMM4.172(DQ17) XU1.AP34(DDR1_DQ[21]/DDR0_DQ[53])
M_CHB_DQ22: CON_XMM2.34(DQ18) CON_XMM4.34(DQ18) XU1.AN31(DDR1_DQ[22]/DDR0_DQ[54])
M_CHB_DQ23: CON_XMM2.179(DQ19) CON_XMM4.179(DQ19) XU1.AP31(DDR1_DQ[23]/DDR0_DQ[55])
M_CHB_DQ24: CON_XMM2.36(DQ28) CON_XMM4.36(DQ28) XU1.AL29(DDR1_DQ[24]/DDR0_DQ[56])
M_CHB_DQ25: CON_XMM2.38(DQ24) CON_XMM4.38(DQ24) XU1.AM29(DDR1_DQ[25]/DDR0_DQ[57])
M_CHB_DQ26: CON_XMM2.43(DQ30) CON_XMM4.43(DQ30) XU1.AP29(DDR1_DQ[26]/DDR0_DQ[58])
M_CHB_DQ27: CON_XMM2.45(DQ26) CON_XMM4.45(DQ26) XU1.AR29(DDR1_DQ[27]/DDR0_DQ[59])
M_CHB_DQ28: CON_XMM2.183(DQ25) CON_XMM4.183(DQ25) XU1.AM28(DDR1_DQ[28]/DDR0_DQ[60])
M_CHB_DQ29: CON_XMM2.181(DQ29) CON_XMM4.181(DQ29) XU1.AL28(DDR1_DQ[29]/DDR0_DQ[61])
M_CHB_DQ30: CON_XMM2.190(DQ27) CON_XMM4.190(DQ27) XU1.AR28(DDR1_DQ[30]/DDR0_DQ[62])
M_CHB_DQ31: CON_XMM2.188(DQ31) CON_XMM4.188(DQ31) XU1.AP28(DDR1_DQ[31]/DDR0_DQ[63])
M_CHB_DQ32: CON_XMM2.97(DQ32) CON_XMM4.97(DQ32) XU1.AR12(DDR1_DQ[32]/DDR1_DQ[16])
M_CHB_DQ33: CON_XMM2.242(DQ33) CON_XMM4.242(DQ33) XU1.AP12(DDR1_DQ[33]/DDR1_DQ[17])
M_CHB_DQ34: CON_XMM2.102(DQ38) CON_XMM4.102(DQ38) XU1.AM13(DDR1_DQ[34]/DDR1_DQ[18])
M_CHB_DQ35: CON_XMM2.104(DQ34) CON_XMM4.104(DQ34) XU1.AL13(DDR1_DQ[35]/DDR1_DQ[19])
M_CHB_DQ36: CON_XMM2.95(DQ36) CON_XMM4.95(DQ36) XU1.AR13(DDR1_DQ[36]/DDR1_DQ[20])
M_CHB_DQ37: CON_XMM2.240(DQ37) CON_XMM4.240(DQ37) XU1.AP13(DDR1_DQ[37]/DDR1_DQ[21])
M_CHB_DQ38: CON_XMM2.247(DQ39) CON_XMM4.247(DQ39) XU1.AM12(DDR1_DQ[38]/DDR1_DQ[22])
M_CHB_DQ39: CON_XMM2.249(DQ35) CON_XMM4.249(DQ35) XU1.AL12(DDR1_DQ[39]/DDR1_DQ[23])
M_CHB_DQ40: CON_XMM2.251(DQ45) CON_XMM4.251(DQ45) XU1.AP10(DDR1_DQ[40]/DDR1_DQ[24])
M_CHB_DQ41: CON_XMM2.106(DQ44) CON_XMM4.106(DQ44) XU1.AR10(DDR1_DQ[41]/DDR1_DQ[25])
M_CHB_DQ42: CON_XMM2.113(DQ46) CON_XMM4.113(DQ46) XU1.AR7(DDR1_DQ[42]/DDR1_DQ[26])
M_CHB_DQ43: CON_XMM2.115(DQ42) CON_XMM4.115(DQ42) XU1.AP7(DDR1_DQ[43]/DDR1_DQ[27])
M_CHB_DQ44: CON_XMM2.108(DQ40) CON_XMM4.108(DQ40) XU1.AR9(DDR1_DQ[44]/DDR1_DQ[28])
M_CHB_DQ45: CON_XMM2.253(DQ41) CON_XMM4.253(DQ41) XU1.AP9(DDR1_DQ[45]/DDR1_DQ[29])
M_CHB_DQ46: CON_XMM2.258(DQ47) CON_XMM4.258(DQ47) XU1.AR6(DDR1_DQ[46]/DDR1_DQ[30])
M_CHB_DQ47: CON_XMM2.260(DQ43) CON_XMM4.260(DQ43) XU1.AP6(DDR1_DQ[47]/DDR1_DQ[31])
M_CHB_DQ48: CON_XMM2.117(DQ52) CON_XMM4.117(DQ52) XU1.AM10(DDR1_DQ[48])
M_CHB_DQ49: CON_XMM2.262(DQ53) CON_XMM4.262(DQ53) XU1.AL10(DDR1_DQ[49])
M_CHB_DQ50: CON_XMM2.124(DQ54) CON_XMM4.124(DQ54) XU1.AM7(DDR1_DQ[50])
M_CHB_DQ51: CON_XMM2.126(DQ50) CON_XMM4.126(DQ50) XU1.AL7(DDR1_DQ[51])
M_CHB_DQ52: CON_XMM2.119(DQ48) CON_XMM4.119(DQ48) XU1.AM9(DDR1_DQ[52])
M_CHB_DQ53: CON_XMM2.264(DQ49) CON_XMM4.264(DQ49) XU1.AL9(DDR1_DQ[53])
M_CHB_DQ54: CON_XMM2.269(DQ55) CON_XMM4.269(DQ55) XU1.AM6(DDR1_DQ[54])
M_CHB_DQ55: CON_XMM2.271(DQ51) CON_XMM4.271(DQ51) XU1.AL6(DDR1_DQ[55])
M_CHB_DQ56: CON_XMM2.275(DQ57) CON_XMM4.275(DQ57) XU1.AJ6(DDR1_DQ[56])
M_CHB_DQ57: CON_XMM2.128(DQ60) CON_XMM4.128(DQ60) XU1.AJ7(DDR1_DQ[57])
M_CHB_DQ58: CON_XMM2.282(DQ59) CON_XMM4.282(DQ59) XU1.AE6(DDR1_DQ[58])
M_CHB_DQ59: CON_XMM2.135(DQ62) CON_XMM4.135(DQ62) XU1.AF7(DDR1_DQ[59])
M_CHB_DQ60: CON_XMM2.273(DQ61) CON_XMM4.273(DQ61) XU1.AH7(DDR1_DQ[60])
M_CHB_DQ61: CON_XMM2.130(DQ56) CON_XMM4.130(DQ56) XU1.AH6(DDR1_DQ[61])
M_CHB_DQ62: CON_XMM2.280(DQ63) CON_XMM4.280(DQ63) XU1.AE7(DDR1_DQ[62])
M_CHB_DQ63: CON_XMM2.137(DQ58) CON_XMM4.137(DQ58) XU1.AF6(DDR1_DQ[63])
M_CHB_DQS0: CON_XMM2.153(DQS0P) CON_XMM4.153(DQS0P) XU1.AF35(DDR1_DQSP[0]/DDR0_DQSP[2])
M_CHB_DQS0#: CON_XMM2.152(DQS0N) CON_XMM4.152(DQS0N) XU1.AF34(DDR1_DQSN[0]/DDR0_DQSN[2])
M_CHB_DQS1: CON_XMM2.164(DQS1P) CON_XMM4.164(DQS1P) XU1.AL33(DDR1_DQSP[1]/DDR0_DQSP[3])
M_CHB_DQS1#: CON_XMM2.163(DQS1N) CON_XMM4.163(DQS1N) XU1.AK33(DDR1_DQSN[1]/DDR0_DQSN[3])
M_CHB_DQS2: CON_XMM2.175(DQS2P) CON_XMM4.175(DQS2P) XU1.AP33(DDR1_DQSP[2]/DDR0_DQSP[6])
M_CHB_DQS2#: CON_XMM2.174(DQS2N) CON_XMM4.174(DQS2N) XU1.AN33(DDR1_DQSN[2]/DDR0_DQSN[6])
M_CHB_DQS3: CON_XMM2.186(DQS3P) CON_XMM4.186(DQS3P) XU1.AN28(DDR1_DQSP[3]/DDR0_DQSP[7])
M_CHB_DQS3#: CON_XMM2.185(DQS3N) CON_XMM4.185(DQS3N) XU1.AN29(DDR1_DQSN[3]/DDR0_DQSN[7])
M_CHB_DQS4: CON_XMM2.245(DQS4P) CON_XMM4.245(DQS4P) XU1.AN12(DDR1_DQSP[4]/DDR1_DQSP[2])
M_CHB_DQS4#: CON_XMM2.244(DQS4N) CON_XMM4.244(DQS4N) XU1.AN13(DDR1_DQSN[4]/DDR1_DQSN[2])
M_CHB_DQS5: CON_XMM2.256(DQS5P) CON_XMM4.256(DQS5P) XU1.AP8(DDR1_DQSP[5]/DDR1_DQSP[3])
M_CHB_DQS5#: CON_XMM2.255(DQS5N) CON_XMM4.255(DQS5N) XU1.AR8(DDR1_DQSN[5]/DDR1_DQSN[3])
M_CHB_DQS6: CON_XMM2.267(DQS6P) CON_XMM4.267(DQS6P) XU1.AL8(DDR1_DQSP[6])
M_CHB_DQS6#: CON_XMM2.266(DQS6N) CON_XMM4.266(DQS6N) XU1.AM8(DDR1_DQSN[6])
M_CHB_DQS7: CON_XMM2.278(DQS7P) CON_XMM4.278(DQS7P) XU1.AG7(DDR1_DQSP[7])
M_CHB_DQS7#: CON_XMM2.277(DQS7N) CON_XMM4.277(DQS7N) XU1.AG6(DDR1_DQSN[7])
M_CHB_MAA0: CON_XMM2.79(A0) CON_XMM4.79(A0) XU1.AL19(DDR1_MA[0]/DDR1_CAB[9]/DDR1_MA[)
M_CHB_MAA1: CON_XMM2.72(A1) CON_XMM4.72(A1) XU1.AL22(DDR1_MA[1]/DDR1_CAB[8]/DDR1_MA[)
M_CHB_MAA2: CON_XMM2.216(A2) CON_XMM4.216(A2) XU1.AM22(DDR1_MA[2]/DDR1_CAB[5]/DDR1_MA[)
M_CHB_MAA3: CON_XMM2.71(A3) CON_XMM4.71(A3) XU1.AM23(DDR1_MA[3])
M_CHB_MAA4: CON_XMM2.214(A4) CON_XMM4.214(A4) XU1.AP23(DDR1_MA[4])
M_CHB_MAA5: CON_XMM2.213(A5) CON_XMM4.213(A5) XU1.AL23(DDR1_MA[5]/DDR1_CAA[0]/DDR1_MA[)
M_CHB_MAA6: CON_XMM2.69(A6) CON_XMM4.69(A6) XU1.AW26(DDR1_MA[6]/DDR1_CAA[2]/DDR1_MA[)
M_CHB_MAA7: CON_XMM2.211(A7) CON_XMM4.211(A7) XU1.AY26(DDR1_MA[7]/DDR1_CAA[4]/DDR1_MA[)
M_CHB_MAA8: CON_XMM2.68(A8) CON_XMM4.68(A8) XU1.AU26(DDR1_MA[8]/DDR1_CAA[3]/DDR1_MA[)
M_CHB_MAA9: CON_XMM2.66(A9) CON_XMM4.66(A9) XU1.AW27(DDR1_MA[9]/DDR1_CAA[1]/DDR1_MA[)
M_CHB_MAA10: CON_XMM2.225(A10) CON_XMM4.225(A10) XU1.AP18(DDR1_MA[10]/DDR1_CAB[7]/DDR1_MA)
M_CHB_MAA11: CON_XMM2.210(A11) CON_XMM4.210(A11) XU1.AU27(DDR1_MA[11]/DDR1_CAA[7]/DDR1_MA)
M_CHB_MAA12: CON_XMM2.65(A12) CON_XMM4.65(A12) XU1.AV27(DDR1_MA[12]/DDR1_CAA[6]/DDR1_MA)
M_CHB_MAA13: CON_XMM2.232(A13) CON_XMM4.232(A13) XU1.AR15(DDR1_MA[13]/DDR1_CAB[0]/DDR1_MA)
M_CHB_MAA14: CON_XMM2.228(A14_WE_N) CON_XMM4.228(A14_WE_N) XU1.AL17(DDR1_WE#/DDR1_CAB[2]/DDR1_MA[14)
M_CHB_MAA15: CON_XMM2.86(A15_CAS_N) CON_XMM4.86(A15_CAS_N) XU1.AP16(DDR1_CAS#/DDR1_CAB[1]/DDR1_MA[1)
M_CHB_MAA16: CON_XMM2.82(A16_RAS_N) CON_XMM4.82(A16_RAS_N) XU1.AN18(DDR1_RAS#/DDR1_CAB[3]/DDR1_MA[1)
M_CHB_ODT0: CON_XMM4.87(ODT0) XU1.AM16(DDR1_ODT[0])
M_CHB_ODT1: CON_XMM4.91(ODT1) XU1.AL16(DDR1_ODT[1])
M_CHB_ODT2: CON_XMM2.87(ODT0) XU1.AP15(DDR1_ODT[2])
M_CHB_ODT3: CON_XMM2.91(ODT1) XU1.AL15(DDR1_ODT[3])
M_CHB_PAR: CON_XMM2.222(PAR) CON_XMM4.222(PAR) XU1.AL20(DDR1_PAR)
MAIN POWER DISCHARGE: MQ21.2(GATE) MQ21.5(GATE) MQ25.2(GATE) MQ25.3(DRAIN) MQ26.2(GATE) MQ26.5(GATE) PQ2.1(GATE) PR511.2
MCLK: RN23.3 U104.115(MCLK)
MDAT: RN23.1(3) U104.116(MDAT)
ME_DISABLE#: PCH.AY39(GPP_D1) SR13.1 SR275.2
ME_DISABLE#_B: SQ1.1(BASE) SR13.2
ME_DISABLE#_E: SQ1.2(EMITTER) SR14.1
MF_MODE#: FC8.1 PCH.AK43(GPP_E7/CPU_GP1) SR94.2
MIC1-L: AC163.2 AR216.2
MIC1-L_C: AC163.1 AU1.21(MIC1-L)
MIC1-R: AC164.2 AR218.2
MIC1-R_C: AC164.1 AU1.22(MIC1-R)
MIC1-VREFO-L: AR219.2 AU1.28(MIC1-VREFO-L)
MIC1-VREFO-R: AR223.2 AU1.32(MIC1-VREFO-R)
MIC1_JD: AR16.2 J83.3
MIC1_L: AC183.1 AD6.1(ANODE) AL12.1 J83.2
MIC1_L_B: AL12.2 AR216.1 AR219.1
MIC1_R: AC184.1 AD7.1(ANODE) AL14.1 J83.5
MIC1_R_B: AL14.2 AR218.1 AR223.1
MIC2-L: AC162.2 AR5.1
MIC2-L_C: AC162.1 AU1.16(MIC2-L)
MIC2-R: AC161.2 AR6.1
MIC2-R_C: AC161.1 AU1.17(MIC2-R)
MIC2-VREFO: AD1.3(ANODE) AU1.30(MIC2-VREFO)
MIC2_JD: AR11.2 P23.6
MIC2_L_C: AC77.1 AL15.2 P23.1
MIC2_R_C: AC76.1 AL16.2 P23.3
ML_LANE_0N: J125.3(ML_LANE_0N) M1U1.2(TMDS_CH1+) M1U1.9(NC3) SC65.1
ML_LANE_0P: J125.1(ML_LANE_0P) M1U1.1(TMDS_CH1-) M1U1.10(NC4) SC64.1
ML_LANE_1N: J125.6(ML_LANE_1N) M1U1.5(TMDS_CH2+) M1U1.6(NC1) SC67.1
ML_LANE_1P: J125.4(ML_LANE_1P) M1U1.4(TMDS_CH2-) M1U1.7(NC2) SC66.1
ML_LANE_2N: J125.9(ML_LANE_2N) M1U2.2(TMDS_CH1+) M1U2.9(NC3) SC69.1
ML_LANE_2P: J125.7(ML_LANE_2P) M1U2.1(TMDS_CH1-) M1U2.10(NC4) SC68.1
ML_LANE_3N: J125.12(ML_LANE_3N) M1U2.5(TMDS_CH2+) M1U2.6(NC1) SC153.1
ML_LANE_3P: J125.10(ML_LANE_3P) M1U2.4(TMDS_CH2-) M1U2.7(NC2) SC152.1
MODE_DEL: AR242.1 U5.32(MODE_SEL)
MUTE: AQ14.3(COLLECTOR) AR61.1 AR62.1 AR63.1 AR64.1 AR199.1 AR200.1 AR201.1 AR202.1 AR203.1 AR204.1
O_AUD_PCSPKR_DET#: O2R5.2 U104.54((PC_SPKR_DET)GP031)
O_IO_PME#: SR7713.1 U104.75(GP041/IO_PME#)
O_SPEAKER: ECR97.2 OR44.1 U104.125(SPEAKER[DIAG_EN#]/GP070)
OC_ASM1142_PA#: PCH.AH42(GPP_F17/USB_OC6#) U4.28(OCI_A#) UR69721.2 UR69722.1 UU45.3(OC#)
OC_ASM1142_PB#: AR244.2 U4.29(OCI_B#) UU54.3(FLAG)
OSC8M__IN: U15.5(PF0_OSC_IN) UCC1.1 UCR30.1
OSC8M__OUT: U15.6(PF1_OSC_OUT) UCC2.1 Y19.1
P1_PSON#: CON4.16(PSON#) P1C2.1 P1R2.1 P1R3.2
PCH_DDPC_HPD2: PCH.AT7(GPP_I3/DDPE_HPD3) SR139.2
PCH_DDPC_HPD3: PCH.BA1(GPP_I4/EDP_HPD) SR664.2
PCH_DDPD_CTRCLK: M1R13.2 MQ12.3(DRAIN) PCH.AY1(GPP_I9/DDPD_CTRLCLK)
PCH_DDPD_CTRLDATA: M1R12.2 MQ12.1(SOURCE) PCH.AY2(GPP_I10/DDPD_CTRLDATA)
PCH_DPWROK: PCH.BD4(DSW_PWROK) SC149.1 SR7637.1 U104.28(DPWROK/GP013)
PCH_H_TRST#: PCH.AV2(CPU_TRST#) SR280.2
PCH_JTAG_TCK: PCH.AN1(JTAG_TCK) SR160.1 XDP2.55(TCK1)
PCH_PLTRST#: PCH.BD24(GPP_B13/PLTRST#) Q5.2(GATE) SCB119.2 U104.14(LRESET#)
PCH_PME#: PCH.BF15(GPP_A11/PME#) SR115.2 SR7713.2
PCH_PWROK: MQ28.3(DRAIN) OR65.2 PCH.BE4(PCH_PWROK) SR653.1
PCH_RSMRST#: PCH.BG5(RSMRST#) Q3.5(GATE) SC148.1 SR162.1 SR336.1 U104.58(RSMRST#)
PCH_SUSACK#: PCH.BD17(GPP_A15/SUSACK#) SC175.1 SR119.2
PCH_SUSCLK: ECR101.1 J60.50(SUSCLK(32KHZ)(O)(0/3.3V)) M2C53.1 M2R33.1 PCH.AV13(GPD8/SUSCLK) SR7646.2
PCH_SUSWARN#: ECR96.1 PCH.BF17(GPP_A13/SUSWARN#/SUSPWRDNACK) SR119.1
PCH_TGR_L900MIL: PCH.AL1(PCH_TRIGOUT) SR281.1
PCHXDP_HOOK0_RSMRST#: SR162.2 XDP2.39(HOOK0)
PCHXDP_PRDY#: PCH.AR1(PRDY#) SR153.2 SR154.1
PCHXDP_PREQ_R#: PCH.AU3(PREQ#) SR7634.1 SR7635.2
PCI_IRQA: PCH.AY13(GPP_A7/PIRQA#/ESPI_ALERT0#) SR7638.2
PCIE-WAKE_C: J60.55(PEWAKE0#(IO)(0/3.3V)) M2R4.1
PCIE_RCOMPN_W15S15MIL: PCH.B10(PCIE_RCOMPN) SR401.1
PCIE_RCOMPP_W15S15MIL: PCH.C10(PCIE_RCOMPP) SR401.2
PCIEX16_1_PNT1: SLOT4.A1(PRSNT1#) XR15.1
PCIEX16_PNT1: SLOT1.A1(PRSNT1#) XR11.1
PE4_2_A5: SLOT2.A5(JTAG2) XR4.1
PE4_2_A6: SLOT2.A6(JTAG3) XR1.2
PE4_2_A8: SLOT2.A8(JTAG5) XR2.2
PE4_2_TRST#: SLOT2.B9(JTAG1) XR3.2
PE4_3_A5: SLOT3.A5(JTAG2) XR20.1
PE4_3_A6: SLOT3.A6(JTAG3) XR18.2
PE4_3_A8: SLOT3.A8(JTAG5) XR17.2
PE4_3_TRST#: SLOT3.B9(JTAG1) XR19.2
PE5_RXN: PCH.K19(PCIE5_RXN) SLOT2.A17(PERN0)
PE5_RXP: PCH.L19(PCIE5_RXP) SLOT2.A16(PERP0)
PE5_TXN: PCH.D22(PCIE5_TXN) SC61.1
PE5_TXN1_C: J60.37(PETN0) M2C41.1
PE5_TXN_C: SC61.2 SLOT2.B15(PETN0)
PE5_TXP: PCH.C22(PCIE5_TXP) SC32.1
PE5_TXP1_C: J60.35(PETP0) M2C40.1
PE5_TXP_C: SC32.2 SLOT2.B14(PETP0)
PE6_RXN: PCH.G22(PCIE6_RXN) SLOT2.A22(PERN1)
PE6_RXP: PCH.E22(PCIE6_RXP) SLOT2.A21(PERP1)
PE6_TXN: PCH.B22(PCIE6_TXN) SC63.1
PE6_TXN_C: SC63.2 SLOT2.B20(PETN1)
PE6_TXP: PCH.A23(PCIE6_TXP) SC62.1
PE6_TXP_C: SC62.2 SLOT2.B19(PETP1)
PE7_RXN: PCH.L22(PCIE7_RXN) SLOT2.A26(PERN2)
PE7_RXP: PCH.K22(PCIE7_RXP) SLOT2.A25(PERP2)
PE7_TXN: PCH.C23(PCIE7_TXN) SC157.1
PE7_TXN_C: SC157.2 SLOT2.B24(PETN2)
PE7_TXP: PCH.B23(PCIE7_TXP) SC155.1
PE7_TXP_C: SC155.2 SLOT2.B23(PETP2)
PE8_RXN: PCH.K24(PCIE8_RXN) SLOT2.A30(PERN3)
PE8_RXP: PCH.L24(PCIE8_RXP) SLOT2.A29(PERP3)
PE8_TXN: PCH.C24(PCIE8_TXN) SC156.1
PE8_TXN_C: SC156.2 SLOT2.B28(PETN3)
PE8_TXP: PCH.B24(PCIE8_TXP) SC154.1
PE8_TXP_C: SC154.2 SLOT2.B27(PETP3)
