# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Nets (continued)
GND: AC2.2 AC14.2 AC15.2 AC20.2 AC21.2 AC22.2 AC24.2 AC25.2 AC26.2 AC27.2 AC39.2 AC47.2 AC52.2 AC55.2 AC71.2 AC72.2 AC73.2 AC129.2 AC130.2 AC136.1 AC185.1 AC187.2 AC188.2 AC193.2 AC194.2 AC195.2 AC196.2 AC197.2 AC198.2 AD2.2(CATHODE) AD8.1(ANODE) AD9.2(CATHODE) AD10.2(CATHODE) AD11.2(CATHODE) AD12.2(CATHODE) AD20.2(CATHODE) AD21.2(CATHODE) AD22.2(CATHODE) AD23.2(CATHODE) AQ11.3(COLLECTOR) AQ13.3(COLLECTOR) AQ23.3(COLLECTOR) AR4.2 AR23.2 AR227.1 AR231.2 AR232.2 AR247.1 AU1.7(DVSS) C1.2 C2.2 C5.2 C81.2 C82.2 C83.2 C85.2 C93.2 C414.2 C415.2 C416.2 C417.2 C9357.1 C941399.2 C941400.2 C941401.2 C941402.2 CB2.2 CB4107.2 CB4112.2 CB4113.2 CB4114.2 CB4115.2 CB4116.2 CB4117.2 CB4119.2 CB4122.2 CB4123.2 CB4124.2 CB4125.2 CB4126.2 CB4127.2 CB4128.2 CB4129.2 CLIP3.1 CLIP3.2 CLIP4.1 CLIP4.2 CON4.3(GND1) CON4.5(GND2) CON4.7(GND3) CON4.15(GND4) CON4.17(GND5) CON4.18(GND6) CON4.19(GND7) CON4.24(GND8) CON_CBAT.2(-) CON_XMM1.2(VSS<93>) CON_XMM1.4(VSS<92>) CON_XMM1.6(VSS<91>) CON_XMM1.9(VSS<90>) CON_XMM1.11(VSS<89>) CON_XMM1.13(VSS<88>) CON_XMM1.15(VSS<87>) CON_XMM1.17(VSS<86>) CON_XMM1.20(VSS<85>) CON_XMM1.22(VSS<84>) CON_XMM1.24(VSS<83>) CON_XMM1.26(VSS<82>) CON_XMM1.28(VSS<81>) CON_XMM1.31(VSS<80>) CON_XMM1.33(VSS<79>) CON_XMM1.35(VSS<78>) CON_XMM1.37(VSS<77>) CON_XMM1.39(VSS<76>) CON_XMM1.42(VSS<75>) CON_XMM1.44(VSS<74>) CON_XMM1.46(VSS<73>) CON_XMM1.48(VSS<72>) CON_XMM1.50(VSS<71>) CON_XMM1.53(VSS<70>) CON_XMM1.55(VSS<69>) CON_XMM1.57(VSS<68>) CON_XMM1.94(VSS<67>) CON_XMM1.96(VSS<66>) CON_XMM1.98(VSS<65>) CON_XMM1.101(VSS<64>) CON_XMM1.103(VSS<63>) CON_XMM1.105(VSS<62>) CON_XMM1.107(VSS<61>) CON_XMM1.109(VSS<60>) CON_XMM1.112(VSS<59>) CON_XMM1.114(VSS<58>) CON_XMM1.116(VSS<57>) CON_XMM1.118(VSS<56>) CON_XMM1.120(VSS<55>) CON_XMM1.123(VSS<54>) CON_XMM1.125(VSS<53>) CON_XMM1.127(VSS<52>) CON_XMM1.129(VSS<51>) CON_XMM1.131(VSS<50>) CON_XMM1.134(VSS<49>) CON_XMM1.136(VSS<48>) CON_XMM1.138(VSS<47>) CON_XMM1.140(SA1) CON_XMM1.147(VSS<46>) CON_XMM1.149(VSS<45>) CON_XMM1.151(VSS<44>) CON_XMM1.154(VSS<43>) CON_XMM1.156(VSS<42>) CON_XMM1.158(VSS<41>) CON_XMM1.160(VSS<40>) CON_XMM1.162(VSS<39>) CON_XMM1.165(VSS<38>) CON_XMM1.167(VSS<37>) CON_XMM1.169(VSS<36>) CON_XMM1.171(VSS<35>) CON_XMM1.173(VSS<34>) CON_XMM1.176(VSS<33>) CON_XMM1.178(VSS<32>) CON_XMM1.180(VSS<31>) CON_XMM1.182(VSS<30>) CON_XMM1.184(VSS<29>) CON_XMM1.187(VSS<28>) CON_XMM1.189(VSS<27>) CON_XMM1.191(VSS<26>) CON_XMM1.193(VSS<25>) CON_XMM1.195(VSS<24>) CON_XMM1.198(VSS<23>) CON_XMM1.200(VSS<22>) CON_XMM1.202(VSS<21>) CON_XMM1.238(SA2) CON_XMM1.239(VSS<20>) CON_XMM1.241(VSS<19>) CON_XMM1.243(VSS<18>) CON_XMM1.246(VSS<17>) CON_XMM1.248(VSS<16>) CON_XMM1.250(VSS<15>) CON_XMM1.252(VSS<14>) CON_XMM1.254(VSS<13>) CON_XMM1.257(VSS<12>) CON_XMM1.259(VSS<11>) CON_XMM1.261(VSS<10>) CON_XMM1.263(VSS<9>) CON_XMM1.265(VSS<8>) CON_XMM1.268(VSS<7>) CON_XMM1.270(VSS<6>) CON_XMM1.272(VSS<5>) CON_XMM1.274(VSS<4>) CON_XMM1.276(VSS<3>) CON_XMM1.279(VSS<2>) CON_XMM1.281(VSS<1>) CON_XMM1.283(VSS<0>) CON_XMM2.2(VSS<93>) CON_XMM2.4(VSS<92>) CON_XMM2.6(VSS<91>) CON_XMM2.9(VSS<90>) CON_XMM2.11(VSS<89>) CON_XMM2.13(VSS<88>) CON_XMM2.15(VSS<87>) CON_XMM2.17(VSS<86>) CON_XMM2.20(VSS<85>) CON_XMM2.22(VSS<84>) CON_XMM2.24(VSS<83>) CON_XMM2.26(VSS<82>) CON_XMM2.28(VSS<81>) CON_XMM2.31(VSS<80>) CON_XMM2.33(VSS<79>) CON_XMM2.35(VSS<78>) CON_XMM2.37(VSS<77>) CON_XMM2.39(VSS<76>) CON_XMM2.42(VSS<75>) CON_XMM2.44(VSS<74>) CON_XMM2.46(VSS<73>) CON_XMM2.48(VSS<72>) CON_XMM2.50(VSS<71>) CON_XMM2.53(VSS<70>) CON_XMM2.55(VSS<69>) CON_XMM2.57(VSS<68>) CON_XMM2.94(VSS<67>) CON_XMM2.96(VSS<66>) CON_XMM2.98(VSS<65>) CON_XMM2.101(VSS<64>) CON_XMM2.103(VSS<63>) CON_XMM2.105(VSS<62>) CON_XMM2.107(VSS<61>) CON_XMM2.109(VSS<60>) CON_XMM2.112(VSS<59>) CON_XMM2.114(VSS<58>) CON_XMM2.116(VSS<57>) CON_XMM2.118(VSS<56>) CON_XMM2.120(VSS<55>) CON_XMM2.123(VSS<54>) CON_XMM2.125(VSS<53>) CON_XMM2.127(VSS<52>) CON_XMM2.129(VSS<51>) CON_XMM2.131(VSS<50>) CON_XMM2.134(VSS<49>) CON_XMM2.136(VSS<48>) CON_XMM2.138(VSS<47>) CON_XMM2.147(VSS<46>) CON_XMM2.149(VSS<45>) CON_XMM2.151(VSS<44>) CON_XMM2.154(VSS<43>) CON_XMM2.156(VSS<42>) CON_XMM2.158(VSS<41>) CON_XMM2.160(VSS<40>) CON_XMM2.162(VSS<39>) CON_XMM2.165(VSS<38>) CON_XMM2.167(VSS<37>) CON_XMM2.169(VSS<36>) CON_XMM2.171(VSS<35>) CON_XMM2.173(VSS<34>) CON_XMM2.176(VSS<33>) CON_XMM2.178(VSS<32>) CON_XMM2.180(VSS<31>) CON_XMM2.182(VSS<30>) CON_XMM2.184(VSS<29>) CON_XMM2.187(VSS<28>) CON_XMM2.189(VSS<27>) CON_XMM2.191(VSS<26>) CON_XMM2.193(VSS<25>) CON_XMM2.195(VSS<24>) CON_XMM2.198(VSS<23>) CON_XMM2.200(VSS<22>) CON_XMM2.202(VSS<21>) CON_XMM2.238(SA2) CON_XMM2.239(VSS<20>) CON_XMM2.241(VSS<19>) CON_XMM2.243(VSS<18>) CON_XMM2.246(VSS<17>) CON_XMM2.248(VSS<16>) CON_XMM2.250(VSS<15>) CON_XMM2.252(VSS<14>) CON_XMM2.254(VSS<13>) CON_XMM2.257(VSS<12>) CON_XMM2.259(VSS<11>) CON_XMM2.261(VSS<10>) CON_XMM2.263(VSS<9>) CON_XMM2.265(VSS<8>) CON_XMM2.268(VSS<7>) CON_XMM2.270(VSS<6>) CON_XMM2.272(VSS<5>) CON_XMM2.274(VSS<4>) CON_XMM2.276(VSS<3>) CON_XMM2.279(VSS<2>) CON_XMM2.281(VSS<1>) CON_XMM2.283(VSS<0>) CON_XMM3.2(VSS<93>) CON_XMM3.4(VSS<92>) CON_XMM3.6(VSS<91>) CON_XMM3.9(VSS<90>) CON_XMM3.11(VSS<89>) CON_XMM3.13(VSS<88>) CON_XMM3.15(VSS<87>) CON_XMM3.17(VSS<86>) CON_XMM3.20(VSS<85>) CON_XMM3.22(VSS<84>) CON_XMM3.24(VSS<83>) CON_XMM3.26(VSS<82>) CON_XMM3.28(VSS<81>) CON_XMM3.31(VSS<80>) CON_XMM3.33(VSS<79>) CON_XMM3.35(VSS<78>) CON_XMM3.37(VSS<77>) CON_XMM3.39(VSS<76>) CON_XMM3.42(VSS<75>) CON_XMM3.44(VSS<74>) CON_XMM3.46(VSS<73>) CON_XMM3.48(VSS<72>) CON_XMM3.50(VSS<71>) CON_XMM3.53(VSS<70>) CON_XMM3.55(VSS<69>) CON_XMM3.57(VSS<68>) CON_XMM3.94(VSS<67>) CON_XMM3.96(VSS<66>) CON_XMM3.98(VSS<65>) CON_XMM3.101(VSS<64>) CON_XMM3.103(VSS<63>) CON_XMM3.105(VSS<62>) CON_XMM3.107(VSS<61>) CON_XMM3.109(VSS<60>) CON_XMM3.112(VSS<59>) CON_XMM3.114(VSS<58>) CON_XMM3.116(VSS<57>) CON_XMM3.118(VSS<56>) CON_XMM3.120(VSS<55>) CON_XMM3.123(VSS<54>) CON_XMM3.125(VSS<53>) CON_XMM3.127(VSS<52>) CON_XMM3.129(VSS<51>) CON_XMM3.131(VSS<50>) CON_XMM3.134(VSS<49>) CON_XMM3.136(VSS<48>) CON_XMM3.138(VSS<47>) CON_XMM3.139(SA0) CON_XMM3.140(SA1) CON_XMM3.147(VSS<46>) CON_XMM3.149(VSS<45>) CON_XMM3.151(VSS<44>) CON_XMM3.154(VSS<43>) CON_XMM3.156(VSS<42>) CON_XMM3.158(VSS<41>) CON_XMM3.160(VSS<40>) CON_XMM3.162(VSS<39>) CON_XMM3.165(VSS<38>) CON_XMM3.167(VSS<37>) CON_XMM3.169(VSS<36>) CON_XMM3.171(VSS<35>) CON_XMM3.173(VSS<34>) CON_XMM3.176(VSS<33>) CON_XMM3.178(VSS<32>) CON_XMM3.180(VSS<31>) CON_XMM3.182(VSS<30>) CON_XMM3.184(VSS<29>) CON_XMM3.187(VSS<28>) CON_XMM3.189(VSS<27>) CON_XMM3.191(VSS<26>) CON_XMM3.193(VSS<25>) CON_XMM3.195(VSS<24>) CON_XMM3.198(VSS<23>) CON_XMM3.200(VSS<22>) CON_XMM3.202(VSS<21>) CON_XMM3.238(SA2) CON_XMM3.239(VSS<20>) CON_XMM3.241(VSS<19>) CON_XMM3.243(VSS<18>) CON_XMM3.246(VSS<17>) CON_XMM3.248(VSS<16>) CON_XMM3.250(VSS<15>) CON_XMM3.252(VSS<14>) CON_XMM3.254(VSS<13>) CON_XMM3.257(VSS<12>) CON_XMM3.259(VSS<11>) CON_XMM3.261(VSS<10>) CON_XMM3.263(VSS<9>) CON_XMM3.265(VSS<8>) CON_XMM3.268(VSS<7>) CON_XMM3.270(VSS<6>) CON_XMM3.272(VSS<5>) CON_XMM3.274(VSS<4>) CON_XMM3.276(VSS<3>) CON_XMM3.279(VSS<2>) CON_XMM3.281(VSS<1>) CON_XMM3.283(VSS<0>) CON_XMM4.2(VSS<93>) CON_XMM4.4(VSS<92>) CON_XMM4.6(VSS<91>) CON_XMM4.9(VSS<90>) CON_XMM4.11(VSS<89>) CON_XMM4.13(VSS<88>) CON_XMM4.15(VSS<87>) CON_XMM4.17(VSS<86>) CON_XMM4.20(VSS<85>) CON_XMM4.22(VSS<84>) CON_XMM4.24(VSS<83>) CON_XMM4.26(VSS<82>) CON_XMM4.28(VSS<81>) CON_XMM4.31(VSS<80>) CON_XMM4.33(VSS<79>) CON_XMM4.35(VSS<78>) CON_XMM4.37(VSS<77>) CON_XMM4.39(VSS<76>) CON_XMM4.42(VSS<75>) CON_XMM4.44(VSS<74>) CON_XMM4.46(VSS<73>) CON_XMM4.48(VSS<72>) CON_XMM4.50(VSS<71>) CON_XMM4.53(VSS<70>) CON_XMM4.55(VSS<69>) CON_XMM4.57(VSS<68>) CON_XMM4.94(VSS<67>) CON_XMM4.96(VSS<66>) CON_XMM4.98(VSS<65>) CON_XMM4.101(VSS<64>) CON_XMM4.103(VSS<63>) CON_XMM4.105(VSS<62>) CON_XMM4.107(VSS<61>) CON_XMM4.109(VSS<60>) CON_XMM4.112(VSS<59>) CON_XMM4.114(VSS<58>) CON_XMM4.116(VSS<57>) CON_XMM4.118(VSS<56>) CON_XMM4.120(VSS<55>) CON_XMM4.123(VSS<54>) CON_XMM4.125(VSS<53>) CON_XMM4.127(VSS<52>) CON_XMM4.129(VSS<51>) CON_XMM4.131(VSS<50>) CON_XMM4.134(VSS<49>) CON_XMM4.136(VSS<48>) CON_XMM4.138(VSS<47>) CON_XMM4.139(SA0) CON_XMM4.147(VSS<46>) CON_XMM4.149(VSS<45>) CON_XMM4.151(VSS<44>) CON_XMM4.154(VSS<43>) CON_XMM4.156(VSS<42>) CON_XMM4.158(VSS<41>) CON_XMM4.160(VSS<40>) CON_XMM4.162(VSS<39>) CON_XMM4.165(VSS<38>) CON_XMM4.167(VSS<37>) CON_XMM4.169(VSS<36>) CON_XMM4.171(VSS<35>) CON_XMM4.173(VSS<34>) CON_XMM4.176(VSS<33>) CON_XMM4.178(VSS<32>) CON_XMM4.180(VSS<31>) CON_XMM4.182(VSS<30>) CON_XMM4.184(VSS<29>) CON_XMM4.187(VSS<28>) CON_XMM4.189(VSS<27>) CON_XMM4.191(VSS<26>) CON_XMM4.193(VSS<25>) CON_XMM4.195(VSS<24>) CON_XMM4.198(VSS<23>) CON_XMM4.200(VSS<22>) CON_XMM4.202(VSS<21>) CON_XMM4.238(SA2) CON_XMM4.239(VSS<20>) CON_XMM4.241(VSS<19>) CON_XMM4.243(VSS<18>) CON_XMM4.246(VSS<17>) CON_XMM4.248(VSS<16>) CON_XMM4.250(VSS<15>) CON_XMM4.252(VSS<14>) CON_XMM4.254(VSS<13>) CON_XMM4.257(VSS<12>) CON_XMM4.259(VSS<11>) CON_XMM4.261(VSS<10>) CON_XMM4.263(VSS<9>) CON_XMM4.265(VSS<8>) CON_XMM4.268(VSS<7>) CON_XMM4.270(VSS<6>) CON_XMM4.272(VSS<5>) CON_XMM4.274(VSS<4>) CON_XMM4.276(VSS<3>) CON_XMM4.279(VSS<2>) CON_XMM4.281(VSS<1>) CON_XMM4.283(VSS<0>) CR2.2(CATHODE) CR9.2(CATHODE) D4C1.2 D4C2.2 D4C3.2 D4C4.2 D4C5.2 D4C7.2 D4C8.2 D4C12.2 D4C13.2 D4C17.2 D4C18.2 D4C21.2 D4C22.2 D4C23.2 D4C24.2 D4CB1.2 D4CB2.2 D4CB3.2 D4CB4.2 D4CB5.2 D4CB6.2 D4CB7.2 D4CB8.2 D4CB9.2 D4CB10.2 D4CB11.2 D4CB12.2 D4CB13.2 D4CB14.2 D4CB15.2 D4CB16.2 D4CB17.2 D4CB18.2 D4CB19.2 D4CB20.2 D4CB21.2 D4CB22.2 D4CB23.2 D4CB24.2 D4CB25.2 D4CB26.2 D4CB27.2 D4CB28.2 D4CB29.2 D4CB30.2 D4CB31.2 D4CB32.2 D4CB33.2 D4CB34.2 D4CB35.2 D4CB36.2 D4CB37.2 D4CB38.2 D4CB39.2 D4CB40.2 D4CB41.2 D4CB48.2 D4CB49.2 D4CB50.2 D4CB51.2 D4CB52.2 D4CB53.2 D4CB54.2 D4CB55.2 D4CB57.2 D4CB58.2 D4CB59.2 D4CB60.2 D4CB61.2 D4CB62.2 D4CB63.2 D4CB64.2 D4CB65.2 D4CB66.2 D4CB67.2 D4CB68.2 D4CB69.2 D4CB70.2 D4CB71.2 D4CB72.2 D4CB73.2 D4CB74.2 D4CB75.2 D4CB76.2 D4CB77.2 D4CB78.2 D4CB88.2 D4CB89.2 D4CE4.2 D4R20.2 D4R31.1 D4R32.2 D4R35.1 E16.10 EC22.2 ECC55.2 ECC56.2 ECQ12.2(EMITTER) ECQ13.2(EMITTER) F3CB1.2 F3CB3.2 F3CB4.2 F3U1.4(GND) F3U2.4(GND) FC2.2 FC3.2 FC5.2 FC6.2 FC8.2 FC13.2 FC14.2 FC15.2 FC16.2 FCE1.2 FCE4.2 FCE5.2 GPU_PWR.1 GPU_PWR.2 GPU_PWR.3 GPU_PWR.4 H1.1(GND1) H1.2(GND2) H1.3(GND3) H1.4(GND4) H1.5(GND5) H1.6(GND6) H1.7(GND7) H1.8(GND8) H2.1(GND1) H2.2(GND2) H2.3(GND3) H2.4(GND4) H2.5(GND5) H2.6(GND6) H2.7(GND7) H2.8(GND8) H3.1(GND1) H3.2(GND2) H3.3(GND3) H3.4(GND4) H3.5(GND5) H3.6(GND6) H3.7(GND7) H3.8(GND8) H4.1(GND1) H4.2(GND2) H4.3(GND3) H4.4(GND4) H4.5(GND5) H4.6(GND6) H4.7(GND7) H4.8(GND8) H6.2(GND1) H6.3(GND2) H6.4(GND3) H6.5(GND4) H6.6(GND5) H6.7(GND6) H6.8(GND7) H6.9(GND8) H13.1 H14.1 H15.1 H16.1 H20.1 H21.1 H22.1 H23.1 HC3.2 HC4.2 HC5.2 HC11.2 HC23.2 HC24.2 HC25.2 HC27.2 HC29.2 HR14.2 HR15.2 HR31.2 HR36.2 HR615.2 HR616.2 HR617.2 HR618.2 HR619.2 HR620.2 HR621.2 HR622.2 HR626.2 HR627.1 HR629.1 J9.1(P_GND1) J9.2(P_GND2) J9.3(P_GND3) J9.4(P_GND4) J9.5(P_GND5) J9.6(P_GND6) J9.7(P_GND7) J9.8(P_GND8) J9.U4 J9.U8 J10.1(SIDE_G1) J10.2(SIDE_G2) J10.3(SIDE_G3) J10.4(SIDE_G4) J10.5(SIDE_G5) J10.6(SIDE_G6) J10.14(GND1) J10.24(GND2) J10.34(GND3) J10.44(GND4) J60.1(GND1) J60.7(GND2) J60.18(GND3) J60.23(GND4) J60.24(GND5) J60.29(GND6) J60.30(GND7) J60.33(GND8) J60.36(GND9) J60.39(GND10) J60.45(GND11) J60.51(GND12) J60.57(GND13) J60.63(GND14) J60.69(GND15) J60.75(GND16) J60.76(SIDE1) J60.77(SIDE2) J125.2(GND_0) J125.5(GND_1) J125.8(GND_2) J125.11(GND_3) J125.16(GND_6) J125.19(RETURN) J125.21(P_GND1) J125.22(P_GND2) J125.23(P_GND3) J125.24(P_GND4) J133.1(P_GND1) J133.2(P_GND2) J133.3(P_GND3) J133.4(P_GND4) J133.5(P_GND5) J133.6(P_GND6) J133.14(GND1) J133.17(GND8) J133.24(GND2) J133.27(GND7) J133.34(GND3) J133.37(GND6) J133.44(GND4) J133.47(GND5) J_TYPEC.1(P_GND1) J_TYPEC.2(P_GND2) J_TYPEC.3(P_GND3) J_TYPEC.4(P_GND4) J_TYPEC.5(P_GND5) J_TYPEC.6(P_GND6) J_TYPEC.A1(GND2) J_TYPEC.A12(GND1) J_TYPEC.B1(GND3) J_TYPEC.B12(GND4) LC4.2 LC5.2 LC6.2 LC7.2 LC8.2 LC12.2 LC18.2 LC44.2 LCB2.2 LCB3.2 LCB4.2 LCB5.2 LCB6.2 LCB7.2 LCB9.2 LCB10.2 LCB11.2 LCB12.2 LCB13.2 LCB14.2 LCB15.2 LCB16.2 LCB17.2 LCB18.2 LCB19.2 LCB20.2 LCB21.2 LCB22.2 LR9.2 LR20.2 LR24.2 M1C1.2 M1C35.2 M1D1.2(CATHODE) M1R11.2 M1R36.2 M1R37.2 M1U1.3(GND1) M1U1.8(GND2) M1U2.3(GND1) M1U2.8(GND2) M1U3.3(GND1) M1U3.8(GND2) M1U4.3(GND1) M1U4.8(GND2) M1U5.3(GND1) M1U5.8(GND2) M1U6.3(GND1) M1U6.8(GND2) M1U7.3(GND1) M1U7.8(GND2) M1U8.3(GND1) M1U8.8(GND2) M1U9.3(GND1) M1U9.8(GND2) M2C1.2 M2C2.2 M2C3.2 M2C4.2 M2C5.2 M2C6.2 M2C13.2 M2C14.2 M2C15.2 M2C16.2 M2C17.2 M2C18.2 M2C19.2 M2C20.2 M2C21.2 M2C44.2 M2C46.2 M2C47.2 M2C48.2 M2C49.2 M2C50.2 M2C51.2 M2C52.2 M2C53.2 M2C54.2 M2C55.2 M2R39.2 MQ8.1(SOURCE) MQ8.4(SOURCE) MQ18.2(SOURCE) MQ19.1(SOURCE) MQ19.4(SOURCE) MQ20.1(SOURCE) MQ20.4(SOURCE) MQ21.1(SOURCE) MQ21.4(SOURCE) MQ22.2(SOURCE) MQ24.1(SOURCE) MQ24.4(SOURCE) MQ25.1(SOURCE) MQ25.4(SOURCE) MQ26.1(SOURCE) MQ26.4(SOURCE) MQ28.1(SOURCE) MQ28.4(SOURCE) MQ29.1(SOURCE) MQ29.4(SOURCE) MQ35.1(SOURCE) MQ35.4(SOURCE) MR41.2 O2CB1.2 O2CB2.2 O2CB3.2 O2CB4.2 O2CB5.2 O2CB6.2 O2CB7.2 O2CB8.2 O2CB10.2 O2CB11.2 O2CB12.2 O2CB15.2 O2CB16.2 O2CB17.2 O2CB19.2 O2CB20.2 O2Q6.1 O2Q6.4 O2R2.2 O2R8.2 O2R10.1 OR6.2 OR34.1 OR44.2 OR59.2 P1C2.2 P1CB1.2 P1CB2.2 P1CB3.2 P1CB4.2 P1CB5.2 P1CB8.2 P1CB10.2 P1CB11.2 P1CB12.2 P1CB13.2 P1CB14.2 P1CB15.2 P1CB16.2 P1CB17.2 P3.1 P3.2 P17.3 P24.9 P24.14 P24.15 P29.1 P61.1(GND1) P61.4(GND2) P61.7(GND3) P62.1(GND1) P62.4(GND2) P62.7(GND3) P63.1(GND1) P63.4(GND2) P63.7(GND3) P64.1(GND1) P64.4(GND2) P64.7(GND3) P70.1 P118.9 P118.11 P150.6 P150.7 P150.12 P150.13 P189.8 P189.9 P311.5(IRTX) P312.4 P458.1 P461.1 P_HDDFAN.1 P_HDDFAN.5(SIDE1) P_HDDFAN.6(SIDE2) PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC13.1 PC15.2 PC118.2 PC121.2 PC126.2 PC133.2 PC137.2 PC138.2 PC142.2 PC149.2 PC150.2 PC151.2 PC152.2 PC154.2 PC156.2 PC157.2 PC159.2 PC161.2 PC162.2 PC163.2 PC164.2 PC193.2 PC194.2 PC205.2 PC206.2 PC207.2 PC208.2 PC209.2 PC212.2 PC213.2 PC214.2 PC215.2 PC218.2 PC231.2 PC234.2 PC236.2 PC238.2 PC239.2 PC240.2 PC241.2 PC242.2 PC243.2 PC247.2 PC272.2 PC273.2 PC274.2 PC329.2 PC331.2 PC332.2 PC333.2 PC334.2 PC335.2 PC339.2 PC341.2 PC343.2 PC481.2 PC483.2 PC484.2 PC485.2 PC486.2 PC566.2 PC567.2 PC568.2 PC569.2 PC570.2 PC601.2 PC602.2 PC604.2 PC605.2 PC606.2 PC608.2 PC609.2 PC610.2 PC612.2 PC613.2 PC614.2 PC616.2 PC617.2 PC618.2 PC619.2 PC620.2 PC642.2 PC661.2 PC832.2 PC834.2 PC5801.2 PC5804.2 PC5806.2 PC5808.2 PC5810.2 PC5812.2 PC5813.2 PC5814.2 PC5815.2 PC5817.2 PC5820.2 PC5822.2 PC5825.1 PC5826.1 PC5827.2 PC5828.2 PC5829.2 PC5830.2 PC5903.2 PC5904.2 PC5905.2 PC5906.2 PC5907.2 PC5908.2 PC5909.2 PC5910.2 PC5912.2 PC5913.2 PC5914.2 PC5916.2 PC5917.2 PC5918.2 PC5919.2 PC5920.2 PC6101.2 PC6102.2 PC6104.2 PC6105.2 PC6106.2 PC6108.2 PC6109.2 PC6110.2 PC6112.2 PC6113.2 PC6114.2 PC6116.2 PC6117.2 PC6118.2 PC6119.2 PC6120.2 PC6201.2 PC6202.2 PC6203.2 PC6204.2 PC6205.2 PC6206.2 PC6207.2 PC6208.2 PC6209.2 PC6210.2 PC6211.2 PC6212.2 PC6213.2 PC6214.2 PC6215.2 PC6216.2 PC6217.2 PC6218.2 PC6219.2 PC6220.2 PC6221.2 PC6222.2 PC6223.2 PC6224.2 PC6225.2 PC6226.2 PC6227.2 PC6228.2 PC6229.2 PC6230.2 PC6231.2 PC6232.2 PC6233.2 PC6234.2 PC6235.2 PC6236.2 PC6237.2 PC6238.2 PC6239.2 PC6240.2 PC6241.2 PC6242.2 PC6243.2 PC6244.2 PC6501.2 PC6502.2 PC6521.2 PC6522.2 PC6523.2 PC6524.2 PC6525.2 PC6526.2 PC6527.2 PC6805.2 PC6807.2 PC6808.2 PC6810.2 PC640625.2 PC640626.2 PC640627.2 PC640628.2 PC640629.2 PC640630.2 PC640631.2 PC640632.2 PC640633.2 PC640634.2 PC640635.2 PC640636.2 PC640637.2 PC640639.2 PC640644.2 PC640645.2 PC640646.2 PC640649.2 PC640651.2 PC640653.2 PC640656.2 PC640660.2 PC640661.2 PC640662.2 PC640665.2 PC640667.2 PC640671.2 PC640672.1 PC640674.2 PC640675.2 PC640676.2 PC640681.2 PC640682.2 PC640683.2 PC640684.2 PC640685.2 PC640686.2 PC640687.2 PC640688.2 PC640689.2 PC640690.2 PC640691.2 PC640692.2 PCE11.2 PCE12.2 PCE13.2 PCE14.2 PCE17.2 PCE18.2 PCE23.2 PCE591.2 PCE601.2 PCE611.2 PCE651.2 PCE652.2 PCE653.2 PCE6201.2 PCE6202.2 PCE6203.2 PCE6204.2 PCE6205.2 PCE6206.2 PCE6207.2 PCE6208.2 PCE6209.2 PCE6210.2 PCE6211.2 PCE6212.2 PCH.A2(VSS_2) PCH.A3(VSS_4) PCH.A4(VSS_7) PCH.A6(VSS_12) PCH.A12(VSS_1) PCH.A25(VSS_3) PCH.A30(VSS_5) PCH.A35(VSS_6) PCH.A40(VSS_8) PCH.A41(VSS_9) PCH.A42(VSS_10) PCH.A44(VSS_11) PCH.AA17(VSS_13) PCH.AA18(VSS_14) PCH.AA20(VSS_15) PCH.AA21(VSS_16) PCH.AA26(VSS_17) PCH.AA28(VSS_18) PCH.AA29(VSS_19) PCH.AB4(VSS_26) PCH.AB17(VSS_20) PCH.AB18(VSS_21) PCH.AB20(VSS_22) PCH.AB21(VSS_23) PCH.AB25(VSS_24) PCH.AB29(VSS_25) PCH.AB42(VSS_27) PCH.AC4(VSS_34) PCH.AC5(VSS_35) PCH.AC7(VSS_36) PCH.AC8(VSS_37) PCH.AC10(VSS_28) PCH.AC11(VSS_29) PCH.AC14(VSS_30) PCH.AC16(VSS_31) PCH.AC32(VSS_32) PCH.AC38(VSS_33) PCH.AD1(VSS_38) PCH.AD18(VSS_39) PCH.AD20(VSS_40) PCH.AD21(VSS_41) PCH.AD25(VSS_42) PCH.AD29(VSS_43) PCH.AD45(VSS_44) PCH.AE4(VSS_50) PCH.AE8(VSS_51) PCH.AE11(VSS_45) PCH.AE14(VSS_46) PCH.AE32(VSS_47) PCH.AE33(VSS_48) PCH.AE38(VSS_49) PCH.AF4(VSS_58) PCH.AF18(VSS_52) PCH.AF20(VSS_53) PCH.AF21(VSS_54) PCH.AF25(VSS_55) PCH.AF28(VSS_56) PCH.AF29(VSS_57) PCH.AF42(VSS_59) PCH.AG18(VSS_60) PCH.AG20(VSS_61) PCH.AG21(VSS_62) PCH.AG23(VSS_63) PCH.AG25(VSS_64) PCH.AG26(VSS_65) PCH.AG28(VSS_66) PCH.AG29(VSS_67) PCH.AH11(VSS_68) PCH.AH13(VSS_69) PCH.AH30(VSS_70) PCH.AH32(VSS_71) PCH.AH33(VSS_72) PCH.AH38(VSS_73) PCH.AJ1(VSS_74) PCH.AJ17(VSS_75) PCH.AJ18(VSS_76) PCH.AJ20(VSS_77) PCH.AJ21(VSS_78) PCH.AJ23(VSS_79) PCH.AJ25(VSS_80) PCH.AJ26(VSS_81) PCH.AJ28(VSS_82) PCH.AJ29(VSS_83) PCH.AJ45(VSS_84) PCH.AK10(VSS_85) PCH.AK14(VSS_86) PCH.AK16(VSS_87) PCH.AK17(VSS_88) PCH.AK18(VSS_89) PCH.AK26(VSS_90) PCH.AK28(VSS_91) PCH.AK29(VSS_92) PCH.AK30(VSS_93) PCH.AK32(VSS_94) PCH.AK35(VSS_95) PCH.AK39(VSS_96) PCH.AL4(VSS_97) PCH.AL42(VSS_98) PCH.AM4(VSS_110) PCH.AM10(VSS_99) PCH.AM11(VSS_100) PCH.AM13(VSS_101) PCH.AM14(VSS_102) PCH.AM17(VSS_103) PCH.AM19(VSS_104) PCH.AM24(VSS_105) PCH.AM27(VSS_106) PCH.AM29(VSS_107) PCH.AM32(VSS_108) PCH.AM33(VSS_109) PCH.AN14(VSS_111) PCH.AN45(VSS_112) PCH.AP10(VSS_113) PCH.AP11(VSS_114) PCH.AP13(VSS_115) PCH.AP15(VSS_116) PCH.AP19(VSS_117) PCH.AP22(VSS_118) PCH.AP27(VSS_119) PCH.AP31(VSS_120) PCH.AP33(VSS_121) PCH.AP34(VSS_122) PCH.AP39(VSS_123) PCH.AR4(VSS_129) PCH.AR13(VSS_124) PCH.AR22(VSS_125) PCH.AR27(VSS_126) PCH.AR31(VSS_127) PCH.AR33(VSS_128) PCH.AT10(VSS_130) PCH.AT13(VSS_131) PCH.AT35(VSS_132) PCH.AT37(VSS_133) PCH.AT42(VSS_134) PCH.AU11(VSS_135) PCH.AU17(VSS_136) PCH.AU29(VSS_137) PCH.AU33(VSS_138) PCH.AV1(VSS_139) PCH.AV8(VSS_148) PCH.AV10(VSS_140) PCH.AV15(VSS_141) PCH.AV24(VSS_142) PCH.AV27(VSS_143) PCH.AV33(VSS_144) PCH.AV35(VSS_145) PCH.AV38(VSS_146) PCH.AV45(VSS_147) PCH.AY4(VSS_152) PCH.AY8(VSS_154) PCH.AY11(VSS_149) PCH.AY19(VSS_150) PCH.AY37(VSS_151) PCH.AY42(VSS_153) PCH.B1(VSS_155) PCH.B2(VSS_157) PCH.B3(VSS_159) PCH.B4(VSS_162) PCH.B12(VSS_156) PCH.B25(VSS_158) PCH.B30(VSS_160) PCH.B35(VSS_161) PCH.B41(VSS_163) PCH.B44(VSS_164) PCH.B45(VSS_165) PCH.BA4(VSS_171) PCH.BA13(VSS_166) PCH.BA17(VSS_167) PCH.BA29(VSS_168) PCH.BA31(VSS_169) PCH.BA37(VSS_170) PCH.BA42(VSS_172) PCH.BB40(VSS_173) PCH.BC9(VSS_176) PCH.BC38(VSS_174) PCH.BC40(VSS_175) PCH.BD1(VSS_177) PCH.BD2(VSS_180) PCH.BD7(VSS_186) PCH.BD11(VSS_178) PCH.BD16(VSS_179) PCH.BD21(VSS_181) PCH.BD25(VSS_182) PCH.BD30(VSS_183) PCH.BD34(VSS_184) PCH.BD39(VSS_185) PCH.BE1(VSS_187) PCH.BE2(VSS_188) PCH.BF2(VSS_189) PCH.BF5(VSS_193) PCH.BF43(VSS_190) PCH.BF44(VSS_191) PCH.BF45(VSS_192) PCH.BG9(VSS_202) PCH.BG14(VSS_194) PCH.BG18(VSS_195) PCH.BG23(VSS_196) PCH.BG28(VSS_197) PCH.BG32(VSS_198) PCH.BG37(VSS_199) PCH.BG40(VSS_200) PCH.BG44(VSS_201) PCH.C1(VSS_203) PCH.C2(VSS_204) PCH.C9(VSS_206) PCH.C37(VSS_205) PCH.D1(VSS_207) PCH.D7(VSS_224) PCH.D10(VSS_208) PCH.D12(VSS_209) PCH.D15(VSS_210) PCH.D16(VSS_211) PCH.D19(VSS_212) PCH.D21(VSS_213) PCH.D24(VSS_214) PCH.D25(VSS_215) PCH.D29(VSS_216) PCH.D30(VSS_217) PCH.D33(VSS_218) PCH.D35(VSS_219) PCH.D36(VSS_220) PCH.D39(VSS_221) PCH.D44(VSS_222) PCH.D45(VSS_223) PCH.E6(VSS_226) PCH.E8(VSS_227) PCH.E31(VSS_225) PCH.F2(VSS_228) PCH.F6(VSS_231) PCH.F39(VSS_229) PCH.F43(VSS_230) PCH.G4(VSS_232) PCH.G9(VSS_235) PCH.G40(VSS_233) PCH.G42(VSS_234) PCH.H4(VSS_247) PCH.H9(VSS_249) PCH.H11(VSS_236) PCH.H13(VSS_237) PCH.H17(VSS_238) PCH.H19(VSS_239) PCH.H22(VSS_240) PCH.H24(VSS_241) PCH.H27(VSS_242) PCH.H29(VSS_243) PCH.H33(VSS_244) PCH.H35(VSS_245) PCH.H38(VSS_246) PCH.H42(VSS_248) PCH.J4(VSS_250) PCH.K3(VSS_305) PCH.K8(VSS_311) PCH.K11(VSS_302) PCH.K13(VSS_303) PCH.K27(VSS_304) PCH.K33(VSS_306) PCH.K35(VSS_307) PCH.K36(VSS_308) PCH.K38(VSS_309) PCH.K45(VSS_310) PCH.L4(VSS_315) PCH.L13(VSS_312) PCH.L15(VSS_313) PCH.L35(VSS_314) PCH.L42(VSS_316) PCH.M4(VSS_253) PCH.M8(VSS_254) PCH.M9(VSS_255) PCH.M11(VSS_317) PCH.M36(VSS_251) PCH.M38(VSS_252) PCH.N13(VSS_256) PCH.N15(VSS_257) PCH.N19(VSS_258) PCH.N22(VSS_259) PCH.N24(VSS_260) PCH.N31(VSS_261) PCH.N42(VSS_262) PCH.P4(VSS_273) PCH.P8(VSS_275) PCH.P10(VSS_263) PCH.P12(VSS_264) PCH.P13(VSS_265) PCH.P15(VSS_266) PCH.P17(VSS_267) PCH.P19(VSS_268) PCH.P22(VSS_269) PCH.P31(VSS_270) PCH.P33(VSS_271) PCH.P35(VSS_272) PCH.P42(VSS_274) PCH.R1(VSS_276) PCH.R32(VSS_277) PCH.T4(VSS_285) PCH.T5(VSS_289) PCH.T10(VSS_278) PCH.T14(VSS_279) PCH.T22(VSS_280) PCH.T29(VSS_281) PCH.T32(VSS_282) PCH.T36(VSS_283) PCH.T38(VSS_284) PCH.T42(VSS_286) PCH.U4(VSS_290) PCH.U42(VSS_291) PCH.V4(VSS_301) PCH.V8(VSS_288) PCH.V10(VSS_292) PCH.V14(VSS_293) PCH.V16(VSS_294) PCH.V17(VSS_295) PCH.V18(VSS_296) PCH.V30(VSS_297) PCH.V32(VSS_298) PCH.V33(VSS_299) PCH.V38(VSS_300) PCH.W3(VSS_324) PCH.W18(VSS_287) PCH.W20(VSS_318) PCH.W21(VSS_319) PCH.W23(VSS_320) PCH.W25(VSS_321) PCH.W26(VSS_322) PCH.W29(VSS_323) PCH.W45(VSS_325) PCH.Y4(VSS_332) PCH.Y8(VSS_333) PCH.Y13(VSS_326) PCH.Y14(VSS_327) PCH.Y30(VSS_328) PCH.Y32(VSS_329) PCH.Y33(VSS_330) PCH.Y38(VSS_331) PD3.2(CATHODE) PQ2.2(SOURCE) PQ10.2(SOURCE) PQ11.1(SOURCE) PQ11.4(SOURCE) PQ23.2(SOURCE) PQ29.4(SOURCE1) PQ29.8(SOURCE2) PQ30.4(SOURCE1) PQ30.8(SOURCE2) PQ40.5(S2_1) PQ40.6(S2_2) PQ40.7(S2_3) PQ46.1(EMITTER1) PQ80.2(SOURCE) PQ115.2(EMITTER) PQ592.1(S_1) PQ592.2(S_2) PQ592.3(S_3) PQ593.1(S_1) PQ593.2(S_2) PQ593.3(S_3) PQ595.1(S_1) PQ595.2(S_2) PQ595.3(S_3) PQ596.1(S_1) PQ596.2(S_2) PQ596.3(S_3) PQ602.1(S_1) PQ602.2(S_2) PQ602.3(S_3) PQ603.1(S_1) PQ603.2(S_2) PQ603.3(S_3) PQ605.1(S_1) PQ605.2(S_2) PQ605.3(S_3) PQ606.1(S_1) PQ606.2(S_2) PQ606.3(S_3) PQ612.1(S_1) PQ612.2(S_2) PQ612.3(S_3) PQ613.1(S_1) PQ613.2(S_2) PQ613.3(S_3) PQ615.1(S_1) PQ615.2(S_2) PQ615.3(S_3) PQ616.1(S_1) PQ616.2(S_2) PQ616.3(S_3) PQ652.1(S_1) PQ652.2(S_2) PQ652.3(S_3) PQ653.1(S_1) PQ653.2(S_2) PQ653.3(S_3) PQ9777.2(SOURCE) PQ9787.2(SOURCE) PR12.2 PR14.2 PR126.2 PR131.2 PR133.2 PR136.2 PR138.2 PR139.2 PR168.1 PR171.2 PR174.1 PR175.2 PR194.1 PR245.2 PR605.1 PR612.1 PR622.2 PR624.2 PR5812.2 PR5824.1 PR5830.1 PR5834.1 PR5837.1 PR5840.1 PR5856.1 PR5870.1 PR5871.1 PR5873.1 PR5906.1 PR5912.1 PR6105.1 PR6112.1 PR6603.2 PR6609.2 PR6809.2 PR70190.2 PR70195.2 PR70201.1 PR70206.2 PR70212.2 PR70217.2 PR70223.2 PR70227.2 PR70244.2 PR70245.2 PR70246.2 PR70296.2 PRT583.1 PRT584.1 PT26.1 PT27.1 PT28.1 PT29.1 PT30.1 PT31.1 PT32.1 PT33.1 PT34.1 PT35.1 PT36.1 PT37.1 PT38.1 PT39.1 PT40.1 PU5.2(GND) PU7.11(GND) PU7.12(GND1) PU7.13(GND2) PU7.14(GND3) PU7.15(GND4) PU9.11(GND) PU9.12(GND1) PU9.13(GND2) PU9.14(GND3) PU9.15(GND4) PU10.11(GND) PU10.12(GND_1) PU10.13(GND_2) PU10.14(GND_3) PU10.15(GND_4) PU12.2(GND) PU80.2(GND1) PU80.5(NC1) PU80.7(NC2) PU80.8(NC3) PU80.9(GND2) PU581.16(NC1) PU581.28(NC2) PU581.44(NC4) PU581.56(NC5) PU581.57(GND) PU581.58(GND_1) PU581.59(GND_2) PU581.60(GND_3) PU581.61(GND_4) PU591.6(GND1) PU591.9(GND2) PU592.6(GND1) PU592.9(GND2) PU601.6(GND1) PU601.9(GND2) PU602.6(GND1) PU602.9(GND2) PU611.6(GND1) PU611.9(GND2) PU612.6(GND1) PU612.9(GND2) PU651.11(GND) PU651.12(GND_1) PU651.13(GND_2) PU651.14(GND_3) PU651.15(GND_4) PU681.8(GND1) PU681.9(GND2) Q3.1(SOURCE) Q3.4(SOURCE) Q4.2(EMITTER) Q5.1(SOURCE) Q5.4(SOURCE) Q9.2(EMITTER) Q35.1(SOURCE) Q35.4(SOURCE) Q53.1(SOURCE) Q53.4(SOURCE) R636.2 R60373.2 R60374.2 R60381.2 R60385.2 R69694.2 R69695.2 RFC14.2 RFC15.2 RFC29.2 RFC30.2 RFC31.2 RFC32.2 RFC100.2 RFC101.2 RFC102.2 RFC103.2 RFC104.2 RFC105.2 RFC106.2 RFC107.2 RFC108.2 RFC109.2 RFC110.2 RFC111.2 RFC112.2 RFC113.2 RFC114.2 RFC115.2 RFC116.2 RFC117.2 RFC118.2 RFC119.2 RFC120.2 RFC121.2 S/PDIF.3(GND) S/PDIF.4 SC6.2 SC7.2 SC8.2 SC9.2 SC52.1 SC70.2 SC72.2 SC80.2 SC81.2 SC82.2 SC83.2 SC85.2 SC86.2 SC90.2 SC100.2 SC101.2 SC102.2 SC103.2 SC105.2 SC121.2 SC141.2 SC146.2 SC147.2 SC148.2 SC149.2 SC166.2 SC167.2 SC168.2 SC170.2 SC171.2 SC173.2 SC174.2 SC175.2 SCB1.2 SCB2.2 SCB3.2 SCB4.2 SCB5.2 SCB7.2 SCB8.2 SCB9.2 SCB10.2 SCB11.2 SCB12.2 SCB13.2 SCB14.2 SCB15.2 SCB16.2 SCB19.2 SCB21.2 SCB25.2 SCB28.2 SCB29.2 SCB30.2 SCB31.2 SCB32.2 SCB35.2 SCB36.2 SCB68.1 SCB69.1 SCB70.1 SCB75.2 SCB118.2 SCB119.1 SCB120.2 SCB121.1 SCB122.2 SHS1.1 SHS1.2 SHS1.3 SHS1.4 SLOT1.A4(GND35) SLOT1.A12(GND36) SLOT1.A15(GND37) SLOT1.A18(GND38) SLOT1.A20(GND39) SLOT1.A23(GND40) SLOT1.A24(GND41) SLOT1.A27(GND42) SLOT1.A28(GND43) SLOT1.A31(GND44) SLOT1.A34(GND45) SLOT1.A37(GND46) SLOT1.A38(GND47) SLOT1.A41(GND48) SLOT1.A42(GND49) SLOT1.A45(GND50) SLOT1.A46(GND51) SLOT1.A49(GND52) SLOT1.A51(GND53) SLOT1.A54(GND54) SLOT1.A55(GND55) SLOT1.A58(GND56) SLOT1.A59(GND57) SLOT1.A62(GND58) SLOT1.A63(GND59) SLOT1.A66(GND60) SLOT1.A67(GND61) SLOT1.A70(GND62) SLOT1.A71(GND63) SLOT1.A74(GND64) SLOT1.A75(GND65) SLOT1.A78(GND66) SLOT1.A79(GND67) SLOT1.A82(GND68) SLOT1.B4(GND1) SLOT1.B7(GND2) SLOT1.B13(GND3) SLOT1.B16(GND4) SLOT1.B18(GND5) SLOT1.B21(GND6) SLOT1.B22(GND7) SLOT1.B25(GND8) SLOT1.B26(GND9) SLOT1.B29(GND10) SLOT1.B32(GND11) SLOT1.B35(GND12) SLOT1.B36(GND13) SLOT1.B39(GND14) SLOT1.B40(GND15) SLOT1.B43(GND16) SLOT1.B44(GND17) SLOT1.B47(GND18) SLOT1.B49(GND19) SLOT1.B52(GND20) SLOT1.B53(GND21) SLOT1.B56(GND22) SLOT1.B57(GND23) SLOT1.B60(GND24) SLOT1.B61(GND25) SLOT1.B64(GND26) SLOT1.B65(GND27) SLOT1.B68(GND28) SLOT1.B69(GND29) SLOT1.B72(GND30) SLOT1.B73(GND31) SLOT1.B76(GND32) SLOT1.B77(GND33) SLOT1.B80(GND34) SLOT2.A1(PRSNT1#) SLOT2.A4(GND12) SLOT2.A12(GND13) SLOT2.A15(GND14) SLOT2.A18(GND15) SLOT2.A20(GND16) SLOT2.A23(GND17) SLOT2.A24(GND18) SLOT2.A27(GND19) SLOT2.A28(GND20) SLOT2.A31(GND21) SLOT2.B4(GND1) SLOT2.B7(GND2) SLOT2.B13(GND3) SLOT2.B16(GND4) SLOT2.B18(GND5) SLOT2.B21(GND6) SLOT2.B22(GND7) SLOT2.B25(GND8) SLOT2.B26(GND9) SLOT2.B29(GND10) SLOT2.B32(GND11) SLOT3.A1(PRSNT1#) SLOT3.A4(GND12) SLOT3.A12(GND13) SLOT3.A15(GND14) SLOT3.A18(GND15) SLOT3.A20(GND16) SLOT3.A23(GND17) SLOT3.A24(GND18) SLOT3.A27(GND19) SLOT3.A28(GND20) SLOT3.A31(GND21) SLOT3.B4(GND1) SLOT3.B7(GND2) SLOT3.B13(GND3) SLOT3.B16(GND4) SLOT3.B18(GND5) SLOT3.B21(GND6) SLOT3.B22(GND7) SLOT3.B25(GND8) SLOT3.B26(GND9) SLOT3.B29(GND10) SLOT3.B32(GND11) SLOT4.A4(GND35) SLOT4.A12(GND36) SLOT4.A15(GND37) SLOT4.A18(GND38) SLOT4.A20(GND39) SLOT4.A23(GND40) SLOT4.A24(GND41) SLOT4.A27(GND42) SLOT4.A28(GND43) SLOT4.A31(GND44) SLOT4.A34(GND45) SLOT4.A37(GND46) SLOT4.A38(GND47) SLOT4.A41(GND48) SLOT4.A42(GND49) SLOT4.A45(GND50) SLOT4.A46(GND51) SLOT4.A49(GND52) SLOT4.A51(GND53) SLOT4.A54(GND54) SLOT4.A55(GND55) SLOT4.A58(GND56) SLOT4.A59(GND57) SLOT4.A62(GND58) SLOT4.A63(GND59) SLOT4.A66(GND60) SLOT4.A67(GND61) SLOT4.A70(GND62) SLOT4.A71(GND63) SLOT4.A74(GND64) SLOT4.A75(GND65) SLOT4.A78(GND66) SLOT4.A79(GND67) SLOT4.A82(GND68) SLOT4.B4(GND1) SLOT4.B7(GND2) SLOT4.B13(GND3) SLOT4.B16(GND4) SLOT4.B18(GND5) SLOT4.B21(GND6) SLOT4.B22(GND7) SLOT4.B25(GND8) SLOT4.B26(GND9) SLOT4.B29(GND10) SLOT4.B32(GND11) SLOT4.B35(GND12) SLOT4.B36(GND13) SLOT4.B39(GND14) SLOT4.B40(GND15) SLOT4.B43(GND16) SLOT4.B44(GND17) SLOT4.B47(GND18) SLOT4.B49(GND19) SLOT4.B52(GND20) SLOT4.B53(GND21) SLOT4.B56(GND22) SLOT4.B57(GND23) SLOT4.B60(GND24) SLOT4.B61(GND25) SLOT4.B64(GND26) SLOT4.B65(GND27) SLOT4.B68(GND28) SLOT4.B69(GND29) SLOT4.B72(GND30) SLOT4.B73(GND31) SLOT4.B76(GND32) SLOT4.B77(GND33) SLOT4.B80(GND34) SR1.2 SR2.2 SR18.2 SR60.2 SR139.1 SR160.2 SR336.2 SR371.2 SR545.2 SR629.2 SR653.2 SR664.1 SR694.2 SR711.2 SR712.2 SR749.2 SR758.2 SR7637.2 SR7646.1 SR7658.2 SR7690.2 SR7717.1 SR7781.2 SR7787.2 SR7788.2 SS4.1(GND_1) SS4.3(GND_2) SS4.9(GND_3) SS4.15(GND_4) SS4.21(GND_5) SS4.27(GND_6) SS4.33(GND_7) SS4.39(GND_8) SS4.45(GND_9) SS4.51(GND_10) SS4.57(GND_11) SS4.71(GND_12) SS4.73(GND_13) SS4.75(GND_14) SS4.76(SIDE1) SS4.77(SIDE2) SW1.3 SW1.4 SW2.3 SW2.4 TUC21.2 TUC22.2 TUCE1.2 TUU2.2(GND) U2FC1.2 U2FC2.2 U4.15(PGND) U4.65(GND) U4.66(GND1) U4.67(GND2) U4.68(GND3) U4.69(GND4) U4.70(GND5) U4.71(GND6) U4.72(GND7) U4.73(GND8) U4.74(GND9) U4.75(GND10) U4.76(GND11) U4.77(GND12) U5.4(GNDA_1) U5.16(GNDA_2) U5.25(GNDA_3) U5.33(GND1) U5.34(GND2) U5.35(GND3) U5.36(GND4) U5.37(GND5) U5.38(GND6) U5.39(GND7) U5.40(GND8) U5.41(GND9) U10.27(TESTMODE[2]) U10.41(GND) U10.42(GND1) U10.43(GND2) U10.44(GND3) U10.45(GND4) U10.46(GND5) U10.47(GND6) U10.48(GND7) U10.49(GND8) U10.50(GND9) U15.8(VSSA) U15.20(PB2) U15.23(VSS_1) U15.35(VSS_2) U15.47(VSS_3) U51.14(GND1) U51.17(GND2) U104.1(VSS1) U104.3(VSS2) U104.17(VSS3) U104.18(AVSS) U104.35(VSS4) U104.40(HVSS) U104.59(VSS5) U104.66(VSS6) U104.82(VSS7) U104.83(VSS8) U104.86(VSS9) U104.88(VSS10) U104.90(VSS11) U104.117(VSS12) U942691.14(GND1) U942691.17(GND2) UC2.4(GND) UC9.2 UC10.2 UC11.2 UC12.2 UC16.2 UC68.2 UC69.2 UC72.2 UC74.2 UC75.2 UC77.2 UC78.2 UC79.2 UC81.2 UC82.2 UC83.2 UC90.2 UC91.2 UC92.2 UC93.2 UC94.2 UC641.2 UC950.2 UC965.2 UC968.2 UC969.2 UC970.2 UC971.2 UC972.2 UC973.2 UC974.2 UCB1.2 UCB2.2 UCB3.2 UCB4.2 UCB5.2 UCB6.2 UCB9.2 UCB18.2 UCB19.2 UCB23.2 UCB24.2 UCB25.2 UCB26.2 UCB27.2 UCB28.2 UCC1.2 UCC2.2 UCC3.2 UCC4.2 UCC5.2 UCC6.2 UCC7.2 UCC8.2 UCC9.2 UCC10.2 UCC11.2 UCC12.2 UCC13.2 UCC14.2 UCE10.2 UCE11.2 UCE12.2 UCR23.2 UCR45.2 UD8878.1(ANODE) UD8879.1(ANODE) UD8880.2(CATHODE) UD8881.1(ANODE) UR6.2 UR69686.1 UR69705.2 UR69716.2 UR69718.2 UR69720.2 UR69722.2 UR69724.2 UR69725.2 UU4.3(GND1) UU4.8(GND2) UU5.3(GND1) UU5.8(GND2) UU10.3(GND1) UU10.8(GND2) UU14.3(GND1) UU14.8(GND2) UU22.3(GND1) UU22.8(GND2) UU26.3(GND1) UU26.8(GND2) UU34.3(GND1) UU34.8(GND2) UU39.3(GND1) UU39.8(GND2) UU40.3(GND1) UU40.8(GND2) UU43.3(GND1) UU43.8(GND2) UU44.3(GND1) UU44.8(GND2) UU45.2(GND) UU47.2(GND) UU50.2(GND) UU51.2(GND) UU52.3(GND1) UU52.8(GND2) UU53.3(GND1) UU53.8(GND2) UU54.2(GND) VCB155.2 X1.2(GND1) X1.4(GND2) XC33.2 XC35.2 XC89.2 XC90.2 XC91.2 XC92.2 XC93.2 XC94.2 XC95.2 XC128.2 XC129.2 XC130.2 XC131.2 XCB5.2 XCB6.2 XCE2.2 XCE14.2 XCE15.2 XCE16.2 XCE17.2 XDP2.2(GND2) XDP2.7(GND3) XDP2.8(GND4) XDP2.13(GND5) XDP2.14(GND6) XDP2.19(GND7) XDP2.20(GND8) XDP2.25(GND9) XDP2.26(GND10) XDP2.31(GND11) XDP2.32(GND12) XDP2.37(GND13) XDP2.38(GND14) XDP2.49(GND15) XDP2.50(GND16) XDP2.59(GND17) XDP2.60(GND18) XR3.1 XR4.2 XR5.1 XR10.2 XR11.2 XR13.1 XR14.2 XR15.2 XR19.1 XR20.2 XU1.A4(VSS8) XU1.A7(VSS_6) XU1.A11(VSS_1) XU1.A13(VSS_2) XU1.A15(VSS_3) XU1.A17(VSS_4) XU1.A24(VSS_5) XU1.AA3(VSS_7) XU1.AA8(VSS_9) XU1.AA33(VSS_8) XU1.AB5(VSS_11) XU1.AB39(VSS_10) XU1.AC3(VSS_12) XU1.AC6(VSS_16) XU1.AC33(VSS_13) XU1.AC34(VSS_14) XU1.AC35(VSS_15) XU1.AD1(VSS_17) XU1.AD4(VSS_23) XU1.AD6(VSS_25) XU1.AD7(VSS_26) XU1.AD8(VSS_27) XU1.AD33(VSS_18) XU1.AD36(VSS_19) XU1.AD37(VSS_20) XU1.AD38(VSS_21) XU1.AD39(VSS_22) XU1.AD40(VSS_24) XU1.AE3(VSS_28) XU1.AE4(VSS_SAIO_SENSE) XU1.AE5(VSS_31) XU1.AE8(VSS_32) XU1.AE33(VSS_29) XU1.AE36(VSS_30) XU1.AF1(VSS_33) XU1.AF5(VSS_38) XU1.AF8(VSS_39) XU1.AF33(VSS_34) XU1.AF36(VSS_35) XU1.AF37(VSS_36) XU1.AF40(VSS_37) XU1.AG1(VSS_40) XU1.AG2(VSS_41) XU1.AG3(VSS_42) XU1.AG4(VSS_45) XU1.AG5(VSS_46) XU1.AG8(VSS_47) XU1.AG33(VSS_43) XU1.AG36(VSS_44) XU1.AH5(VSS_54) XU1.AH8(VSS_55) XU1.AH33(VSS_48) XU1.AH36(VSS_49) XU1.AH37(VSS_50) XU1.AH38(VSS_51) XU1.AH39(VSS_52) XU1.AH40(VSS_53) XU1.AJ1(VSS_56) XU1.AJ4(VSS_63) XU1.AJ5(VSS_64) XU1.AJ8(VSS_65) XU1.AJ24(VSS1) XU1.AJ30(VSS2) XU1.AJ31(VSS_57) XU1.AJ32(VSS_58) XU1.AJ33(VSS_59) XU1.AJ34(VSS_60) XU1.AJ35(VSS_61) XU1.AJ36(VSS_62) XU1.AK5(VSS_84) XU1.AK6(VSS_85) XU1.AK7(VSS_86) XU1.AK8(VSS_87) XU1.AK9(VSS_88) XU1.AK10(VSS_66) XU1.AK12(VSS_67) XU1.AK13(VSS_68) XU1.AK15(VSS_69) XU1.AK16(VSS_70) XU1.AK17(VSS_71) XU1.AK18(VSS_72) XU1.AK19(VSS_73) XU1.AK20(VSS_74) XU1.AK22(VSS3) XU1.AK23(VSS_75) XU1.AK25(VSS_76) XU1.AK26(VSS_77) XU1.AK27(VSS4) XU1.AK28(VSS_78) XU1.AK29(VSS_79) XU1.AK30(VSS_80) XU1.AK36(VSS_81) XU1.AK37(VSS_82) XU1.AK40(VSS_83) XU1.AL1(VSS_89) XU1.AL2(VSS_92) XU1.AL3(VSS_96) XU1.AL4(VSS_99) XU1.AL5(VSS_100) XU1.AL11(VSS_90) XU1.AL14(VSS_91) XU1.AL21(VSS_93) XU1.AL24(VSS_94) XU1.AL27(VSS_95) XU1.AL30(VSS_97) XU1.AL36(VSS_98) XU1.AM5(VSS_118) XU1.AM11(VSS_101) XU1.AM14(VSS_102) XU1.AM17(VSS_103) XU1.AM19(VSS_104) XU1.AM24(VSS_105) XU1.AM27(VSS_106) XU1.AM30(VSS_107) XU1.AM31(VSS_108) XU1.AM32(VSS_109) XU1.AM33(VSS_110) XU1.AM34(VSS_111) XU1.AM35(VSS_112) XU1.AM36(VSS_113) XU1.AM37(VSS_114) XU1.AM38(VSS_115) XU1.AM39(VSS_116) XU1.AM40(VSS_117) XU1.AN1(VSS_119) XU1.AN4(VSS_131) XU1.AN5(VSS_132) XU1.AN6(VSS_133) XU1.AN7(VSS_134) XU1.AN8(VSS_135) XU1.AN9(VSS_136) XU1.AN10(VSS_120) XU1.AN11(VSS_121) XU1.AN14(VSS_122) XU1.AN16(VSS_123) XU1.AN19(VSS_124) XU1.AN22(VSS_125) XU1.AN23(VSS_126) XU1.AN24(VSS_127) XU1.AN27(VSS_128) XU1.AN30(VSS_129) XU1.AN36(VSS_130) XU1.AP5(VSS_145) XU1.AP11(VSS_137) XU1.AP14(VSS_138) XU1.AP24(VSS_139) XU1.AP27(VSS_140) XU1.AP30(VSS_141) XU1.AP36(VSS_142) XU1.AP37(VSS_143) XU1.AP40(VSS_144) XU1.AR1(VSS_146) XU1.AR2(VSS_153) XU1.AR3(VSS_160) XU1.AR4(VSS_168) XU1.AR5(VSS_169) XU1.AR11(VSS_147) XU1.AR14(VSS_148) XU1.AR16(VSS_149) XU1.AR17(VSS_150) XU1.AR18(VSS_151) XU1.AR19(VSS_152) XU1.AR20(VSS_154) XU1.AR21(VSS_155) XU1.AR22(VSS_156) XU1.AR23(VSS_157) XU1.AR24(VSS_158) XU1.AR27(VSS_159) XU1.AR30(VSS_161) XU1.AR31(VSS_162) XU1.AR32(VSS_163) XU1.AR33(VSS_164) XU1.AR34(VSS_165) XU1.AR35(VSS_166) XU1.AR36(VSS_167) XU1.AT5(VSS_192) XU1.AT6(VSS_193) XU1.AT7(VSS_194) XU1.AT8(VSS_195) XU1.AT9(VSS_196) XU1.AT10(VSS_170) XU1.AT11(VSS_171) XU1.AT12(VSS_172) XU1.AT13(VSS_173) XU1.AT14(VSS_174) XU1.AT15(VSS_175) XU1.AT17(VSS_176) XU1.AT24(VSS_177) XU1.AT25(VSS_178) XU1.AT26(VSS_179) XU1.AT27(VSS_180) XU1.AT28(VSS_181) XU1.AT29(VSS_182) XU1.AT30(VSS_183) XU1.AT31(VSS_184) XU1.AT32(VSS_185) XU1.AT34(VSS_186) XU1.AT36(VSS_187) XU1.AT37(VSS_188) XU1.AT38(VSS_189) XU1.AT39(VSS_190) XU1.AT40(VSS_191) XU1.AU1(VSS_197) XU1.AU4(VSS_201) XU1.AU5(VSS_202) XU1.AU7(VSS_203) XU1.AU25(VSS_198) XU1.AU30(VSS_199) XU1.AU34(VSS_200) XU1.AU39(VSS7) XU1.AU40(VSS6) XU1.AV2(VSS_204) XU1.AV5(VSS_210) XU1.AV9(VSS_211) XU1.AV26(VSS_205) XU1.AV28(VSS_206) XU1.AV30(VSS_207) XU1.AV34(VSS_208) XU1.AV38(VSS_209) XU1.AV39(VSS12) XU1.AW3(VSS_212) XU1.AW5(VSS_217) XU1.AW9(VSS_218) XU1.AW30(VSS_213) XU1.AW32(VSS_214) XU1.AW34(VSS_215) XU1.AW36(VSS_216) XU1.AW38(VSS15) XU1.AY3(VSS_220) XU1.AY5(VSS_222) XU1.AY7(VSS_223) XU1.AY9(VSS_224) XU1.AY27(VSS_219) XU1.AY30(VSS_221) XU1.B6(VSS_229) XU1.B24(VSS_225) XU1.B26(VSS_226) XU1.B28(VSS_227) XU1.B30(VSS_228) XU1.B38(VSS9) XU1.C2(VSS10) XU1.C5(VSS_242) XU1.C8(VSS_243) XU1.C10(VSS_230) XU1.C12(VSS_231) XU1.C14(VSS_232) XU1.C16(VSS_233) XU1.C18(VSS_234) XU1.C20(VSS_235) XU1.C22(VSS_236) XU1.C24(VSS_237) XU1.C31(VSS_238) XU1.C33(VSS_239) XU1.C35(VSS_240) XU1.C37(VSS_241) XU1.D4(VSS_250) XU1.D7(VSS_251) XU1.D24(VSS_244) XU1.D26(VSS_245) XU1.D28(VSS_246) XU1.D30(VSS_247) XU1.D37(VSS_248) XU1.D39(VSS_249) XU1.D40(VSS11) XU1.E3(VSS_259) XU1.E6(VSS_264) XU1.E9(VSS_265) XU1.E11(VSS_252) XU1.E13(VSS_253) XU1.E15(VSS_254) XU1.E17(VSS_255) XU1.E19(VSS_256) XU1.E21(VSS_257) XU1.E23(VSS_258) XU1.E31(VSS_260) XU1.E33(VSS_261) XU1.E35(VSS_262) XU1.E37(VSS_263) XU1.F1(VSS_266) XU1.F4(VSS_272) XU1.F7(VSS_274) XU1.F10(VSS_267) XU1.F22(VSS_268) XU1.F26(VSS_269) XU1.F28(VSS_270) XU1.F30(VSS_271) XU1.F36(VSS5) XU1.F40(VSS_273) XU1.G3(VSS_281) XU1.G6(VSS_284) XU1.G8(VSS_285) XU1.G11(VSS_275) XU1.G13(VSS_276) XU1.G15(VSS_277) XU1.G17(VSS_278) XU1.G19(VSS_279) XU1.G22(VSS_280) XU1.G31(VSS_282) XU1.G33(VSS_283) XU1.H1(VSS_286) XU1.H4(VSS_295) XU1.H7(VSS_296) XU1.H9(VSS_298) XU1.H11(VSS13) XU1.H12(VSS14) XU1.H21(VSS_287) XU1.H24(VSS_288) XU1.H26(VSS_289) XU1.H28(VSS_290) XU1.H30(VSS_291) XU1.H35(VSS_292) XU1.H37(VSS_293) XU1.H39(VSS_294) XU1.J3(VSS_304) XU1.J6(VSS_307) XU1.J10(VSS_299) XU1.J12(VSS_300) XU1.J16(VSS_301) XU1.J18(VSS_302) XU1.J20(VSS_303) XU1.J32(VSS_305) XU1.J34(VSS_306) XU1.K1(VSS_308) XU1.K4(VSS_322) XU1.K7(VSS_323) XU1.K14(VSS_309) XU1.K15(VSS_310) XU1.K17(VSS_311) XU1.K19(VSS_312) XU1.K22(VSS_313) XU1.K24(VSS_314) XU1.K26(VSS_315) XU1.K28(VSS_316) XU1.K30(VSS_317) XU1.K33(VSS_318) XU1.K35(VSS_319) XU1.K37(VSS_320) XU1.K39(VSS_321) XU1.L3(VSS_326) XU1.L6(VSS_328) XU1.L9(VSS_329) XU1.L11(VSS_324) XU1.L13(VSS_325) XU1.L32(VSS_327) XU1.M1(VSS_330) XU1.M4(VSS_344) XU1.M7(VSS_345) XU1.M10(VSS_331) XU1.M12(VSS_332) XU1.M15(VSS_333) XU1.M17(VSS_334) XU1.M19(VSS_335) XU1.M21(VSS_336) XU1.M23(VSS_337) XU1.M25(VSS_338) XU1.M27(VSS_339) XU1.M29(VSS_340) XU1.M35(VSS_341) XU1.M37(VSS_342) XU1.M39(VSS_343) XU1.N3(VSS_346) XU1.N6(VSS_348) XU1.N8(VSS_349) XU1.N33(VSS_347) XU1.P1(VSS_350) XU1.P4(VSS_354) XU1.P35(VSS_351) XU1.P37(VSS_352) XU1.P39(VSS_353) XU1.R3(VSS_355) XU1.R6(VSS_357) XU1.R8(VSS_358) XU1.R33(VSS_356) XU1.T1(VSS_359) XU1.T4(VSS_363) XU1.T35(VSS_360) XU1.T37(VSS_361) XU1.T39(VSS_362) XU1.U3(VSS_364) XU1.U6(VSS_366) XU1.U33(VSS_365) XU1.V1(VSS_367) XU1.V8(VSS_371) XU1.V35(VSS_368) XU1.V37(VSS_369) XU1.V39(VSS_370) XU1.W3(VSS_372) XU1.W6(VSS_374) XU1.W33(VSS_373) XU1.Y5(VSS_377) XU1.Y35(VSS_375) XU1.Y37(VSS_376) Y10.2(GND1) Y10.4(GND2) Y18.2(GND1) Y18.4(GND2) Y19.2(GND1) Y19.4(GND2)
GND_CTR: J9.R10(GND) LR20.1
V5_ALW_MON: AC39.1 OR5.1 OR6.1 U104.15(V5_ALW_MON)
VCC: PC568.1 PR6601.2 PU12.1(VCC)
VCC_SENSE: PJP621.2 XU1.C38(VCC_SENSE)
VCCGT_SENSE: PJP623.2 XU1.F39(VCCGT_SENSE)
VCCIO_PG: ECC56.1 ECQ12.1(BASE) ECQ13.3(COLLECTOR) ECR105.2
VCCIO_SENSE: PR313.2 XU1.AF4(VCCIO_SENSE)
VCCSA_PWRGD: PR70176.2 PU10.8(PGOOD)
VCCSA_SENSE: PR317.2 XU1.AD5(VCCSA_SENSE)
VCCST&PCH_PWRGD: HC29.1 MQ28.2(GATE) MQ28.5(GATE) OR51.2 PQ9777.3(DRAIN)
VCCST_PWRGD_1P0V: HC25.1 HR630.1 MQ28.6(DRAIN) OR52.2 PR4.1
VCCST_PWRGD_DISCHARGE: MQ21.3(DRAIN) PR4.2
VDDQ_DAC: PC569.1 PR70225.2 PU12.8(VREF2)
VDDQ_PWRGD: PR6506.2 PU651.8(PGOOD) U104.111((MEM_REG_PG)GP061)
VDDQ_SET: PR6602.2 PU12.6(PINSET2) R69694.1
VSS_SENSE: PJP622.2 XU1.D38(VSS_SENSE)
VSSGT_SENSE: PJP624.2 XU1.F38(VSSGT_SENSE)
+0P95V_CPUIO: ECR92.1 HR4.1 HR6.1 HR29.1 PC153.1 PC156.1 PC157.1 PC161.1 PC162.1 PC163.1 PC164.1 PC834.1 PCE14.1 PQ19.1(S_1) PQ19.2(S_2) PQ19.3(S_3) PR3.1 PR130.1 PR131.1 XU1.AJ23(VCCIO_1) XU1.AK11(VCCIO_2) XU1.AK14(VCCIO_3) XU1.AK24(VCCIO_4) XU1.M8(VCCIO_5) XU1.P8(VCCIO_6) XU1.T8(VCCIO_7) XU1.U8(VCCIO_8) XU1.W8(VCCIO_9)
+0P95V_DISCHARGE: MQ21.6(DRAIN) PR3.2
+1P2V: PC640676.1 PQ9784.2(SOURCE) U4.1(VDD1) U4.12(VDD2) U4.33(VDD3) U4.35(VDDU1) U4.41(VDDU2) U4.47(VDDU3) U4.52(VDDP1) U4.58(VDDP2) UC68.1 UC69.1 UC77.1 UC78.1 UC83.1 UC90.1 UC92.1 UC970.1
+1P2V_DUAL: CON_XMM1.7(DQS9P) CON_XMM1.18(DQS10P) CON_XMM1.29(DQS11P) CON_XMM1.40(DQS12P) CON_XMM1.51(DQS17P) CON_XMM1.59(VDD<25>) CON_XMM1.61(VDD<24>) CON_XMM1.64(VDD<23>) CON_XMM1.67(VDD<22>) CON_XMM1.70(VDD<21>) CON_XMM1.73(VDD<20>) CON_XMM1.76(VDD<19>) CON_XMM1.80(VDD<18>) CON_XMM1.83(VDD<17>) CON_XMM1.85(VDD<16>) CON_XMM1.88(VDD<15>) CON_XMM1.90(VDD<14>) CON_XMM1.92(VDD<13>) CON_XMM1.99(DQS13P) CON_XMM1.110(DQS14P) CON_XMM1.121(DQS15P) CON_XMM1.132(DQS16P) CON_XMM1.204(VDD<12>) CON_XMM1.206(VDD<11>) CON_XMM1.209(VDD<10>) CON_XMM1.212(VDD<9>) CON_XMM1.215(VDD<8>) CON_XMM1.217(VDD<7>) CON_XMM1.220(VDD<6>) CON_XMM1.223(VDD<5>) CON_XMM1.226(VDD<4>) CON_XMM1.229(VDD<3>) CON_XMM1.231(VDD<2>) CON_XMM1.233(VDD<1>) CON_XMM1.236(VDD<0>) CON_XMM2.7(DQS9P) CON_XMM2.18(DQS10P) CON_XMM2.29(DQS11P) CON_XMM2.40(DQS12P) CON_XMM2.51(DQS17P) CON_XMM2.59(VDD<25>) CON_XMM2.61(VDD<24>) CON_XMM2.64(VDD<23>) CON_XMM2.67(VDD<22>) CON_XMM2.70(VDD<21>) CON_XMM2.73(VDD<20>) CON_XMM2.76(VDD<19>) CON_XMM2.80(VDD<18>) CON_XMM2.83(VDD<17>) CON_XMM2.85(VDD<16>) CON_XMM2.88(VDD<15>) CON_XMM2.90(VDD<14>) CON_XMM2.92(VDD<13>) CON_XMM2.99(DQS13P) CON_XMM2.110(DQS14P) CON_XMM2.121(DQS15P) CON_XMM2.132(DQS16P) CON_XMM2.204(VDD<12>) CON_XMM2.206(VDD<11>) CON_XMM2.209(VDD<10>) CON_XMM2.212(VDD<9>) CON_XMM2.215(VDD<8>) CON_XMM2.217(VDD<7>) CON_XMM2.220(VDD<6>) CON_XMM2.223(VDD<5>) CON_XMM2.226(VDD<4>) CON_XMM2.229(VDD<3>) CON_XMM2.231(VDD<2>) CON_XMM2.233(VDD<1>) CON_XMM2.236(VDD<0>) CON_XMM3.7(DQS9P) CON_XMM3.18(DQS10P) CON_XMM3.29(DQS11P) CON_XMM3.40(DQS12P) CON_XMM3.51(DQS17P) CON_XMM3.59(VDD<25>) CON_XMM3.61(VDD<24>) CON_XMM3.64(VDD<23>) CON_XMM3.67(VDD<22>) CON_XMM3.70(VDD<21>) CON_XMM3.73(VDD<20>) CON_XMM3.76(VDD<19>) CON_XMM3.80(VDD<18>) CON_XMM3.83(VDD<17>) CON_XMM3.85(VDD<16>) CON_XMM3.88(VDD<15>) CON_XMM3.90(VDD<14>) CON_XMM3.92(VDD<13>) CON_XMM3.99(DQS13P) CON_XMM3.110(DQS14P) CON_XMM3.121(DQS15P) CON_XMM3.132(DQS16P) CON_XMM3.204(VDD<12>) CON_XMM3.206(VDD<11>) CON_XMM3.209(VDD<10>) CON_XMM3.212(VDD<9>) CON_XMM3.215(VDD<8>) CON_XMM3.217(VDD<7>) CON_XMM3.220(VDD<6>) CON_XMM3.223(VDD<5>) CON_XMM3.226(VDD<4>) CON_XMM3.229(VDD<3>) CON_XMM3.231(VDD<2>) CON_XMM3.233(VDD<1>) CON_XMM3.236(VDD<0>) CON_XMM4.7(DQS9P) CON_XMM4.18(DQS10P) CON_XMM4.29(DQS11P) CON_XMM4.40(DQS12P) CON_XMM4.51(DQS17P) CON_XMM4.59(VDD<25>) CON_XMM4.61(VDD<24>) CON_XMM4.64(VDD<23>) CON_XMM4.67(VDD<22>) CON_XMM4.70(VDD<21>) CON_XMM4.73(VDD<20>) CON_XMM4.76(VDD<19>) CON_XMM4.80(VDD<18>) CON_XMM4.83(VDD<17>) CON_XMM4.85(VDD<16>) CON_XMM4.88(VDD<15>) CON_XMM4.90(VDD<14>) CON_XMM4.92(VDD<13>) CON_XMM4.99(DQS13P) CON_XMM4.110(DQS14P) CON_XMM4.121(DQS15P) CON_XMM4.132(DQS16P) CON_XMM4.204(VDD<12>) CON_XMM4.206(VDD<11>) CON_XMM4.209(VDD<10>) CON_XMM4.212(VDD<9>) CON_XMM4.215(VDD<8>) CON_XMM4.217(VDD<7>) CON_XMM4.220(VDD<6>) CON_XMM4.223(VDD<5>) CON_XMM4.226(VDD<4>) CON_XMM4.229(VDD<3>) CON_XMM4.231(VDD<2>) CON_XMM4.233(VDD<1>) CON_XMM4.236(VDD<0>) D4CB17.1 D4CB18.1 D4CB19.1 D4CB20.1 D4CB21.1 D4CB22.1 D4CB23.1 D4CB24.1 D4CB25.1 D4CB26.1 D4CB27.1 D4CB28.1 D4CB29.1 D4CB30.1 D4CB31.1 D4CB32.1 D4CB33.1 D4CB34.1 D4CB35.1 D4CB36.1 D4CB37.1 D4CB38.1 D4CB39.1 D4CB40.1 D4CB41.1 D4CB48.1 D4CB49.1 D4CB50.1 D4CB51.1 D4CB52.1 D4CB53.1 D4CB54.1 D4CB55.1 D4CB57.1 D4CB58.1 D4CB59.1 D4CB60.1 D4CB61.1 D4CB62.1 D4CB63.1 D4CB64.1 D4CB65.1 D4CB66.1 D4CB67.1 D4CB68.1 D4CB69.1 D4CB70.1 D4CB71.1 D4CB72.1 D4CB73.1 D4CB74.1 D4CB75.1 D4CB76.1 D4CB77.1 D4CB78.1 D4CB88.1 D4CB89.1 D4CE4.1 D4R1.1 D4R10.1 D4R15.1 D4R21.1 D4R24.1 D4R33.1 HR70.2 O2R22.1 PC150.1 PC483.1 PC6521.1 PC6522.1 PC6523.1 PC6524.1 PC6525.1 PCE652.1 PCE653.1 PJP652.1 PL652.2 PQ19.5(D) PQ19.6(D_1) PQ19.7(D_2) PQ19.8(D_3) PQ19.9(D_4) PQ19.10(D_5) PQ19.11(D_6) PQ19.12(D_7) PQ19.13(D_8) PQ19.14(D_9) PR9.1 PR125.1 PR70212.1 PU80.1(VIN) RFC100.1 RFC105.1 RFC108.1 RFC111.1 SR659.1 XU1.AT18(VDDQ_1) XU1.AT21(VDDQ_2) XU1.AU13(VDDQ_3) XU1.AU15(VDDQ_4) XU1.AU19(VDDQ_5) XU1.AU23(VDDQ_6) XU1.AV11(VDDQ_7) XU1.AV17(VDDQ_8) XU1.AV21(VDDQ_9) XU1.AW10(VDDQ_10) XU1.AW14(VDDQ_11) XU1.AW25(VDDQ_12) XU1.AY12(VDDQ_13) XU1.AY16(VDDQ_14) XU1.AY18(VDDQ_15) XU1.AY23(VDDQ_16)
+1P2V_DUAL__FB: PC640664.1 PR70222.2 PR70223.1 PU651.6(FB)
+1P2V_DUAL__LG_D: PR70220.1 PR70227.1 PU651.4(LGATE/OCSET)
+1P2V_DUAL__LX_D: PC640658.2 PC640662.1 PC640663.1 PL652.1 PQ651.1(S_1) PQ651.2(S_2) PQ651.3(S_3) PQ652.5(D) PQ652.6(D_1) PQ652.7(D_2) PQ652.8(D_3) PQ652.9(D_4) PQ652.10(D_5) PQ652.11(D_6) PQ652.12(D_7) PQ652.13(D_8) PQ652.14(D_9) PQ653.5(D) PQ653.6(D_1) PQ653.7(D_2) PQ653.8(D_3) PQ653.9(D_4) PQ653.10(D_5) PQ653.11(D_6) PQ653.12(D_7) PQ653.13(D_8) PQ653.14(D_9) PR70216.1 PR70221.2 PU651.3(PHASE)
+1P2V_DUAL__REFOUT: PC640653.1 PR70211.1 PU651.10(REFOUT)
+1P2V_DUAL__UG_D: PR70210.1 PU651.2(UGATE)
+1P2V_DUAL__VCC_C: PC640665.1 PR70219.2 PU651.5(VCC)
+1P2V_DUAL_BOOT_D: PR70215.2 PU651.1(BOOT)
+1P2V_DUAL_BOOTR_D: PC640663.2 PR70215.1
+1P2V_DUAL_DAC_A: PR70213.2 PR70217.1 PR70224.1 PR70225.1
+1P2V_DUAL_DISCHARGE: MQ24.6(DRAIN) PR9.2
+1P2V_DUAL_EN_A: PC640671.1 PR11.2 PU651.7(EN)
+1P2V_DUAL_FB_C_B: PC6527.1 PJP652.2 PR70260.2
+1P2V_DUAL_FB_R_B: PC640664.2 PR70222.1 PR70260.1
+1P2V_DUAL_LG_R_D: PC640656.1 PC640667.1 PQ652.4(G) PQ653.4(G) PR70220.2
+1P2V_DUAL_REFIN: PC640661.1 PR70211.2 PR70224.2 PU651.9(REFIN)
+1P2V_DUAL_UG_R_D: PC640658.1 PQ651.4(G) PR70210.2 PR70221.1
+1P2V_FB: PC6809.2 PR6807.2 PR6809.1 PU681.7(FB)
+1P2V_FB_R: PC6809.1 PR6806.2 PR6807.1
+1P2V_SUS: PC6807.1 PC6808.1 PQ9784.3(DRAIN) PR6806.1 PU681.6(VOUT) U4.21(VDDSUS1) U4.34(VDDSUS2) UC72.1
+1P2V_SUS_CRT_MAIN_R: PC640675.1 PQ9784.1(GATE) PR136.1 PR70254.2
+1P2V_VDD: PC6810.1 PR6810.2 PU681.4(VDD)
+1P05_SA_BOOT_D: PR70198.2 PU10.1(BOOT)
+1P05_SA_BOOTR_D: PC640647.2 PR70198.1
+1P05_SA_DAC_A: PR70188.1 PR70196.2 PR70201.2 PR70207.1
+1P05_SA_EN_A: PC640672.2 PR70189.1 PU10.7(EN)
+1P05_SA_FB: PC640648.1 PR70205.2 PR70206.1 PU10.6(FB)
+1P05_SA_FB_C_B: PC640674.1 PJP17.2 PR317.1 PR70261.2
+1P05_SA_FB_R_B: PC640648.2 PR70205.1 PR70261.1
+1P05_SA_LG_D: PR70190.1 PR70203.1 PU10.4(LGATE/OCSET)
+1P05_SA_LG_R_D: PC640639.1 PC640651.1 PQ29.3(GATE) PQ30.3(GATE) PR70203.2
+1P05_SA_LX_D: PC640641.2 PC640646.1 PC640647.1 PL631.1 PQ28.4(SOURCE1) PQ28.8(SOURCE2) PQ29.1(DRAIN1) PQ29.2(DRAIN2) PQ29.5(DRAIN3) PQ29.6(DRAIN4) PQ29.7(DRAIN5) PQ30.1(DRAIN1) PQ30.2(DRAIN2) PQ30.5(DRAIN3) PQ30.6(DRAIN4) PQ30.7(DRAIN5) PR70199.1 PR70204.2 PU10.3(PHASE)
+1P05_SA_REFIN: PC640644.1 PR70194.2 PR70207.2 PU10.9(REFIN)
+1P05_SA_REFOUT: PC640637.1 PR70194.1 PU10.10(REFOUT)
+1P05_SA_SN: PC640645.1 PR70199.2
+1P05_SA_UG_D: PR70193.1 PU10.2(UGATE)
+1P05_SA_UG_R_D: PC640641.1 PQ28.3(GATE) PR70193.2 PR70204.1
+1P05_SA_VCC_C: PC640649.1 PR70202.2 PU10.5(VCC)
+1P05V_SA: PC142.1 PC149.1 PC329.1 PC331.1 PC332.1 PC333.1 PC334.1 PC335.1 PC640632.1 PC640633.1 PC640634.1 PC640635.1 PC640636.1 PCE12.1 PCE13.1 PJP17.1 PL631.2 PR70195.1 XU1.AA6(VCCSA_1) XU1.AA7(VCCSA_2) XU1.AB6(VCCSA_3) XU1.AB7(VCCSA_4) XU1.AB8(VCCSA_5) XU1.AC7(VCCSA_6) XU1.AC8(VCCSA_7) XU1.N7(VCCSA_8) XU1.P7(VCCSA_9) XU1.R7(VCCSA_10) XU1.T7(VCCSA_11) XU1.U7(VCCSA_12) XU1.V7(VCCSA_13) XU1.W7(VCCSA_14) XU1.Y6(VCCSA_15) XU1.Y7(VCCSA_16) XU1.Y8(VCCSA_17)
+2P5_VPP_FB: PC122.1 PR6608.2 PR6609.1 PR6611.1 PU7.6(FB)
+2P5_VPP_FB_C: PC122.2 PJP25.1 PR6608.1
+2P5_VPP_SW: PL661.1 PU7.1(LX1) PU7.2(LX2) PU7.3(LX3)
+2P5V_VPP: CON_XMM1.142(VPP<4>) CON_XMM1.143(VPP<3>) CON_XMM1.286(VPP<1>) CON_XMM1.287(VPP<0>) CON_XMM1.288(VPP<2>) CON_XMM2.142(VPP<4>) CON_XMM2.143(VPP<3>) CON_XMM2.286(VPP<1>) CON_XMM2.287(VPP<0>) CON_XMM2.288(VPP<2>) CON_XMM3.142(VPP<4>) CON_XMM3.143(VPP<3>) CON_XMM3.286(VPP<1>) CON_XMM3.287(VPP<0>) CON_XMM3.288(VPP<2>) CON_XMM4.142(VPP<4>) CON_XMM4.143(VPP<3>) CON_XMM4.286(VPP<1>) CON_XMM4.287(VPP<0>) CON_XMM4.288(VPP<2>) D4CB3.1 D4CB4.1 D4CB7.1 D4CB8.1 D4CB11.1 D4CB12.1 D4CB15.1 D4CB16.1 PC193.1 PC194.1 PC832.1 PJP25.2 PL661.2 PR14.1 RFC102.1 RFC104.1 RFC107.1 RFC110.1
+3P3V: AL2.1 AR53.1 CON4.1(+3V1) CON4.2(+3V2) CON4.12(+3V3) CON4.13(+3V4) CON_XMM1.139(SA0) CON_XMM1.284(VDDSPD) CON_XMM2.139(SA0) CON_XMM2.140(SA1) CON_XMM2.284(VDDSPD) CON_XMM3.284(VDDSPD) CON_XMM4.140(SA1) CON_XMM4.284(VDDSPD) D4C2.1 D4C7.1 D4C12.1 D4C17.1 ECR90.1 F3U2.7(HOLD#) F3U2.8(VDD) FD1.3(CATHODE) FD8.3(CATHODE) FD10.3(CATHODE) FR1.1 FR8.1 FR30.1 FR31.1 FR33.1 FR35.1 M2C13.1 M2C14.1 M2C15.1 M2C16.1 M2C17.1 M2C18.1 M2C19.1 M2C20.1 M2C21.1 M2C51.1 M2C52.1 M2C55.1 M2R1.1 MQ4.2(SOURCE) O2CB8.1 O2R21.1 OR37.2 P1CB4.1 P1CB8.1 P118.1 P118.3 PCH.AE13(VCCATS) PD2.1(ANODE) PR7.1 PR124.1 PR641.2 PR5816.1 PR5860.1 PR70176.1 PR70228.1 PT21.1 PT22.1 PT23.1 PT24.1 PT25.1 R18.1 R19.1 R25.1 RFC29.1 RFC30.1 RFC31.1 RFC32.1 RFC112.1 RFC120.1 RFC121.1 SCB32.1 SLOT1.A9(+3.3V_2) SLOT1.A10(+3.3V_3) SLOT1.B8(+3.3V_1) SLOT2.A9(+3.3V_2) SLOT2.A10(+3.3V_3) SLOT2.B8(+3.3V_1) SLOT3.A9(+3.3V_2) SLOT3.A10(+3.3V_3) SLOT3.B8(+3.3V_1) SLOT4.A9(+3.3V_2) SLOT4.A10(+3.3V_3) SLOT4.B8(+3.3V_1) SR7.1 SR8.1 SR87.1 SR94.1 SR164.1 SR166.1 SR343.1 SR366.1 SR650.1 SR667.1 SR671.1 SR673.1 SR680.1 SR713.1 SR714.1 SR738.1 SR746.1 SR7627.1 SR7628.1 SR7629.1 SR7638.1 SR7714.1 SR7784.1 SS4.2(3P3V_1) SS4.4(3P3V_2) SS4.12(3P3V_3) SS4.14(3P3V_4) SS4.16(3P3V_5) SS4.18(3P3V_6) SS4.70(3P3V_7) SS4.72(3P3V_8) SS4.74(3P3V_9) U4.4(VCC1) U4.32(VCC2) U4.38(VCCU1) U4.44(VCCU2) U4.55(VCCP1) U4.62(VCCP2) U104.4(VCC) UC74.1 UC79.1 UC81.1 UC82.1 UC91.1 UC93.1 UC94.1 UCR43.1 UD8869.2(CATHODE) UR195.1 UR69692.2 UR69695.1 UR69703.1 UR69704.1 XC91.1 XC94.1 XCB5.1 XCB6.1 XCE2.1 XCE15.1 XCE17.1 XR1.1 XR2.1 XR8.1 XR9.1 XR12.1 XR16.1 XR17.1 XR18.1
+3P3V_DISCHARGE: MQ25.6(DRAIN) PR7.2
+3P3V_DP: AC136.2 J125.20(DP_PWR) M1C1.1 M1F1.2 M1R8.1 M1R12.1 M1R13.1 RFC115.1
+3P3V_DVDD: AC14.1 AC15.1 AC20.1 AC21.1 AL2.2 AU1.1(DVDD) AU1.9(DVDD-IO) RFC113.1 RFC114.1
+3P3V_LAN: LCB2.1 LCB3.1 LCB4.1 LCB5.1 LCB16.1 LCB17.1 LCB18.1 LR1.1 LR2.1 LR3.2 LR5.1 LR10.2 LR23.2 MQ23.3(DRAIN) SC173.1 SR7707.2 U10.1(VDD33) U10.16(AVDD33)
+3P3V_UC: P311.1(+5V) P312.1 UC2.7(HOLD#) UC2.8(VCC) UCC11.1 UCC12.1 UCR3.1 UCR11.1 UCR12.1 UCR25.1 UCR28.1 UCR29.1 UCR34.1 UCR39.2 UCR41.2 UCR48.1
+3P3VA: AC47.1 AR57.2 O2CB1.1 O2CB2.1 O2CB3.1 O2CB4.1 O2CB5.1 O2CB6.1 O2CB16.1 O2CB17.1 O2CB20.1 O2R11.1 OR51.1 OR70.1 PC232.1 PC239.1 PC240.1 PC247.1 PC640631.1 PCH.BC24(VCCPDSW_3P3) PCH.Y16(VCCDSW_3P3) PJP20.2 PQ33.2(VOUT) PQ691.2(SOURCE) PR187.1 PR70250.1 R30.1 SCB31.1 SR360.1 SR363.1 SR365.1 SR375.1 SR759.1 SR7630.1 U104.22(V3_DUAL1) U104.32(V3_DUAL2) U104.45(HV3_DUAL) U104.55(V3_DUAL3) U104.60(V3_DUAL4) U104.65(V3_DUAL5) U104.77(V3_DUAL6) U104.104(V3_DUAL7) U104.120(V3_DUAL8) UCR26.1 UCR41.1
+3P3VA_LED: CR2.1(ANODE) R30.2
