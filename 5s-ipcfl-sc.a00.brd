# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_RX_P2_C: length 9
  TOP w0.102: UC991.2 231.86,89.63 232.53,89.63 232.59,89.69 232.59,89.84 232.67,89.92 UU22.4 UU22.7 234.05,89.92 234.11,89.87 234.11,89.69 234.17,89.63 234.34,89.63 arc(234.49,89.66) 234.63,89.74 234.92,90.02 arc(235.24,90.4) 235.45,90.84 235.97,92.37 arc(236.1,92.65) 236.29,92.89 236.46,93.06 arc(236.61,93.16) 236.78,93.19 237.02,93.19 237.13,93.3 P24.17
USB3_RX_P3: length 138.8
  TOP w0.102: UC993.1 229.66,121.91 229.5,121.91 v1(229.25,122.16) ; v1(183.62,83.75) 183.38,83.51 183.1,83.51 arc(182.79,83.38) 182.66,83.07 182.66,82.66 arc(182.63,82.48) 182.53,82.33 182.2,82 arc(181.6,81.6) 180.9,81.46 178.61,81.46 arc(173.6,82.46) 169.36,85.29 169.14,85.51 arc(167.78,86.42) 166.17,86.74 163.65,86.74 arc(161.86,86.38) 160.34,85.37 157.96,82.99 arc(157.47,82.26) 157.3,81.39 157.3,81.15 arc(156.83,78.8) 155.5,76.81 155.26,76.57 arc(153.48,73.91) 152.86,70.78 152.86,69.36 arc(153.11,68.1) 153.82,67.03 154.4,66.45 arc(155.83,65.49) 157.52,65.16 160.65,65.16 arc(161.38,65.01) 161.99,64.6 163.86,62.73 arc(163.98,62.56) 164.02,62.35 164.02,62.04 PCH.A9
  BOTTOM w0.102: v2(187.31,83.96) 187.31,83.67 ; 187.31,83.67 190.09,83.67 arc(190.43,83.6) 190.71,83.41 190.74,83.38 arc(190.82,83.33) 190.91,83.31 207.79,83.31 arc(208.31,83.41) 208.74,83.7 208.92,83.89 arc(209.36,84.18) 209.86,84.28 211.07,84.28 arc(212.71,84.6) 214.1,85.53 215.35,86.78 arc(217.05,87.92) 219.06,88.32 219.19,88.32 arc(220.12,88.5) 220.91,89.03 223.7,91.82 arc(224.46,92.79) 224.96,93.91 224.98,93.95 arc(225.78,95.73) 226.99,97.27 228.22,98.51 arc(228.61,99.1) 228.75,99.79 228.75,103.09 arc(228.86,103.64) 229.18,104.12 229.37,104.31 arc(230.06,105.16) 230.54,106.14 232.02,110.18 arc(232.08,110.37) 232.09,110.56 232.09,114.81 arc(232.01,115.79) 231.78,116.74 230.95,119.29 arc(230.76,119.69) 230.5,120.03 230.34,120.18 arc(230.21,120.27) 230.06,120.3 229.45,120.3 arc(229.23,120.35) 229.05,120.47 228.87,120.65 arc(228.66,120.96) 228.59,121.32 228.59,121.32 arc(228.62,121.49) 228.71,121.63 v1(229.25,122.16) ; 187.31,83.67 183.7,83.67 v1(183.62,83.75)
USB3_RX_P3_C: length 10.1
  TOP w0.102: P150.14 239.12,123.36 239.02,123.25 237.28,123.25 arc(236.86,123.19) 236.48,123 234.29,121.43 arc(234.21,121.39) 234.12,121.38 233.99,121.38 233.84,121.52 UU43.10 UU43.1 232.85,121.52 232.68,121.35 232.36,121.35 arc(232.19,121.38) 232.05,121.46 231.79,121.66 arc(231.7,121.73) 231.61,121.8 231.6,121.81 arc(231.47,121.89) 231.32,121.92 231.26,121.92 UC993.2
USB3_RX_P4: length 141.8
  TOP w0.102: v1(164.03,59.66) 164.27,59.66 PCH.G11 ; v1(159.72,63.29) 159.56,63.29 159.13,62.87 158.82,62.87 158.62,62.66 158.08,62.66 arc(157.82,62.71) 157.61,62.86 arc(157.4,62.99) 157.16,63.04 156.77,63.04 arc(156.49,63.05) 156.21,63.08 arc(154.77,63.51) 153.54,64.38 152.25,65.67 arc(151.12,67.36) 150.72,69.36 150.72,70.88 arc(151.53,74.93) 153.82,78.36 153.97,78.51 arc(154.68,79.58) 154.93,80.84 154.93,81.76 arc(155.2,83.09) 155.95,84.22 158.52,86.78 arc(160.75,88.27) 163.39,88.8 166.63,88.8 arc(168.69,88.39) 170.44,87.22 171.16,86.5 arc(171.93,85.98) 172.84,85.8 181.53,85.8 v1(181.72,86) ; v1(229.64,119.85) 229.86,119.63 230.36,119.63 UC996.1
  BOTTOM w0.102: v1(159.72,63.29) 160.13,63.7 161.16,63.7 arc(161.59,63.62) 161.95,63.38 163.05,62.28 arc(163.23,62) 163.3,61.68 163.3,60.37 arc(163.33,60.19) 163.44,60.03 163.63,59.84 163.86,59.84 v1(164.03,59.66) ; v1(181.72,86) 181.85,85.87 183.86,85.87 ; 183.86,85.87 190.57,85.87 arc(190.82,85.92) 191.03,86.06 191.24,86.27 arc(191.46,86.42) 191.72,86.47 193.23,86.47 arc(193.49,86.42) 193.71,86.28 193.78,86.2 arc(193.91,86.11) 194.07,86.08 213.29,86.08 arc(213.59,86.14) 213.84,86.31 214.84,87.31 arc(216.72,88.56) 218.94,89 219.18,89 arc(219.81,89.13) 220.35,89.49 223.17,92.31 arc(223.83,93.16) 224.29,94.15 224.51,94.8 arc(225.19,96.22) 226.16,97.45 227.65,98.93 arc(227.96,99.4) 228.07,99.95 228.07,103.12 arc(228.23,103.95) 228.71,104.66 229.05,105.01 arc(229.22,105.2) 229.35,105.4 arc(229.45,105.63) 229.51,105.87 229.85,107.61 arc(229.92,108.13) 229.95,108.65 229.95,115.79 arc(229.77,116.67) 229.27,117.42 229.08,117.61 arc(228.74,118.12) 228.63,118.72 228.63,118.95 arc(228.83,119.43) 229.31,119.63 229.43,119.63 v1(229.64,119.85) ; 183.86,85.87 v2(183.86,86.17)
USB3_RX_P4_C: length 7.1
  TOP w0.102: P150.15 237.13,121.36 237.02,121.25 236.8,121.25 arc(236.33,121.16) 235.93,120.9 235.43,120.4 arc(234.84,120) 234.15,119.86 234.01,119.86 233.85,120.02 UU43.7 UU43.4 232.82,120.02 232.69,119.89 232.55,119.89 arc(232.39,119.86) 232.25,119.76 232.23,119.74 arc(232.16,119.7) 232.08,119.68 231.98,119.68 UC996.2
USB3_RX_P5: length 199
  TOP w0.102: UC985.2 27.57,125.53 28.24,125.53 arc(28.92,125.39) 29.5,125.01 29.9,124.61 arc(30.1,124.3) 30.18,123.95 30.18,122.96 arc(30.34,122.12) 30.82,121.4 32.58,119.64 arc(34.28,118.51) 36.27,118.11 36.78,118.11 arc(37.49,118.25) 38.11,118.63 38.98,119.45 arc(39.39,119.72) 39.86,119.82 40.05,119.82 arc(40.29,119.72) 40.4,119.47 v1(40.4,118.89) ; PCH.G13 165.76,59.2 v1(165.29,58.73)
  BOTTOM w0.102: v1(165.29,58.73) 165.76,59.2 165.76,61.27 arc(165.66,61.85) 165.39,62.36 arc(165.32,62.45) 165.24,62.53 160.11,67.66 arc(159.86,68.03) 159.77,68.47 159.77,68.6 arc(159.44,69.39) 158.65,69.72 154.53,69.72 arc(154.02,69.62) 153.59,69.34 152.31,68.06 ; 152.31,68.06 152.1,67.84 arc(151.82,67.66) 151.49,67.59 145.95,67.59 arc(145.08,67.42) 144.34,66.93 144.19,66.78 arc(143.84,66.54) 143.41,66.45 78.52,66.45 arc(76.93,66.77) 75.57,67.68 74.26,68.99 arc(71.26,70.99) 67.72,71.69 62.96,71.69 arc(62.27,71.56) 61.68,71.16 61.17,70.65 arc(60.53,70.23) 59.78,70.08 52.93,70.08 arc(49.26,70.81) 46.15,72.89 42.57,76.46 arc(41.93,77.43) 41.7,78.56 41.7,93.45 arc(41.44,94.77) 40.68,95.9 40.38,96.2 arc(39.69,97.23) 39.45,98.44 39.45,116.13 arc(39.52,116.48) 39.72,116.77 39.88,116.94 arc(40.14,117.32) 40.23,117.77 40.23,118.72 40.39,118.89 v1(40.4,118.89) ; 152.31,68.06 v2(152.1,68.27)
USB3_RX_P5_C: length 13.3
  TOP w0.102: UC985.1 25.97,125.53 25.88,125.53 arc(25.73,125.5) 25.6,125.43 25.11,125.03 arc(24.96,124.95) 24.8,124.92 24.74,124.92 24.6,125.05 UU14.7 UU14.4 23.66,125.05 23.5,124.89 23.26,124.89 arc(23.26,124.89) 23.25,124.89 arc(23.04,124.85) 22.84,124.77 22.5,124.58 arc(22.05,124.4) 21.57,124.33 17.91,124.33 arc(17.11,124.54) 16.5,125.1 15.88,126.08 arc(15.74,126.21) 15.54,126.26 15.47,126.26 15.34,126.39 J133.26
USB3_RX_P6: length 206
  TOP w0.102: UC983.2 29.2,127.03 29.31,127.03 arc(29.53,126.98) 29.73,126.86 30.22,126.4 arc(30.71,125.7) 30.89,124.87 30.89,123.22 arc(31.04,122.46) 31.47,121.82 33.09,120.2 arc(34.5,119.26) 36.18,118.92 36.86,118.92 arc(37.11,119.03) 37.21,119.28 37.21,119.39 v1(37,119.61) ; PCH.K15 166.51,57.72 166.27,57.48 v1(166.27,57.3)
  BOTTOM w0.102: v1(166.27,57.3) 166.12,57.45 165.15,57.45 164.61,57.99 164.61,59.37 164.52,59.46 164.52,60.55 164.36,60.71 164.36,61.53 arc(164.26,61.98) 164.01,62.37 161.01,65.37 arc(160.41,65.77) 159.7,65.91 157.51,65.91 ; v1(37,119.61) 37.21,119.39 37.21,99.02 arc(37.57,97.21) 38.59,95.68 39.45,94.83 arc(39.95,94.08) 40.12,93.19 40.12,75.94 arc(40.34,74.87) 40.95,73.96 41.98,72.93 arc(42.4,72.29) 42.55,71.53 42.55,70.7 arc(42.71,69.9) 43.16,69.23 43.25,69.13 arc(43.95,68.67) 44.78,68.5 60.56,68.5 arc(61.45,68.68) 62.21,69.19 62.55,69.53 arc(63.01,69.84) 63.56,69.95 67.3,69.95 arc(70.33,69.34) 72.91,67.63 74.88,65.65 arc(75.14,65.26) 75.24,64.79 75.24,64.79 arc(75.37,64.13) 75.74,63.57 76.21,63.1 arc(76.39,62.82) 76.46,62.49 76.46,62.13 arc(76.75,61.43) 77.45,61.14 77.74,61.14 arc(77.91,61.1) 78.04,61.01 78.82,60.23 arc(79.01,59.96) 79.07,59.64 79.07,59.52 arc(79.12,59.27) 79.26,59.06 79.99,58.33 arc(81.01,57.65) 82.22,57.41 114.43,57.41 arc(114.73,57.47) 114.98,57.64 115.32,57.97 arc(116.05,58.46) 116.91,58.63 121.41,58.63 arc(123.12,58.97) 124.57,59.94 127.88,63.26 arc(128.21,63.47) 128.59,63.55 141.8,63.55 arc(143.09,63.81) 144.18,64.54 145.39,65.75 arc(145.57,65.87) 145.78,65.91 157.51,65.91 ; 157.51,65.91 v2(157.51,65.61)
USB3_RX_P6_C: length 7.4
  TOP w0.102: J133.46 21.74,126.49 21.97,126.26 22.19,126.26 arc(22.39,126.27) 22.58,126.3 22.93,126.35 arc(23.11,126.38) 23.29,126.39 23.52,126.39 23.68,126.55 UU14.1 UU14.10 24.6,126.55 24.74,126.42 24.87,126.42 arc(25.12,126.44) 25.36,126.52 26.08,126.85 arc(26.56,127.01) 27.06,127.07 27.69,127.07 UC983.1
USB3_RX_P7: length 204.7
  TOP w0.089: PCH.E15 166.74,59.66 166.62,59.54 166.4,59.54 v1(166.27,59.66)
  TOP w0.102: UC981.2 26.67,128.46 27.98,128.46 arc(28.9,128.32) 29.69,127.84 30.18,127.38 arc(30.75,127.03) 31.4,126.9 35.86,126.9 arc(36.37,126.87) 36.87,126.74 38.05,126.32 arc(38.58,126.17) 39.13,126.12 40.72,126.12 arc(40.96,126.18) 41.17,126.32 41.36,126.51 arc(41.44,126.64) 41.47,126.79 41.47,126.88 41.38,126.97 41.07,126.97 41,127.05 v1(41,127.28)
  BOTTOM w0.102: v1(41,127.28) 41,127.03 41.07,126.95 41.4,126.95 41.47,126.88 41.47,120.6 arc(41.53,120.3) 41.7,120.05 41.74,120.02 arc(41.88,119.8) 41.94,119.53 41.94,115.98 ; 41.94,115.98 41.94,115.44 arc(41.84,114.97) 41.57,114.57 41.16,114.16 arc(40.82,113.65) 40.7,113.05 40.7,98.9 arc(40.95,97.63) 41.67,96.57 41.91,96.32 arc(42.62,95.26) 42.87,94.01 42.87,78.67 arc(43.03,77.88) 43.47,77.21 46.82,73.86 arc(47.81,73.2) 48.97,72.97 68.63,72.97 arc(72.13,72.28) 75.09,70.29 77.1,68.28 arc(77.84,67.79) 78.7,67.62 137.2,67.62 arc(138.86,67.95) 140.27,68.89 141.18,69.81 arc(142.38,70.61) 143.8,70.89 149.88,70.89 arc(150.42,71) 150.87,71.3 151.04,71.47 arc(151.27,71.62) 151.55,71.68 157.32,71.68 arc(158.07,71.53) 158.71,71.1 160.08,69.73 arc(160.35,69.33) 160.44,68.85 arc(160.6,68.09) 161.03,67.45 166.1,62.37 arc(166.48,61.81) 166.61,61.14 166.61,60 v1(166.27,59.66) ; 41.94,115.98 v2(41.63,115.98)
USB3_RX_P7_C: length 8.8
  TOP w0.102: UC981.1 25.09,128.45 24.81,128.45 24.66,128.61 UU53.7 UU53.4 23.63,128.61 23.5,128.47 23.1,128.47 arc(22.65,128.44) 22.21,128.34 21.57,128.14 arc(21.56,128.14) 21.55,128.14 21.5,128.12 arc(21.2,127.96) 20.94,127.74 19.73,126.53 arc(19.41,126.32) 19.04,126.25 18.68,126.25 18.54,126.39 J133.36
USB3_SS_TXN1_C: length 9.8
  TOP w0.102: P24.12 239.12,100.89 239.02,100.99 236.03,100.99 arc(235.77,100.97) 235.53,100.89 235.22,100.74 arc(234.96,100.65) 234.69,100.62 234.12,100.62 233.82,100.32 UU26.9 UU26.2 232.77,100.32 232.48,100.62 232.37,100.62 arc(231.91,100.53) 231.52,100.27 231.36,100.11 arc(231.33,100.06) 231.32,99.99 231.32,99.92 231.54,99.7 URN163.4
USB3_SS_TXN1_CMC: length 1.3
  TOP w0.102: UC50.2 231.29,97.6 231.29,97.96 231.54,98.22 URN163.3
USB3_SS_TXN2_C: length 7.9
  TOP w0.102: P24.13 237.13,98.89 237.02,98.99 235.49,98.99 arc(235.27,99) 235.05,99.03 234.78,99.08 234.69,99.09 arc(234.51,99.11) 234.33,99.12 234.09,99.12 233.8,98.82 UU26.6 UU26.5 232.77,98.82 232.6,98.99 232.45,98.99 arc(232.33,98.94) 232.27,98.81 232.27,98.78 arc(232.3,98.67) 232.36,98.57 233.45,97.49 URN164.4
USB3_SS_TXN2_CMC: length 1.3
  TOP w0.102: URN164.3 233.45,96.03 233.22,95.81 233.22,95.47 UC53.2
USB3_SS_TXN3_C: length 10
  TOP w0.102: UL94.4 231.06,128.25 230.89,128.42 230.89,128.51 arc(230.97,128.72) 231.18,128.8 232.56,128.8 232.7,128.67 UU44.2 UU44.9 233.7,128.67 233.83,128.8 234.23,128.8 arc(234.45,128.82) 234.67,128.86 234.67,128.86 arc(234.78,128.89) 234.9,128.92 234.96,128.93 arc(235.11,128.97) 235.25,129.01 arc(235.26,129.01) 235.28,129.01 arc(235.46,129.05) 235.65,129.06 238.67,129.06 238.74,129.13 238.98,129.13 239.12,128.99 P150.10
USB3_SS_TXN3_CMC: length 1.2
  TOP w0.102: UL94.3 231.06,126.67 230.84,126.44 230.84,126.25 UC963.2
USB3_SS_TXN4_C: length 7.6
  TOP w0.102: URN168.4 233.07,126.07 232.84,126.29 232.84,126.38 arc(232.82,126.48) 232.77,126.56 232.38,126.95 arc(232.33,127.03) 232.31,127.12 232.31,127.16 arc(232.36,127.28) 232.48,127.33 232.61,127.33 232.77,127.17 UU44.5 UU44.6 233.7,127.17 233.86,127.33 234.28,127.33 arc(234.49,127.32) 234.69,127.29 235.04,127.23 arc(235.3,127.2) 235.57,127.19 236.99,127.19 237.13,127.05 P150.11
USB3_SS_TXN4_CMC: length 1.3
  TOP w0.102: UC964.2 232.83,124.11 232.83,124.35 233.07,124.58 URN168.3
USB3_SS_TXP1_C: length 9.8
  TOP w0.102: P24.10 239.12,101.3 239.02,101.19 236.04,101.19 arc(235.73,101.17) 235.44,101.07 235.13,100.93 arc(234.91,100.85) 234.69,100.82 UU26.10 UU26.1 232.37,100.82 arc(231.84,100.72) 231.38,100.41 231.22,100.25 arc(231.14,100.13) 231.11,99.99 231.11,99.9 230.89,99.67 URN163.2
USB3_SS_TXP1_CMC: length 1.3
  TOP w0.102: URN163.1 230.89,98.19 231.08,98 231.08,97.75 UC51.2
USB3_SS_TXP2_C: length 7.9
  TOP w0.102: P24.11 237.13,99.3 237.02,99.19 235.49,99.19 arc(235.29,99.21) 235.08,99.23 234.82,99.28 234.72,99.3 arc(234.72,99.3) 234.71,99.3 arc(234.52,99.32) 234.33,99.32 UU26.7 UU26.4 232.77,99.32 232.65,99.2 232.45,99.2 arc(232.18,99.08) 232.07,98.81 232.07,98.78 arc(232.11,98.59) 232.22,98.43 232.69,97.95 232.74,97.89 arc(232.78,97.83) 232.8,97.76 URN164.2
USB3_SS_TXP2_CMC: length 1.3
  TOP w0.102: URN164.1 232.8,96.01 233.02,95.78 233.02,95.47 UC52.2
USB3_SS_TXP3_C: length 10
  TOP w0.102: UL94.1 230.51,128.25 230.68,128.42 230.68,128.51 arc(230.83,128.86) 231.18,129.01 232.59,129.01 232.75,129.17 UU44.1 UU44.10 233.72,129.17 233.88,129.01 234.23,129.01 arc(234.43,129.02) 234.62,129.06 234.62,129.06 arc(234.73,129.09) 234.85,129.12 234.91,129.13 arc(235.07,129.17) 235.23,129.21 arc(235.44,129.25) 235.65,129.26 238.58,129.26 239.12,129.8 P150.8
USB3_SS_TXP3_CMC: length 1.1
  TOP w0.102: UC960.2 230.63,126.2 230.63,126.54 230.51,126.67 UL94.2
USB3_SS_TXP4_C: length 7.6
  TOP w0.102: P150.9 237.13,127.53 236.99,127.39 235.57,127.39 arc(235.32,127.4) 235.07,127.43 235.07,127.43 234.73,127.49 arc(234.51,127.52) 234.29,127.53 233.86,127.53 233.72,127.67 UU44.7 UU44.4 232.72,127.67 232.59,127.53 232.48,127.53 arc(232.22,127.42) 232.1,127.16 232.1,127.12 arc(232.14,126.95) 232.24,126.8 232.63,126.41 arc(232.64,126.4) 232.64,126.38 232.64,126.29 232.42,126.07 URN168.2
USB3_SS_TXP4_CMC: length 1.3
  TOP w0.102: UC959.2 232.63,124.03 232.63,124.4 232.42,124.61 URN168.1
USB3_TX_N1: length 118.4
  TOP w0.076: PCH.D13 165.54,61 165.54,61.3 165.46,61.38 165.46,61.84 165.58,61.96 165.58,62.24 165.33,62.48 165.33,62.76
  TOP w0.102: v1(231.11,95.63) 231.11,96.02 UC50.1 ; 165.33,62.76 165.33,63.64 arc(165.25,64.04) 165.02,64.39 163.32,66.09 arc(163.21,66.16) 163.09,66.18 161.68,66.18 arc(161.56,66.16) 161.46,66.09 arc(161.19,65.91) 160.87,65.84 157.52,65.84 arc(156.09,66.13) 154.88,66.94 154.4,67.42 arc(153.77,68.37) 153.54,69.49 153.54,70.66 arc(154.1,73.45) 155.67,75.81 156.14,76.28 arc(157.66,78.54) 158.19,81.21 158.19,81.38 arc(158.32,82.08) 158.72,82.67 160.91,84.86 arc(162.23,85.74) 163.79,86.06 166.07,86.06 arc(167.45,85.78) 168.63,85 169.17,84.45 arc(173.27,81.71) 178.12,80.75 180.98,80.75 arc(181.86,80.92) 182.61,81.42 183.34,82.15 arc(183.61,82.33) 183.93,82.4 184.32,82.4 arc(184.7,82.32) 185.03,82.1 185.36,81.77 arc(185.8,81.11) 185.95,80.34 v1(185.95,79.17)
  BOTTOM w0.102: v1(231.11,95.63) 230.96,95.48 230.96,95.28 arc(230.93,95.14) 230.85,95.01 arc(230.75,94.94) 230.63,94.92 230.31,94.92 arc(230.04,94.87) 229.82,94.72 229.49,94.38 arc(229.34,94.16) 229.29,93.9 arc(229.21,93.51) 228.99,93.18 222.7,86.9 arc(221.04,85.78) 219.08,85.39 arc(217.37,85.05) 215.91,84.08 215.62,83.79 arc(213.65,82.48) 211.33,82.02 211.11,82.02 arc(210.37,81.87) 209.75,81.46 arc(207.97,80.27) 205.87,79.85 186.85,79.85 arc(186.65,79.81) 186.48,79.7 v1(185.95,79.17)
USB3_TX_N2: length 118
  TOP w0.089: PCH.B13 165.95,61.67 165.95,62.92 165.95,62.93 165.95,62.97 165.93,62.99 165.93,63
  TOP w0.102: v1(181.89,79.86) 182.02,79.73 182.02,79.45 181.91,79.34 179.31,79.34 arc(173.71,80.46) 168.97,83.63 168.18,84.42 arc(167.15,85.1) 165.94,85.34 163.6,85.34 arc(162.8,85.19) 162.13,84.73 159.58,82.19 arc(159.17,81.57) 159.02,80.85 159.02,80.81 arc(158.54,78.37) 157.15,76.3 156.2,75.34 arc(154.74,73.16) 154.23,70.59 154.23,69.7 arc(154.44,68.67) 155.02,67.79 155.35,67.46 arc(156.38,66.77) 157.6,66.53 160.43,66.53 arc(160.73,66.59) 160.98,66.76 160.99,66.76 arc(161.11,66.85) 161.27,66.88 163.08,66.88 arc(163.48,66.8) 163.83,66.57 165.55,64.84 arc(165.79,64.51) 165.91,64.11 arc(165.92,64.06) 165.92,64.01 arc(165.93,63.97) 165.93,63.94 165.93,63 ; v1(231.9,92.38) 232.25,92.03 arc(232.37,91.95) 232.52,91.92 232.98,91.92 arc(233.53,92.15) 233.76,92.7 233.76,93.44 arc(233.73,93.59) 233.64,93.72 233.58,93.78 UC53.1
  BOTTOM w0.102: v1(231.9,92.38) 231.42,92.38 arc(231.05,92.31) 230.74,92.1 224.8,86.16 arc(222.32,84.5) 219.4,83.92 218.99,83.92 arc(217.84,83.69) 216.87,83.05 216.43,82.6 arc(214.26,81.15) 211.7,80.64 211.36,80.64 arc(210.95,80.57) 210.61,80.34 210.61,80.34 arc(208.55,78.96) 206.13,78.48 191.34,78.48 arc(190.66,78.34) 190.08,77.96 190.06,77.94 arc(188.97,77.21) 187.68,76.95 185.06,76.95 arc(183.92,77.18) 182.95,77.83 182.25,78.52 arc(182.06,78.81) 181.99,79.15 181.99,79.76 v1(181.89,79.86)
USB3_TX_N3: length 136.7
  TOP w0.089: PCH.B14 166.36,61.69 166.51,61.83 166.51,62.45 166.5,62.44 166.5,62.45 166.5,62.47
  TOP w0.102: UC963.1 230.86,124.68 230.86,124.18 230.94,124.1 231.21,124.1 231.36,123.95 v1(231.36,123.69) ; 166.5,62.47 166.5,63.06 166.45,63.11 166.45,64.19 arc(166.32,64.84) 165.97,65.4 arc(165.95,65.42) 165.93,65.44 164.31,67.06 arc(163.74,67.44) 163.06,67.57 160.9,67.57 arc(160.77,67.55) 160.67,67.48 arc(160.38,67.28) 160.03,67.22 157.68,67.22 arc(156.65,67.42) 155.77,68.01 155.52,68.26 arc(155.12,68.85) 154.99,69.54 154.99,70.87 arc(155.18,71.85) 155.74,72.68 155.93,72.88 arc(157.95,74.22) 160.32,74.7 165.86,74.7 arc(166.86,74.9) 167.71,75.46 168.54,76.3 arc(170.86,77.85) 173.59,78.39 182.67,78.39 arc(183.03,78.54) 183.17,78.9 183.17,79.69 arc(183.16,79.78) 183.11,79.85 183.09,79.87 arc(182.99,80.02) 182.95,80.2 182.95,80.34 arc(183.18,80.89) 183.73,81.11 184.09,81.11 v1(184.35,81.38)
  BOTTOM w0.102: v1(184.35,81.38) 184.12,81.15 184.04,81.15 arc(183.93,81.2) 183.88,81.32 183.88,81.6 arc(183.95,81.76) 184.11,81.83 186.39,81.83 arc(186.74,81.77) 187.03,81.57 arc(187.42,81.31) 187.87,81.22 205.35,81.22 arc(207.37,81.62) 209.08,82.77 arc(209.77,83.23) 210.58,83.39 211.24,83.39 arc(213.06,83.75) 214.61,84.78 214.92,85.09 arc(216.83,86.37) 219.08,86.82 arc(220.56,87.11) 221.82,87.95 227.04,93.17 arc(227.61,94.03) 227.81,95.04 arc(227.96,95.77) 228.38,96.4 230.86,98.88 arc(231.03,99.14) 231.09,99.44 231.09,100.13 arc(231.18,100.6) 231.45,100.99 231.52,101.07 arc(231.69,101.28) 231.78,101.54 232.89,107.81 arc(232.96,108.34) 232.98,108.88 232.98,115.28 arc(232.87,116.61) 232.54,117.9 231.84,119.92 arc(231.61,120.39) 231.28,120.81 231.28,120.81 arc(231.03,121.19) 230.94,121.63 230.94,123.27 v1(231.36,123.69)
USB3_TX_N4: length 132
  TOP w0.089: 166.93,63.29 166.93,63.28 166.95,63.26 166.95,63.22 166.95,63.21 166.95,61.9 167.08,61.78 167.08,61.67 166.98,61.57 PCH.B15
  TOP w0.102: v1(184.02,79.05) 184.3,78.76 184.3,78.63 arc(184.28,78.53) 184.22,78.44 183.97,78.18 arc(183.34,77.76) 182.6,77.62 173.41,77.62 arc(171.28,77.19) 169.48,75.99 168.77,75.28 arc(167.32,74.31) 165.61,73.97 160.11,73.97 arc(158.23,73.6) 156.64,72.53 156.12,72.02 arc(155.8,71.53) 155.68,70.96 155.68,69.54 arc(155.77,69.1) 156.02,68.73 156.24,68.51 arc(156.91,68.06) 157.7,67.9 159.68,67.9 arc(159.95,67.96) 160.18,68.11 160.21,68.14 arc(160.37,68.25) 160.56,68.28 163.06,68.28 arc(164.04,68.09) 164.88,67.53 166.12,66.29 arc(166.72,65.39) 166.93,64.33 166.93,63.29 ; v1(232.99,122.15) 232.75,122.39 232.75,122.72 232.91,122.87 UC964.1
  BOTTOM w0.102: v1(232.99,122.15) 232.99,121.82 232.94,121.77 232.61,121.77 232.54,121.69 232.54,121.55 arc(232.57,121.39) 232.66,121.25 232.75,121.16 arc(233.43,120.15) 233.67,118.95 233.67,108.74 arc(233.64,107.95) 233.54,107.17 233.4,106.34 arc(233.34,105.86) 233.32,105.38 233.32,103.33 arc(233.06,101.99) 232.3,100.86 232.24,100.8 arc(231.9,100.28) 231.78,99.67 231.78,99.43 arc(231.66,98.85) 231.33,98.36 229.05,96.09 arc(228.64,95.47) 228.5,94.74 228.5,94.74 arc(228.3,93.74) 227.73,92.89 222.3,87.47 arc(220.8,86.46) 219.02,86.11 arc(217.1,85.72) 215.48,84.64 215.16,84.32 arc(213.37,83.12) 211.26,82.7 211.07,82.7 arc(210.09,82.51) 209.26,81.95 arc(207.69,80.9) 205.84,80.54 186.14,80.54 arc(185.55,80.42) 185.05,80.08 v1(184.02,79.05)
USB3_TX_N5: length 200.8
  TOP w0.102: UC97.1 32.53,127.53 32.65,127.65 32.65,128.03 32.74,128.12 38.07,128.12 arc(38.2,128.1) 38.31,128.02 38.38,127.96 v1(38.38,127.56) ; PCH.A16 167.57,62.06 167.57,64.03 arc(167.24,65.71) 166.28,67.13 165.42,67.99 arc(164.33,68.72) 163.04,68.98 160.3,68.98 arc(160.02,69.04) 159.79,69.19 arc(159.53,69.36) 159.23,69.42 158.29,69.42 arc(158.11,69.35) 158.04,69.17 158.04,69.01 v1(158.24,68.81)
  BOTTOM w0.102: v1(38.38,127.56) 38.38,127.22 38.47,127.12 38.73,127.12 38.84,127.02 38.84,126.54 arc(38.81,126.4) 38.73,126.28 arc(38.61,126.1) 38.56,125.88 38.56,98.31 arc(38.85,96.88) 39.66,95.66 39.96,95.37 arc(40.57,94.46) 40.81,93.39 arc(40.81,93.35) 40.81,93.31 40.81,76.08 arc(41,75.15) 41.52,74.36 42.74,73.15 arc(43.22,72.42) 43.4,71.55 43.4,70.97 arc(43.53,70.28) 43.92,69.71 44.12,69.5 arc(44.47,69.27) 44.88,69.19 59.89,69.19 arc(60.98,69.41) 61.91,70.03 62.16,70.28 arc(62.61,70.58) 63.15,70.69 67.65,70.69 arc(70.75,70.07) 73.39,68.31 75.29,66.41 arc(76.22,65.78) 77.33,65.57 132.88,65.57 arc(133.68,65.41) 134.36,64.95 134.56,64.76 arc(135.1,64.39) 135.75,64.26 141.67,64.26 arc(142.84,64.49) 143.83,65.16 144.94,66.26 arc(145.38,66.56) 145.89,66.66 154.49,66.66 arc(156.08,66.98) 157.43,67.87 157.88,68.33 158.14,68.33 158.24,68.43 v1(158.24,68.81)
USB3_TX_N5_C: length 12.9
  TOP w0.102: J133.28 15.34,131.85 15.52,132.03 15.85,132.03 arc(16.23,131.95) 16.56,131.73 17.91,130.39 arc(18.55,130.12) 19.19,130.39 19.58,130.78 arc(20.13,131.01) 20.68,130.78 20.75,130.71 arc(21.03,130.48) 21.36,130.3 22.04,130 arc(22.65,129.81) 23.29,129.74 23.55,129.74 23.68,129.61 UU53.2 UU53.9 24.58,129.61 24.74,129.77 25.04,129.77 25.27,130 25.5,130 25.73,129.77 URN151.3
USB3_TX_N5_CMC: length 5.3
  TOP w0.102: UC97.2 31,127.89 30.84,127.89 arc(30.5,127.96) 30.22,128.15 28.89,129.48 arc(28.32,129.86) 27.64,130 27.41,130 27.18,129.77 URN151.4
USB3_TX_N6: length 199.6
  TOP w0.102: PCH.C17 168.06,61.3 167.97,61.39 167.85,61.39 v1(167.42,60.97) ; UC99.1 31.59,129.77 31.81,129.77 arc(31.89,129.76) 31.97,129.73 32.68,129.26 arc(33.32,128.96) 34.03,128.86 39.43,128.86 arc(39.73,128.92) 39.99,129.09 40.01,129.12 arc(40.18,129.23) 40.39,129.27 41.03,129.27 v1(41.3,129.01)
  BOTTOM w0.102: v1(41.3,129.01) 41.93,128.38 arc(42.16,128.04) 42.24,127.64 42.24,121.26 arc(42.35,120.66) 42.69,120.16 42.81,120.04 arc(43.01,119.74) 43.08,119.39 43.08,113.37 arc(42.93,112.6) 42.49,111.94 42.35,111.8 arc(42.04,111.35) 41.94,110.81 41.94,98.38 arc(42.14,97.35) 42.72,96.48 42.76,96.44 arc(43.35,95.57) 43.55,94.53 43.55,78.7 arc(43.66,78.15) 43.98,77.68 47.28,74.37 arc(48.08,73.84) 49.01,73.66 69.58,73.66 arc(72.62,73.05) 75.2,71.33 77.85,68.68 arc(78.26,68.4) 78.74,68.31 136.94,68.31 arc(138.52,68.62) 139.86,69.52 140.64,70.3 arc(142.06,71.24) 143.73,71.58 149.07,71.58 arc(149.6,71.68) 150.06,71.99 150.21,72.14 arc(150.46,72.31) 150.75,72.36 157.44,72.36 arc(158.34,72.19) 159.1,71.68 160.73,70.05 arc(161.03,69.61) 161.13,69.08 161.13,69.03 arc(161.26,68.39) 161.62,67.84 167.55,61.92 arc(167.8,61.53) 167.89,61.08 167.89,60.78 167.77,60.66 167.49,60.66 167.42,60.72 v1(167.42,60.97)
USB3_TX_N6_C: length 5.4
  TOP w0.102: URN156.3 25.71,131.34 25.48,131.57 25.34,131.57 arc(25.27,131.56) 25.2,131.52 25.14,131.48 arc(25.02,131.42) 24.89,131.39 24.77,131.39 24.63,131.26 UU40.6 UU40.5 23.68,131.26 23.52,131.42 23.34,131.42 arc(23.13,131.45) 22.94,131.54 22.27,131.97 arc(22.15,132.03) 22.03,132.05 21.84,132.05 21.74,131.95 J133.48
USB3_TX_N6_CMC: length 4.3
  TOP w0.102: URN156.4 27.18,131.34 27.4,131.57 27.59,131.57 arc(27.77,131.53) 27.93,131.42 29.36,129.99 arc(29.61,129.83) 29.9,129.77 30.05,129.77 UC99.2
USB3_TX_N7: length 201.8
  TOP w0.102: UC30.1 29.92,131.49 30.11,131.3 arc(30.38,131.13) 30.69,131.06 31.14,131.06 arc(31.67,130.96) 32.13,130.65 32.37,130.41 arc(32.86,130.08) 33.42,129.97 v1(38.61,129.97) ; v1(157.16,70.5) 157.6,70.94 157.92,70.94 158.05,71.07 arc(158.17,71.15) 158.31,71.18 158.56,71.18 arc(159.15,71.06) 159.65,70.72 160.08,70.3 arc(160.49,70.02) 160.97,69.93 163,69.93 arc(164.63,69.6) 166.02,68.67 166.83,67.86 arc(167.84,66.35) 168.2,64.56 168.2,62.32 PCH.A18
  BOTTOM w0.102: v1(38.61,129.97) 39.04,129.54 39.04,129.2 arc(39.13,128.76) 39.38,128.38 39.57,128.19 arc(39.91,127.68) 40.04,127.07 40.04,121.34 arc(40.18,120.6) 40.6,119.98 40.75,119.83 arc(41.12,119.27) 41.25,118.62 41.25,117.7 arc(41.15,117.2) 40.87,116.78 40.54,116.45 arc(40.15,115.87) 40.02,115.19 40.02,98.53 arc(40.25,97.34) 40.93,96.34 41.29,95.97 arc(41.95,94.99) 42.18,93.82 42.18,78.63 arc(42.38,77.62) 42.96,76.75 46.42,73.3 arc(47.54,72.55) 48.86,72.29 68.11,72.29 arc(71.6,71.59) 74.55,69.62 76.24,67.93 arc(77.34,67.19) 78.64,66.94 137.31,66.94 arc(139.17,67.31) 140.74,68.36 141.57,69.19 arc(142.7,69.94) 144.03,70.21 150.85,70.21 arc(151.39,70.31) 151.84,70.61 152,70.78 arc(152.24,70.94) 152.52,70.99 157.19,70.99 arc(157.27,70.96) 157.3,70.88 157.3,70.64 v1(157.16,70.5)
USB3_TX_N7_C: length 9.6
  TOP w0.102: URN155.3 25.72,132.91 25.48,133.15 25.34,133.15 arc(25.26,133.13) 25.2,133.09 25.11,133 arc(24.99,132.92) 24.84,132.89 24.74,132.89 24.6,132.76 UU40.9 UU40.2 23.66,132.76 23.5,132.92 23.34,132.92 arc(23.33,132.92) 23.31,132.92 arc(23.08,133.01) 22.87,133.16 22.12,133.91 arc(22.04,133.97) 21.94,133.99 21.94,133.99 arc(21.59,133.94) 21.27,133.83 20.93,133.66 arc(20.68,133.56) 20.43,133.5 arc(20.42,133.5) 20.42,133.5 20.3,133.5 arc(19.89,133.39) 19.6,133.09 19.28,132.52 arc(19.08,132.26) 18.82,132.07 arc(18.8,132.06) 18.78,132.05 18.64,132.05 18.54,131.95 J133.38
USB3_TX_N7_CMC: length 2.6
  TOP w0.102: URN155.4 27.19,132.91 27.42,133.13 27.76,133.13 arc(28.24,133.03) 28.66,132.76 28.83,132.59 UC30.2
USB3_TX_P1: length 118.2
  TOP w0.076: PCH.C13 165.78,61.3 165.64,61.45 165.64,61.77 165.76,61.88 165.76,62.31 165.53,62.53 165.53,62.69
  TOP w0.102: 165.53,62.69 165.53,63.64 arc(165.44,64.12) 165.16,64.53 163.46,66.23 arc(163.29,66.35) 163.09,66.39 161.68,66.39 arc(161.49,66.35) 161.32,66.24 arc(161.11,66.1) 160.87,66.05 157.52,66.05 arc(156.17,66.32) 155.03,67.08 154.55,67.56 arc(153.95,68.45) 153.75,69.49 153.75,70.66 arc(154.28,73.37) 155.82,75.67 156.29,76.13 arc(157.84,78.46) 158.39,81.21 158.39,81.38 arc(158.51,82) 158.86,82.53 161.05,84.72 arc(162.31,85.56) 163.79,85.85 166.07,85.85 arc(167.37,85.59) 168.48,84.85 169.02,84.31 arc(173.2,81.52) 178.12,80.54 180.98,80.54 arc(181.94,80.73) 182.75,81.28 183.48,82.01 arc(183.69,82.15) 183.93,82.19 184.32,82.19 arc(184.62,82.13) 184.88,81.96 185.22,81.63 arc(185.61,81.03) 185.75,80.34 185.75,79.76 arc(185.7,79.65) 185.59,79.6 185.45,79.6 arc(185.34,79.56) 185.29,79.44 v1(185.29,79.17) ; UC51.1 230.91,96.23 230.91,96.09 v1(230.45,95.63)
  BOTTOM w0.102: v1(185.29,79.17) 185.29,79.33 arc(185.37,79.52) 185.55,79.59 186.08,79.59 186.34,79.84 arc(186.57,80) 186.84,80.05 205.87,80.05 arc(207.89,80.45) 209.61,81.6 arc(210.29,82.06) 211.11,82.22 211.33,82.22 arc(213.58,82.67) 215.48,83.94 215.77,84.23 arc(217.29,85.24) 219.08,85.6 arc(220.96,85.97) 222.56,87.04 228.84,93.32 arc(229.02,93.59) 229.08,93.9 arc(229.15,94.24) 229.34,94.53 229.67,94.86 arc(229.97,95.05) 230.31,95.12 230.63,95.12 arc(230.67,95.13) 230.71,95.15 arc(230.75,95.21) 230.76,95.28 230.76,95.28 230.76,95.33 v1(230.45,95.63)
USB3_TX_P2: length 118
  TOP w0.089: 166.13,63 166.13,62.01 166.15,61.99 PCH.A14
  TOP w0.102: UC52.1 232.66,93.81 232.83,93.65 233.43,93.65 233.5,93.58 arc(233.54,93.52) 233.55,93.44 233.55,92.7 arc(233.39,92.29) 232.98,92.13 232.52,92.13 arc(232.45,92.14) 232.39,92.18 232.33,92.24 232.33,92.61 v1(231.93,93.01) ; 166.13,63 166.13,63.94 arc(166.13,63.98) 166.13,64.02 arc(166.12,64.08) 166.12,64.14 arc(165.98,64.6) 165.7,64.99 163.97,66.71 arc(163.56,66.98) 163.08,67.08 161.27,67.08 arc(161.04,67.04) 160.84,66.91 160.84,66.9 arc(160.65,66.78) 160.43,66.73 157.6,66.73 arc(156.46,66.96) 155.49,67.61 155.17,67.93 arc(154.62,68.74) 154.43,69.7 154.43,70.59 arc(154.93,73.08) 156.34,75.2 157.3,76.16 arc(158.73,78.29) 159.23,80.81 159.23,80.85 arc(159.36,81.49) 159.72,82.04 162.27,84.59 arc(162.88,85) 163.6,85.14 165.94,85.14 arc(167.08,84.92) 168.04,84.27 168.83,83.48 arc(173.64,80.27) 179.31,79.14 181.99,79.14 182.41,79.55 v1(182.45,79.55)
  BOTTOM w0.102: v1(182.45,79.55) 182.19,79.3 182.19,79.15 arc(182.25,78.89) 182.4,78.67 183.09,77.97 arc(184,77.36) 185.06,77.15 187.68,77.15 arc(188.89,77.39) 189.92,78.08 189.94,78.1 arc(190.58,78.53) 191.34,78.68 206.13,78.68 arc(208.48,79.15) 210.47,80.48 210.47,80.48 arc(210.88,80.75) 211.36,80.85 211.7,80.85 arc(214.18,81.34) 216.29,82.75 216.73,83.19 arc(217.77,83.88) 218.99,84.12 219.4,84.12 arc(222.24,84.69) 224.66,86.31 230.6,92.24 arc(230.97,92.49) 231.42,92.58 231.5,92.66 231.5,92.91 231.6,93.01 v1(231.93,93.01)
USB3_TX_P3: length 136.8
  TOP w0.089: 166.7,62.47 166.7,62.45 166.69,62.44 166.69,62.39 166.69,62.38 166.69,61.76 166.62,61.7 166.62,61.16 PCH.C14
  TOP w0.102: v1(230.53,123.69) 230.66,123.82 230.66,124.68 UC960.1 ; v1(184.35,80.74) 184.18,80.91 183.73,80.91 arc(183.32,80.74) 183.16,80.34 183.16,80.2 arc(183.18,80.1) 183.23,80.01 183.25,79.99 arc(183.35,79.85) 183.38,79.69 183.38,78.9 arc(183.17,78.39) 182.67,78.19 173.59,78.19 arc(170.94,77.66) 168.69,76.16 167.85,75.32 arc(166.94,74.71) 165.86,74.49 160.32,74.49 arc(158.02,74.04) 156.08,72.74 155.88,72.54 arc(155.37,71.77) 155.19,70.87 155.19,69.54 arc(155.31,68.93) 155.66,68.41 155.92,68.15 arc(156.73,67.61) 157.68,67.42 160.03,67.42 arc(160.3,67.47) 160.52,67.62 arc(160.69,67.74) 160.9,67.78 163.06,67.78 arc(163.81,67.63) 164.45,67.2 166.07,65.58 arc(166.09,65.56) 166.12,65.54 arc(166.51,64.91) 166.65,64.19 166.65,63.2 166.7,63.14 166.7,62.47
  BOTTOM w0.102: v1(184.35,80.74) 184.14,80.95 184.04,80.95 arc(183.78,81.06) 183.68,81.32 183.68,81.6 arc(183.8,81.91) 184.11,82.04 186.39,82.04 arc(186.82,81.95) 187.17,81.71 arc(187.49,81.5) 187.87,81.42 205.35,81.42 arc(207.29,81.81) 208.94,82.91 arc(209.69,83.42) 210.58,83.59 211.24,83.59 arc(212.98,83.94) 214.46,84.93 214.77,85.24 arc(216.75,86.56) 219.08,87.02 arc(220.49,87.3) 221.68,88.1 226.9,93.32 arc(227.42,94.11) 227.61,95.04 arc(227.77,95.85) 228.23,96.54 230.71,99.02 arc(230.84,99.21) 230.89,99.44 230.89,100.13 arc(230.99,100.67) 231.3,101.13 231.38,101.21 arc(231.38,101.21) 231.38,101.22 arc(231.51,101.38) 231.58,101.58 232.69,107.84 arc(232.76,108.36) 232.78,108.88 232.78,115.28 arc(232.67,116.57) 232.35,117.84 231.65,119.85 arc(231.44,120.29) 231.14,120.66 arc(230.84,121.11) 230.73,121.63 230.73,123.49 v1(230.53,123.69)
USB3_TX_P4: length 132
  TOP w0.089: 167.13,63.29 167.13,61.98 167.26,61.85 167.26,61.59 167.11,61.44 167.11,61.29 PCH.C15
  TOP w0.102: 167.13,63.29 167.13,64.33 arc(166.91,65.47) 166.26,66.44 165.02,67.67 arc(164.12,68.27) 163.06,68.49 160.56,68.49 arc(160.29,68.43) 160.07,68.28 160.04,68.25 arc(159.87,68.14) 159.68,68.11 157.7,68.11 arc(156.99,68.25) 156.39,68.65 156.16,68.87 arc(155.96,69.18) 155.89,69.54 155.89,70.96 arc(155.99,71.45) 156.27,71.87 156.78,72.39 arc(158.31,73.41) 160.11,73.77 165.61,73.77 arc(167.4,74.12) 168.91,75.14 169.62,75.85 arc(171.36,77.01) 173.41,77.41 182.6,77.41 arc(183.42,77.58) 184.11,78.04 184.37,78.3 arc(184.47,78.45) 184.51,78.63 184.51,79.21 v1(184.02,79.7) ; v1(232.33,122.15) 232.51,122.32 232.51,122.67 UC959.1
  BOTTOM w0.102: v1(232.33,122.15) 232.33,121.55 arc(232.38,121.31) 232.52,121.11 232.61,121.02 arc(233.24,120.07) 233.46,118.95 233.46,108.74 arc(233.43,107.97) 233.34,107.2 233.2,106.38 arc(233.14,105.88) 233.12,105.38 233.12,103.33 arc(232.87,102.07) 232.16,101 232.1,100.94 arc(231.71,100.36) 231.57,99.67 231.57,99.43 arc(231.47,98.93) 231.19,98.51 228.91,96.23 arc(228.46,95.55) 228.3,94.74 228.3,94.74 arc(228.11,93.82) 227.59,93.04 222.16,87.61 arc(220.72,86.65) 219.02,86.31 arc(217.02,85.91) 215.33,84.78 215.01,84.46 arc(213.29,83.31) 211.26,82.91 211.07,82.91 arc(210.01,82.69) 209.11,82.09 arc(207.61,81.09) 205.84,80.74 186.14,80.74 arc(185.47,80.61) 184.9,80.23 184.38,79.7 v1(184.02,79.7)
USB3_TX_P5: length 200.8
  TOP w0.102: UC96.1 32.59,128.45 32.71,128.33 38.07,128.33 arc(38.28,128.29) 38.46,128.17 v1(39.04,127.58) ; v1(157.57,68.8) 157.84,69.06 157.84,69.17 arc(157.97,69.49) 158.29,69.63 159.23,69.63 arc(159.61,69.55) 159.93,69.34 159.93,69.33 arc(160.1,69.22) 160.3,69.18 163.04,69.18 arc(164.41,68.91) 165.57,68.14 166.43,67.28 arc(167.42,65.79) 167.77,64.03 167.77,61.88 167.49,61.6 PCH.B16
  BOTTOM w0.102: v1(39.04,127.58) 39.04,126.54 arc(39,126.32) 38.88,126.14 arc(38.8,126.02) 38.77,125.88 38.77,98.31 arc(39.04,96.95) 39.8,95.81 40.1,95.51 arc(40.76,94.54) 41.01,93.39 41.01,93.39 41.01,76.08 arc(41.18,75.23) 41.67,74.5 42.88,73.29 arc(43.41,72.49) 43.6,71.55 43.6,70.97 arc(43.72,70.36) 44.06,69.85 44.26,69.65 arc(44.55,69.46) 44.88,69.39 59.89,69.39 arc(60.9,69.59) 61.76,70.17 62.01,70.42 arc(62.53,70.77) 63.15,70.89 67.65,70.89 arc(70.83,70.26) 73.53,68.45 75.43,66.55 arc(76.3,65.97) 77.33,65.77 132.88,65.77 arc(133.76,65.59) 134.51,65.09 134.7,64.9 arc(135.18,64.58) 135.75,64.47 141.67,64.47 arc(142.76,64.68) 143.69,65.3 144.79,66.41 arc(145.3,66.74) 145.89,66.86 154.49,66.86 arc(156,67.16) 157.28,68.02 157.57,68.31 v1(157.57,68.8)
USB3_TX_P5_C: length 12.9
  TOP w0.102: J133.29 15.34,132.49 15.6,132.23 15.85,132.23 arc(16.31,132.14) 16.7,131.88 18.05,130.53 arc(18.55,130.33) 19.04,130.53 19.44,130.93 arc(20.13,131.21) 20.82,130.93 20.89,130.86 arc(21.15,130.64) 21.44,130.48 22.12,130.19 arc(22.69,130.01) 23.29,129.95 23.5,129.95 23.66,130.11 UU53.1 UU53.10 24.58,130.11 24.71,129.97 24.96,129.97 25.19,130.2 25.48,130.2 25.7,130.42 URN151.1
USB3_TX_P5_CMC: length 5.3
  TOP w0.102: UC96.2 31,128.09 30.84,128.09 arc(30.58,128.15) 30.37,128.29 29.04,129.62 arc(28.39,130.05) 27.64,130.2 27.41,130.2 27.18,130.42 URN151.2
USB3_TX_P6: length 199.5
  TOP w0.102: v1(168.22,60.11) 168.19,60.15 168.18,60.15 168.03,60.29 PCH.D17 ; v1(41.94,129.01) 41.47,129.48 40.39,129.48 arc(40.1,129.42) 39.87,129.26 39.84,129.24 arc(39.65,129.11) 39.43,129.07 34.03,129.07 arc(33.38,129.16) 32.79,129.43 32.08,129.9 arc(31.95,129.96) 31.81,129.98 31.59,129.98 UC98.1
  BOTTOM w0.102: v1(41.94,129.01) 41.94,128.66 42.07,128.52 arc(42.34,128.12) 42.44,127.64 42.44,121.26 arc(42.54,120.74) 42.83,120.3 42.95,120.19 arc(43.2,119.82) 43.28,119.39 43.28,113.37 arc(43.11,112.52) 42.63,111.8 42.49,111.66 arc(42.23,111.27) 42.14,110.81 42.14,98.38 arc(42.33,97.43) 42.86,96.63 42.91,96.59 arc(43.54,95.64) 43.76,94.53 43.76,78.7 arc(43.85,78.23) 44.12,77.82 47.43,74.52 arc(48.15,74.03) 49.01,73.86 69.58,73.86 arc(72.7,73.24) 75.34,71.47 78,68.82 arc(78.34,68.59) 78.74,68.51 136.94,68.51 arc(138.44,68.81) 139.71,69.66 140.49,70.44 arc(141.98,71.43) 143.73,71.78 149.07,71.78 arc(149.53,71.87) 149.92,72.13 150.07,72.29 arc(150.38,72.49) 150.75,72.57 157.44,72.57 arc(158.42,72.37) 159.24,71.82 160.87,70.19 arc(161.21,69.68) 161.33,69.08 161.33,69.03 arc(161.45,68.46) 161.77,67.98 167.69,62.06 arc(167.99,61.61) 168.1,61.08 168.1,60.24 v1(168.22,60.11)
USB3_TX_P6_C: length 5.4
  TOP w0.102: URN156.1 25.69,131.99 25.48,131.78 25.34,131.78 arc(25.2,131.75) 25.07,131.68 25.02,131.64 arc(24.96,131.61) 24.88,131.6 24.74,131.6 24.58,131.76 UU40.7 UU40.4 23.63,131.76 23.5,131.62 23.33,131.62 arc(23.18,131.64) 23.05,131.71 22.38,132.14 arc(22.21,132.22) 22.03,132.25 21.84,132.25 21.74,132.35 J133.49
USB3_TX_P6_CMC: length 4.3
  TOP w0.102: UC98.2 30.05,129.98 29.9,129.98 arc(29.68,130.02) 29.5,130.14 28.07,131.57 arc(27.85,131.72) 27.59,131.77 27.39,131.77 27.16,131.99 URN156.2
USB3_TX_P7: length 201.6
  TOP w0.102: v1(157.79,70.52) 158.19,70.92 arc(158.25,70.96) 158.31,70.97 158.56,70.97 arc(159.07,70.87) 159.51,70.58 159.93,70.15 arc(160.41,69.83) 160.97,69.72 163,69.72 arc(164.56,69.41) 165.88,68.53 166.69,67.72 arc(167.66,66.27) 168,64.56 168,62.13 168.15,61.97 PCH.B18 ; v1(39.24,129.97) 38.81,130.4 38.35,130.4 38.13,130.18 33.42,130.18 arc(32.93,130.27) 32.52,130.55 32.27,130.8 arc(31.75,131.15) 31.14,131.27 30.69,131.27 arc(30.45,131.31) 30.25,131.45 30.07,131.63 UC29.1
  BOTTOM w0.102: v1(157.79,70.52) 157.51,70.81 157.51,70.88 arc(157.41,71.1) 157.19,71.2 152.52,71.2 arc(152.16,71.12) 151.86,70.92 151.7,70.76 arc(151.31,70.5) 150.85,70.41 144.03,70.41 arc(142.62,70.13) 141.43,69.33 140.6,68.5 arc(139.09,67.49) 137.31,67.14 78.64,67.14 arc(77.42,67.38) 76.39,68.07 74.7,69.76 arc(71.68,71.78) 68.11,72.49 48.86,72.49 arc(47.62,72.74) 46.56,73.44 43.1,76.9 arc(42.57,77.69) 42.39,78.63 42.39,93.82 arc(42.14,95.06) 41.44,96.12 41.07,96.48 arc(40.44,97.42) 40.22,98.53 40.22,115.19 arc(40.34,115.8) 40.68,116.31 41.01,116.64 arc(41.34,117.13) 41.45,117.7 41.45,118.62 arc(41.31,119.35) 40.89,119.97 40.74,120.12 arc(40.37,120.68) 40.24,121.34 40.24,127.07 arc(40.1,127.75) 39.71,128.33 39.52,128.53 arc(39.32,128.84) 39.24,129.2 v1(39.24,129.97)
USB3_TX_P7_C: length 9.6
  TOP w0.102: J133.39 18.54,132.35 18.64,132.25 18.73,132.25 arc(18.94,132.41) 19.1,132.62 19.42,133.19 arc(19.79,133.57) 20.3,133.71 20.4,133.71 arc(20.63,133.75) 20.84,133.84 21.17,134.01 arc(21.55,134.14) 21.94,134.19 arc(22.11,134.15) 22.26,134.06 23.02,133.3 arc(23.17,133.19) 23.36,133.12 23.5,133.12 23.63,133.26 UU40.1 UU40.10 24.58,133.26 24.74,133.1 24.84,133.1 arc(24.91,133.11) 24.97,133.15 25.05,133.23 arc(25.18,133.32) 25.34,133.35 25.5,133.35 25.7,133.56 URN155.1
USB3_TX_P7_CMC: length 2.7
  TOP w0.102: UC29.2 28.97,132.73 28.8,132.9 arc(28.32,133.22) 27.76,133.33 27.4,133.33 27.17,133.56 URN155.2
USB3P1_RXN1: length 7.7
  TOP w0.114: v1(14.04,147.05) 13.8,146.81 13.53,146.81 UC978.2 ; U5.24 16.61,146.55 16.54,146.63 16.45,146.63 arc(16.26,146.55) 16.18,146.36 16.18,146.25 arc(16.19,146.19) 16.23,146.13 16.57,145.79 16.67,145.68 arc(16.78,145.53) 16.81,145.34 16.81,145.19 v1(17.04,144.96)
  BOTTOM w0.114: v1(14.04,147.05) 14.28,146.81 15.01,146.81 arc(15.66,146.68) 16.2,146.32 16.63,145.89 arc(16.79,145.66) 16.84,145.39 16.84,145.16 v1(17.04,144.96)
USB3P1_RXN1_C: length 7.8
  TOP w0.114: UC978.1 12.08,146.76 11.75,146.76 arc(11.49,146.65) 11.38,146.39 11.38,145.98 arc(11.34,145.89) 11.24,145.85 11.15,145.85 11.01,145.98 UU34.10 UU34.1 9.81,145.98 9.68,145.85 9.43,145.85 7.99,144.41 6.97,144.41 6.7,144.68 J_TYPEC.A10
USB3P1_RXN2: length 6.5
  TOP w0.114: U5.20 16.69,148.15 16.61,148.23 v1(15.77,148.23) ; UC976.2 12.9,150.63 13.32,150.63 13.32,150.64 14.24,150.64 v1(14.48,150.88)
  BOTTOM w0.114: v1(14.48,150.88) 14.94,150.42 14.94,150.11 15.14,149.9 arc(15.29,149.68) 15.34,149.41 15.34,148.66 v1(15.77,148.23)
USB3P1_RXN2_C: length 13.9
  TOP w0.114: UC976.1 11.59,150.85 10.57,150.85 arc(10.46,150.87) 10.36,150.94 arc(10.24,151.01) 10.11,151.04 UU10.10 UU10.1 7.72,151.04 arc(7.71,151.04) 7.7,151.05 7.65,151.1 7.65,151.1 arc(7.5,151.2) 7.33,151.24 6.84,151.24 arc(6.51,151.3) 6.2,151.43 5.51,151.85 arc(5.08,152.03) 4.62,152.09 3.84,152.09 arc(3.22,151.82) 3,151.19 3,151.19 3,150.69 arc(3.1,149.95) 3.42,149.26 3.96,148.44 arc(4.17,148.25) 4.44,148.18 J_TYPEC.B10
USB3P1_RXP1: length 7.8
  TOP w0.114: UC977.2 13.65,146.58 13.88,146.58 v1(14.04,146.42) ; U5.23 16.63,146.96 16.54,146.86 16.45,146.86 arc(16.1,146.72) 15.95,146.36 15.95,146.25 arc(15.98,146.1) 16.07,145.97 16.41,145.63 16.51,145.52 arc(16.57,145.44) 16.59,145.34 16.59,145.13 v1(16.41,144.96)
  BOTTOM w0.114: v1(14.04,146.42) 14.21,146.58 15.01,146.58 arc(15.57,146.47) 16.04,146.16 16.47,145.73 arc(16.57,145.57) 16.61,145.39 16.61,145.16 v1(16.41,144.96)
USB3P1_RXP1_C: length 7.7
  TOP w0.114: J_TYPEC.A11 8.09,144.18 9.53,145.62 9.68,145.62 9.81,145.48 UU34.2 UU34.9 11.02,145.48 11.15,145.62 11.24,145.62 arc(11.5,145.73) 11.61,145.98 11.61,146.39 arc(11.65,146.49) 11.75,146.53 12.05,146.53 UC977.1
USB3P1_RXP2: length 6.5
  TOP w0.114: UC975.2 12.9,150.41 13.4,150.41 14.31,150.41 v1(14.49,150.23) ; v1(15.11,148.23) 15.54,148.67 16.01,148.67 16.21,148.46 16.62,148.46 16.71,148.55 U5.19
  BOTTOM w0.114: v1(14.49,150.23) 14.71,150.01 14.98,149.74 arc(15.08,149.59) 15.11,149.41 v1(15.11,148.23)
USB3P1_RXP2_C: length 14
  TOP w0.114: UC975.1 11.4,150.06 11.31,150.15 11.31,150.53 11.23,150.62 10.57,150.62 arc(10.37,150.66) 10.19,150.77 arc(10.16,150.8) 10.11,150.81 9.75,150.81 9.69,150.74 9.69,150.61 9.61,150.54 UU10.9 UU10.2 8.29,150.54 8.02,150.81 7.72,150.81 arc(7.63,150.83) 7.54,150.88 7.49,150.93 arc(7.41,150.99) 7.32,151.01 6.83,151.01 arc(6.44,151.08) 6.08,151.24 5.39,151.65 arc(5.02,151.81) 4.62,151.86 3.84,151.86 arc(3.39,151.67) 3.23,151.21 3.23,151.2 3.23,150.69 arc(3.32,150.01) 3.61,149.39 4.15,148.57 arc(4.28,148.45) 4.44,148.41 4.57,148.41 4.84,148.68 J_TYPEC.B11
USB3P1_TXN1: length 3.7
  TOP w0.114: U5.22 16.58,147.36 16.41,147.53 16.28,147.53 arc(16.19,147.51) 16.12,147.46 16.01,147.35 15.18,146.52 arc(15.08,146.38) 15.05,146.22 15.05,145.96 15.14,145.87 15.44,145.87 15.54,145.77 UC949.2
USB3P1_TXN1_CMC: length 1.4
  TOP w0.114: UC947.1 12.73,148.48 12.38,148.48 12.12,148.21 URN161.1
USB3P1_TXN1_R: length 5.8
  TOP w0.114: URN161.2 10.64,148.21 10.43,148.42 10.25,148.42 arc(9.99,148.53) 9.88,148.79 9.88,149.02 arc(9.84,149.13) 9.73,149.17 9.63,149.17 9.49,149.04 UU10.6 UU10.5 8.29,149.04 8.15,149.17 8.08,149.17 arc(7.97,149.13) 7.92,149.02 arc(7.72,148.52) 7.22,148.32 6.7,148.32 6.56,148.18 J_TYPEC.A3
USB3P1_TXN2: length 3.5
  TOP w0.114: U5.18 16.45,148.95 arc(16.25,148.99) 16.08,149.11 16.08,149.11 arc(15.95,149.2) 15.8,149.22 15.52,149.22 arc(15.3,149.18) 15.11,149.05 14.71,148.65 14.67,148.61 arc(14.52,148.51) 14.35,148.48 14.25,148.48 UC947.2
USB3P1_TXN2_CMC: length 3.4
  TOP w0.114: UC949.1 15.54,144.27 15.39,144.11 15.39,143.95 arc(15.24,143.61) 14.9,143.47 14.73,143.47 arc(14.46,143.52) 14.22,143.67 13.82,144.08 arc(13.77,144.11) 13.71,144.12 13.57,144.12 13.39,143.95 URN159.1
USB3P1_TXN2_R: length 15.2
  TOP w0.114: J_TYPEC.B3 4.2,144.68 arc(3.86,144.54) 3.65,144.24 3.26,143.26 arc(3.08,142.65) 3,142.02 3,141.82 arc(3.27,141.17) 3.91,140.9 4.82,140.9 arc(5.24,141.01) 5.61,141.22 5.94,141.47 arc(6.28,141.66) 6.67,141.72 7.28,141.72 arc(7.76,141.85) 8.11,142.21 8.67,143.23 arc(8.86,143.53) 9.09,143.79 9.21,143.92 arc(9.29,143.97) 9.37,143.98 UU34.5 UU34.6 11.66,143.98 11.7,143.95 URN159.2
USB3P1_TXP1: length 3.7
  TOP w0.114: U5.21 16.28,147.76 arc(16.1,147.72) 15.96,147.62 15.85,147.51 15.01,146.68 arc(14.87,146.47) 14.82,146.22 14.82,145.99 14.63,145.8 UC948.2
USB3P1_TXP1_CMC: length 1.3
  TOP w0.114: UC946.1 12.73,148.7 12.28,148.7 12.12,148.86 URN161.3
USB3P1_TXP1_R: length 5.8
  TOP w0.114: J_TYPEC.A2 6.57,148.68 6.7,148.55 7.22,148.55 arc(7.56,148.68) 7.7,149.02 arc(7.81,149.29) 8.08,149.4 8.15,149.4 8.29,149.54 UU10.4 UU10.7 9.49,149.54 9.63,149.4 9.73,149.4 arc(10,149.29) 10.11,149.02 10.11,148.79 arc(10.15,148.69) 10.25,148.65 10.43,148.65 10.64,148.86 URN161.4
USB3P1_TXP2: length 3.5
  TOP w0.114: UC946.2 14.25,148.7 14.35,148.7 arc(14.43,148.72) 14.5,148.77 14.55,148.82 14.95,149.22 arc(15.21,149.39) 15.52,149.45 15.8,149.45 arc(16.04,149.41) 16.24,149.27 16.24,149.27 arc(16.34,149.21) 16.45,149.18 16.49,149.18 16.67,149.36 U5.17
USB3P1_TXP2_CMC: length 3.4
  TOP w0.114: UC948.1 14.63,144.32 14.75,144.2 15.05,144.2 15.16,144.09 15.16,143.95 arc(15.08,143.77) 14.9,143.69 14.73,143.69 arc(14.54,143.73) 14.39,143.84 13.98,144.24 arc(13.86,144.32) 13.71,144.35 13.65,144.35 13.4,144.6 URN159.3
USB3P1_TXP2_R: length 15.2
  TOP w0.114: URN159.4 11.75,144.6 11.64,144.49 11.64,144.3 11.55,144.21 11.29,144.21 11.02,144.48 UU34.7 UU34.4 9.69,144.48 9.58,144.37 9.58,144.28 9.51,144.21 9.37,144.21 arc(9.2,144.18) 9.05,144.08 8.93,143.95 arc(8.68,143.66) 8.47,143.34 7.91,142.32 arc(7.65,142.05) 7.28,141.95 6.67,141.95 arc(6.21,141.88) 5.8,141.66 5.47,141.4 arc(5.16,141.22) 4.8,141.13 3.91,141.13 arc(3.43,141.33) 3.23,141.82 3.23,142.01 arc(3.3,142.6) 3.47,143.17 3.86,144.16 arc(4,144.35) 4.21,144.45 4.5,144.45 4.57,144.38 4.57,144.28 4.67,144.18 J_TYPEC.B2
USB_CHARGEPWR_EN#: length 295.2
  TOP w0.089: PCH.BF11 165.04,39.74 164.77,39.47 164.77,38.77 164.69,38.69 164.69,37.97
  TOP w0.102: v1(219.79,101.68) 219.16,101.05 219.16,99.97 219.33,99.8 219.33,99.23 221.81,96.75 v1(222.76,96.75) 222.76,96.36 223.55,95.56 223.55,90.39 220.55,87.39 220.55,80.54 222.85,78.24 v1(222.85,77.81) ; U942691.5 223.7,112.17 222.94,111.4 v1(222,111.4) ; U51.5 224.76,100.5 223.98,99.72 223.23,99.72 C941402.1 R69695.1 221.92,98.73 222.05,98.6 v1(223.06,98.6) ; v1(237.08,36.07) 237.4,36.07 240.18,33.28 240.18,6.3 239.18,5.3 237.38,5.3 237.2,5.47 234.07,5.47 233.27,4.67 231.03,4.67 v1(230.45,5.25) ; SR360.2 160.07,28.59 160.07,29.18 160.25,29.36 160.25,29.95 161.12,30.82 161.12,32.91 162.36,34.14 162.36,34.27 162.69,34.59 v1(162.69,34.67) 162.69,34.98 164.69,36.98 164.69,37.97 ; v1(136.14,21.46) 137.78,19.82 137.78,18.65 144.47,11.96 151,11.96 153.59,9.37 v1(153.59,8.46)
  BOTTOM w0.102: v1(222.85,77.81) v2(222.85,75.64) 223.27,75.64 228.39,70.51 228.39,68.69 232.58,64.5 232.58,62.21 237.07,57.71 237.07,55.99 234.67,53.58 234.67,42.36 236.4,40.64 237.11,39.92 237.11,38.73 236.54,38.16 236.54,36.61 v1(237.08,36.07) ; v1(136.14,21.46) 136.83,21.46 139.99,24.63 145.32,24.63 145.79,24.16 148.7,24.16 150.07,25.52 153.12,25.52 154.65,27.05 157.17,27.05 157.85,27.74 158.95,27.74 161.7,30.49 161.7,33.28 162.43,34.01 162.43,34.19 162.69,34.44 v1(162.69,34.67) ; v1(219.79,101.68) 219.79,105.87 221.53,107.61 221.53,110.93 v1(222,111.4) ; v1(222.76,96.75) 222.76,98.3 v1(223.06,98.6) ; v1(230.45,5.25) 229.41,4.22 193.14,4.22 192.94,4.42 188.85,4.42 187.96,3.53 156.26,3.53 153.59,6.2 v1(153.59,8.46)
USB_OC0#: length 111.5
  TOP w0.089: 183.29,47.7 182.57,47.7 182.35,47.93 181.48,47.93 181.36,48.04 180.86,48.04 180.6,48.3 PCH.AJ43
  TOP w0.102: v1(222.33,81.46) 221.89,81.89 221.89,87.29 225.06,90.45 225.06,96.96 224.61,97.41 v1(224.61,97.54) ; v1(185.58,48.44) 184.84,47.7 183.29,47.7 ; v1(206.4,76.3) 207.26,75.44 207.26,60.05 v1(206.32,59.11) ; v1(228.3,108.56) 228.77,108.09 228.77,105.42 228.33,104.99 UR69716.1 ; U51.13 227.08,104.16 227.51,104.58 UR69716.1 ; UR69716.1 227.09,104.99 226.75,105.33 226.75,106.17 226.31,106.6 UR69715.2
  BOTTOM w0.102: v1(185.58,48.44) 185.81,48.21 191.95,48.21 192.82,47.33 199.15,47.33 201.02,49.2 202.32,49.2 205.16,52.04 205.16,54.84 206.01,55.69 206.01,57.98 206.32,58.29 v1(206.32,59.11) ; v1(224.61,97.54) 224.61,98.22 224.84,98.45 224.84,99.49 226.16,100.81 226.16,103.25 226.77,103.86 226.77,105.12 227.01,105.36 227.01,106.23 227.41,106.62 227.41,107.67 v1(228.3,108.56) ; v1(206.4,76.3) 206.4,76.43 206.51,76.54 209.43,76.54 211.71,78.83 216.67,78.83 v2(217.46,79.62) 219.3,81.46 v1(222.33,81.46)
USB_OC1#: length 134.7
  TOP w0.089: 182.14,49.14 181.87,48.88 181.34,48.88 PCH.AH44
  TOP w0.102: v1(228.9,70.31) 228.9,67.46 227.13,65.68 227.13,52.5 224.16,49.53 222.3,49.53 220.94,50.89 215.04,50.89 212.36,53.57 210.03,53.57 208.08,55.52 v1(204.77,55.52) ; UR6.1 225.25,115.63 225.21,115.59 U942691.13 ; UR6.1 227.06,116.55 v1(227.28,116.33) ; UR6.1 225.16,116.55 224.17,117.54 224.17,118.25 v1(223.72,118.69) 223.66,118.76 UR5.2 ; v1(224.51,96.88) 224.51,96.57 224.62,96.46 224.62,90.33 221.68,87.38 221.68,87.34 221.5,87.16 221.5,80.93 222.47,79.96 v1(224.36,79.96) ; 182.14,49.14 186.48,49.14 v1(187.1,49.76)
  BOTTOM w0.102: v2(224.46,118.44) 224.21,118.69 v1(223.72,118.69) ; v1(227.28,116.33) 227.04,116.09 227.04,106.56 226.8,106.32 226.8,105.45 225.85,104.51 225.85,100.81 224.61,99.56 224.61,98.6 224.19,98.18 224.19,97.19 v1(224.51,96.88) ; v1(204.77,55.52) 204.57,55.32 204.57,52.1 202.26,49.78 200.99,49.78 199.97,48.77 196.85,48.77 195.86,49.76 v1(187.1,49.76) ; v1(228.9,70.31) 224.36,74.85 v2(224.36,76.81) v1(224.36,79.96)
USB_OC2#: length 144.2
  TOP w0.102: v1(178.59,47.17) 178.59,46.95 PCH.AM39 ; UR69730.2 227.69,132.21 227.72,132.24 UU51.3 v1(227.72,134.11) 227.21,134.62 UR69717.2 UR69718.1 ; v1(218.16,99.14) 218.87,98.42 219.22,98.42 222.54,95.11 222.54,90.29 219.9,87.66 219.9,79.2 223.43,75.68 223.43,70.57 213.83,60.97 213.83,56.16 212.61,54.94 209.42,54.94 207.91,56.45 207.2,56.45 206.96,56.21 v1(205.41,56.21)
  BOTTOM w0.089: 183.76,49.34 180.03,49.34 179.25,48.55 179.25,47.83 v1(178.59,47.17)
  BOTTOM w0.102: v1(205.41,56.21) 205.41,55.47 204.94,55 204.94,52.13 202.34,49.53 201.04,49.53 199.06,47.55 192.94,47.55 192.06,48.43 186.66,48.43 185.75,49.34 183.76,49.34 ; v1(227.72,134.11) v2(226.69,133.08) 221.13,127.52 221.13,126.3 222.84,124.59 222.84,121.23 220.22,118.61 220.22,111.38 220.66,110.93 220.66,107.96 218.67,105.97 218.67,101.1 218.16,100.59 v1(218.16,99.14)
USB_OC3#: length 360.8
  TOP w0.089: v1(179.98,48.44) 179.98,48.15 PCH.AK42
  TOP w0.102: UR69719.2 21.44,141.85 UR69720.1 ; UR69719.2 21.09,142.14 21.09,141.34 20.66,140.9 UU50.3 ; UR69719.2 20.75,142.53 20.75,142.58 v1(20.48,142.85) ; v1(201.17,46.13) 200.96,45.92 200.96,44.04 200.16,43.24 200.16,30.7 200.44,30.42 200.44,24.13 v1(200.84,23.73)
  BOTTOM w0.089: v1(179.98,48.44) 180.39,48.84
  BOTTOM w0.102: v1(201.17,46.13) 200.33,46.13 199.63,46.82 192.66,46.82 191.72,47.76 184.12,47.76 182.94,48.94 180.49,48.94 180.39,48.84 ; v1(20.48,142.85) v2(20.48,141.5) 20.48,140.78 23.62,137.64 23.62,136.35 24.27,135.7 24.27,127.97 23.16,126.86 23.16,124.59 22.89,124.31 22.89,121.5 21.11,119.72 21.11,113.08 21.39,112.8 21.39,56.74 21.97,56.16 21.97,39.84 22.45,39.36 22.45,31.93 23.96,30.43 23.96,28.51 27.18,25.29 27.86,25.29 41.12,12.03 50.53,12.03 51.75,10.81 54.95,10.81 55.92,9.84 57.84,9.84 57.85,9.85 57.98,9.98 58.09,10.09 74.08,10.09 74.38,10.39 74.83,10.39 75.7,11.25 91.49,11.25 92.2,11.96 93.74,11.96 94.05,11.66 104.25,11.66 104.33,11.73 119.59,11.73 119.85,11.47 121.34,11.47 121.49,11.32 134.74,11.32 139.26,15.84 149.43,15.84 149.64,16.06 156.48,16.06 157.13,16.71 158.87,16.71 161.48,19.32 167.79,19.32 168.43,18.68 178.83,18.68 179.93,19.79 181.27,19.79 182.94,21.46 188.88,21.46 189.32,21.02 199.04,21.02 200.84,22.82 v1(200.84,23.73)
USB_OCB4#: length 429.6
  TOP w0.089: 184.68,52.15 182.58,50.04 181.61,50.04 181.33,50.32 180.8,50.32 PCH.AD43
  TOP w0.102: v1(171.07,12.75) 171.07,12.33 167.35,8.61 157.95,8.61 157.09,9.47 155.14,9.47 151.63,12.98 151.13,12.98 150.17,13.94 144.87,13.94 139.95,18.86 139.95,20.62 138.47,22.11 138.47,23.62 v1(135.31,26.78) ; v1(30.71,201.08) CR17.2 ; v1(191.97,31.37) 191.97,28.59 193.73,26.83 193.73,21.63 193.21,21.11 193.21,18.24 v1(192.45,17.48) ; v1(200.2,49.79) 200,49.59 200,43.71 199.73,43.44 199.73,35.5 v1(199.42,35.18) ; 184.68,52.15 185.44,52.15 v1(186.47,53.18)
  BOTTOM w0.102: v1(30.71,201.08) v2(30.71,200.3) 30.71,199.72 27.76,196.77 27.76,192.25 24.33,188.82 24.33,181.18 23.75,180.59 23.75,178.01 21.99,176.25 21,176.25 20.26,175.51 20.26,159.72 24.9,155.08 24.9,149.54 25.24,149.2 25.24,147.38 24.85,146.99 24.85,146.04 24.5,145.68 24.5,138.99 25.19,138.29 25.19,137.01 25.84,136.35 25.84,123.79 24.68,122.62 24.68,120.75 23,119.08 23,113.86 23.18,113.68 23.18,59.56 24.73,58.01 24.73,44.6 32.36,36.97 32.36,29.33 36.22,25.47 96.73,25.47 97.5,24.7 132.14,24.7 134.22,26.78 v1(135.31,26.78) ; v1(192.45,17.48) 189.48,17.48 187.76,15.75 187.68,15.67 183.17,15.67 182.37,14.87 181.6,14.87 180.87,14.87 178.57,14.87 177.22,14.87 176.49,14.87 174.33,14.87 174.04,14.58 173.61,14.58 171.52,14.58 170.66,13.72 170.66,13.16 v1(171.07,12.75) ; v1(186.47,53.18) 187.73,53.18 188.85,52.06 195.87,52.06 197.85,50.07 199.92,50.07 v1(200.2,49.79) ; v1(191.97,31.37) 191.97,32.66 192.9,33.59 197.83,33.59 v1(199.42,35.18)
