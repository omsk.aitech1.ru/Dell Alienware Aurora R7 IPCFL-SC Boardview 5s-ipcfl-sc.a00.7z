# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 160.1,62.13 161.41,62.13 161.56,61.98 161.57,61.96 161.61,61.82 161.72,61.73 161.65,61.56 161.66,61.39 161.54,61.27 161.54,61.14 161.44,60.94 161.5,60.73 161.51,60.64 161.45,60.57 161.37,60.54 161.31,60.49 161.25,60.46 161.18,60.47 161.06,60.51 160.92,60.5 160.89,60.51 160.47,60.81 160.1,60.46 160.06,60.42 160.01,60.42 159.54,60.9 159.54,61.52 159.31,61.75 159.31,62.05 159.51,62.26 159.97,62.26
GND on TOP (solid shape): 12.47,142.04 12.47,141.53 12.37,141.43 11.43,141.43 11.13,141.12 11.13,140.82 10.92,140.61 8.46,140.61 7.82,139.98 7.82,138.86 7.95,138.73 9.25,138.73 9.45,138.53 9.45,137.62 9.35,137.52 8.05,137.52 7.48,136.95 7.22,134.8 9.28,134.16 9.38,134.15 9.42,134.06 9.42,130.91 8.31,129.79 8.31,127.71 6.05,125.45 6.05,121.18 9.3,117.93 9.3,117.6 8.92,117.22 0.58,117.22 0.51,117.3 0.51,141.12 0.51,141.13 2.04,141.13 2.57,140.59 5.89,140.59 6.71,141.4 8.03,141.4 8.38,141.76 11,141.76 11.07,141.83 11.07,141.83 11.2,141.92 11.28,142.04 11.29,142.04 11.33,142.09 12.42,142.09
GND on TOP (solid shape): 168.76,43.4 168.87,43.27 169.03,43.22 169.05,43.22 169.29,42.98 169.29,42.51 169.15,42.37 169.15,42.3 169.09,42.3 168.77,42.13 168.84,41.77 168.88,41.69 168.85,41.62 168.6,41.37 168.58,41.37 168.4,41.32 168.26,41.2 168.08,41.2 168,41.28 167.59,41.48 167.54,41.02 167.54,40.84 167.44,40.74 167.28,40.74 167.11,40.92 167.11,41.81 167.75,42.45 167.77,42.46 168,42.64 167.97,42.94 167.94,42.97 168.4,43.43 168.75,43.43
GND on TOP (solid shape): 172.09,61.16 172.14,61.11 172.14,60.91 172.16,60.88 172.34,60.71 172.33,60.65 172.32,60.57 172.34,60.49 172.38,60.42 172.4,60.34 172.36,60.28 172.3,60.22 172.27,60.14 172.25,60.11 172.22,60.08 172.13,60.08 172.04,60.06 171.99,60.05 171.94,60.03 171.85,60.04 171.8,60.11 171.64,60.31 171.38,60.3 171.27,60.3 171.22,60.38 171.19,60.53 171.11,60.65 171.1,60.69 171.11,60.72 171.13,60.74 171.14,60.77 171.2,60.83 171.28,60.82 171.46,60.78 171.62,60.87 171.64,60.89 171.64,60.9 171.67,60.97 171.68,61.04 171.68,61.11 171.93,61.37 171.93,61.54 171.98,61.59 172.09,61.59
GND on TOP (solid shape): 174.38,61.09 174.38,60.93 174.41,60.89 174.61,60.7 174.6,60.57 174.7,60.37 174.92,60.32 175,60.3 175.03,60.22 175.05,60.07 175.13,59.93 175.15,59.87 175.13,59.81 175.09,59.74 175.05,59.67 175.05,59.65 175,59.62 174.95,59.63 174.91,59.63 174.86,59.63 174.73,60.08 174.27,60.12 174.24,60.12 174.18,60.17 174.16,60.22 174.13,60.28 173.86,60.39 173.64,60.2 173.55,60.2 173.5,60.25 173.44,60.29 173.24,60.45 172.97,60.46 172.88,60.47 172.83,60.55 172.83,60.62 172.82,60.7 172.79,60.77 172.78,60.78 172.78,60.83 172.77,60.84 172.77,60.88 172.82,60.94 172.87,60.98 172.93,60.9 172.93,60.87 173.14,60.62 173.42,60.78 173.48,60.83 173.56,60.82 173.71,60.78 173.85,60.84 173.92,60.92 173.95,61.02 173.95,61.04 174.1,61.18 174.28,61.18
GND on TOP (solid shape): outline of 241 points within 29.46,233.93 36.58,241.05
GND on TOP (solid shape): outline of 241 points within 161.54,233.93 168.66,241.05
GND on TOP (solid shape): outline of 241 points within 161.54,76.45 168.66,83.57
GND on TOP (solid shape): outline of 241 points within 233.93,76.45 241.05,83.57
GND on TOP (solid shape): outline of 258 points within 233.49,233.49 241.49,241.49
GND on TOP (solid shape): outline of 103 points within 168.83,57.17 175.01,59.17
GND on TOP (solid shape): outline of 1832 points within 0.51,0.51 243.33,243.33
GND on TOP (solid shape): outline of 4449 points within 118.31,153.14 144.78,181.43
GND on TOP (solid shape): outline of 5232 points within 160.3,39.22 180.94,62.51
GND on BOTTOM (solid shape): 13.57,158.09 11.03,158.09 11.03,172.46 13.57,172.46
GND on BOTTOM (solid shape): 76.25,2 54.7,2 54.7,4.54 76.25,4.54
GND on BOTTOM (solid shape): 129.16,153.29 129.16,152.53 128.94,152.31 128.23,152.31 128.14,152.4 128.14,153.29 128.27,153.42 129.03,153.42
GND on BOTTOM (solid shape): 211.12,206.96 211.12,201.63 210.95,201.45 208.74,201.45 208.51,201.68 208.51,206.81 208.86,207.16 210.92,207.16
GND on BOTTOM (solid shape): 211.25,198.09 211.25,188.11 210.36,187.22 209.25,187.22 208.48,187.99 208.48,196.98 209.85,198.35 211,198.35
GND on BOTTOM (solid shape): 122.36,171.64 122.36,169.08 122.15,168.86 121.34,168.86 121.28,168.91 121.28,170.13 121.21,170.21 121.21,171.58 121.34,171.7 122.3,171.7
GND on BOTTOM (solid shape): 115.29,226.72 115.29,225.06 114.89,224.66 109.47,224.66 109.23,224.9 109.23,224.92 108.34,225.81 104.08,225.81 103.69,226.2 103.69,227.69 104.28,228.28 113.73,228.28
GND on BOTTOM (solid shape): 124.31,156.44 124.31,154.05 123.85,153.59 119.68,153.59 119.2,154.08 119.2,156.41 119.25,156.46 121.54,156.46 121.64,156.57 124.18,156.57
GND on BOTTOM (solid shape): 127.05,171.48 127.05,167.88 126.89,167.72 125.4,167.72 125.25,167.87 125.25,169.62 125.25,169.62 125.25,171.32 125.53,171.6 126.92,171.6
GND on BOTTOM (solid shape): 134.97,228.19 135.29,228.19 136.27,227.2 136.27,226.19 136.02,225.93 122.17,225.93 121.92,226.19 121.92,227.58 122.56,228.22 124.21,228.22 124.21,228.22 134.93,228.22
GND on BOTTOM (solid shape): 128.65,155.83 129.13,155.83 129.16,155.8 129.16,154.52 128.88,154.24 128.24,154.24 128.03,154.45 128.03,154.67 128.03,154.67 128.03,155.97 128.03,155.97 128.14,156.08 128.4,156.08
GND on BOTTOM (solid shape): 75.82,138.68 75.82,137.36 75.54,137.08 73.18,137.08 72.92,137.34 72.92,137.44 72.77,137.59 71.81,137.59 71.37,137.16 69.09,137.16 68.83,137.41 68.83,138.43 69.22,138.81 75.69,138.81
GND on BOTTOM (solid shape): 59.31,140.12 59.44,140.07 59.57,140.06 59.71,140.07 59.84,140.12 64.96,140.12 66.29,138.79 66.29,136.53 66.17,136.4 65.41,136.4 64.26,137.54 54.97,137.54 54.51,137.99 54.51,139.9 54.74,140.12
GND on BOTTOM (solid shape): 57.84,157.89 59.33,157.89 59.56,157.84 59.79,157.89 60.36,157.89 60.36,157.9 64.08,157.9 64.08,157.89 65.23,157.89 65.47,157.65 65.47,154.5 65.18,154.2 63.83,154.2 63.2,154.83 55.03,154.83 54.44,155.41 54.44,157.9 57.82,157.9
GND on BOTTOM (solid shape): 57.76,175.41 59.46,175.41 59.69,175.36 59.92,175.41 60.55,175.41 60.56,175.42 64,175.42 64,175.41 64.66,175.41 65.91,174.16 65.91,171.58 65.79,171.45 64.14,171.45 62.82,172.76 54.91,172.76 54.51,173.17 54.51,175.42 57.76,175.42
GND on BOTTOM (solid shape): 59.32,192.95 59.58,192.89 59.83,192.95 63.99,192.95 63.99,192.42 64.13,192.28 64.13,191.26 64.39,191.01 65.79,191.01 65.91,190.88 65.91,189.5 65.39,188.98 65.02,188.98 64.14,189.87 63.25,189.87 62.72,190.39 55.62,190.39 54.48,191.53 54.48,192.95
GND on BOTTOM (solid shape): 122.33,162.2 122.42,162.16 122.43,162.07 122.81,161.52 123.19,162.07 123.2,162.16 123.29,162.2 127.48,162.2 127.61,162.08 127.61,161.19 127.36,160.93 122,160.93 121.97,160.96 120.98,160.96 120.93,161.01 120.93,162.05 121.08,162.2
GND on BOTTOM (solid shape): outline of 241 points within 29.46,233.93 36.58,241.05
GND on BOTTOM (solid shape): outline of 241 points within 161.54,233.93 168.66,241.05
GND on BOTTOM (solid shape): outline of 241 points within 161.54,76.45 168.66,83.57
GND on BOTTOM (solid shape): outline of 241 points within 233.93,76.45 241.05,83.57
GND on BOTTOM (solid shape): outline of 258 points within 233.49,233.49 241.49,241.49
GND on BOTTOM (solid shape): outline of 5118 points within 0.51,0.51 243.33,243.33
GND on BOTTOM (solid shape): outline of 74610 points within 124.16,105.74 211.91,230.91
GND on VCC (solid shape): 137.29,226.21 137.29,224.9 137.05,224.66 122.05,224.66 121.92,224.79 121.92,226.97 123.04,228.09 135.4,228.09
GND on VCC (solid shape): 224.19,30.52 224.23,30.49 224.28,30.48 225.93,30.48 225.98,30.49 226.02,30.52 226.37,30.86 226.82,30.86 226.82,30.73 226.83,30.69 226.86,30.64 227.2,30.3 227.2,28.25 226.39,27.43 225.1,27.43 224.92,27.61 224.92,28.32 224.91,28.37 224.88,28.41 223.74,29.55 223.7,29.58 223.65,29.59 222.18,29.59 222.12,29.64 222.12,30.68 222.3,30.86 223.85,30.86
GND on VCC (solid shape): 212.47,95.32 212.47,94.54 211.24,93.31 211.21,93.27 211.2,93.22 211.2,89.28 211.21,89.23 211.24,89.19 212.47,87.96 212.47,78.74 212.48,78.69 212.51,78.65 212.98,78.18 212.98,76.86 211.68,75.56 211.25,75.56 210.95,75.87 210.95,77.54 211.42,78.02 211.45,78.06 211.46,78.11 211.46,87.63 211.45,87.68 211.42,87.72 210.31,88.83 210.31,94.44 211.13,95.25 211.71,95.25 211.76,95.26 211.8,95.29 211.89,95.38 212.42,95.38
GND on VCC (solid shape): 229.49,77.8 229.49,73.2 227.49,71.21 227.47,71.17 227.46,71.12 227.46,68.76 226.1,67.4 226.07,67.36 226.06,67.31 226.06,52.25 223.98,50.16 222.81,50.16 221.74,51.23 221.74,52.4 222.47,53.12 222.49,53.16 222.5,53.21 222.5,53.29 223.48,54.27 223.51,54.31 223.52,54.36 223.52,68.15 226.78,71.41 226.81,71.45 226.82,71.5 226.82,74.7 226.81,74.75 226.78,74.79 225.93,75.64 225.93,78.18 226.37,78.61 228.67,78.61
GND on VCC (solid shape): 215.68,146.6 215.72,146.57 215.77,146.56 218.26,146.56 218.57,146.25 218.57,142.94 218.38,142.75 218.06,142.75 218.01,142.74 217.97,142.71 217.33,142.08 217.31,142.03 217.3,141.99 217.3,133.6 217.31,133.56 217.33,133.51 218.06,132.79 218.06,128.45 216.32,126.71 216.29,126.67 216.28,126.62 216.28,123.24 215.94,122.9 215.91,122.86 215.9,122.81 215.9,110.92 214.32,109.35 210.22,109.35 210.06,109.51 210.06,112.9 210.05,112.95 210.02,112.99 208.91,114.1 208.91,141.93 214.43,147.45 214.83,147.45
GND on VCC (solid shape): 207.65,95.58 207.65,89.41 205.99,89.41 205.95,89.4 205.9,89.37 205.31,88.77 202.74,88.77 202.27,89.24 202.23,89.27 202.18,89.28 200.03,89.28 199.98,89.27 199.94,89.24 198.45,87.76 193.93,87.76 193.88,87.75 193.84,87.72 193.2,87.08 193.18,87.04 193.17,87 193.17,83.19 193.18,83.14 193.2,83.1 194.17,82.13 194.21,82.1 194.26,82.09 197.28,82.09 197.33,82.1 197.37,82.13 199.95,84.71 201.68,84.71 201.72,84.72 201.77,84.75 202.53,85.51 202.56,85.55 202.56,85.6 202.56,86.82 203,87.25 205.69,87.25 206.41,86.52 206.45,86.5 206.5,86.49 207.65,86.49 207.65,84.96 207.65,84.91 207.68,84.87 208.15,84.4 208.15,80.7 207.47,80.01 202.31,80.01 202.26,80 202.22,79.97 201.97,79.72 201.94,79.68 201.93,79.63 201.93,76.77 201.74,76.58 198.63,76.58 198.58,76.57 198.54,76.54 196.92,74.93 196.9,74.93 196.05,75.78 196.01,75.81 195.96,75.82 193.73,75.82 192.15,77.4 192.15,83.41 192.14,83.46 192.11,83.5 190.75,84.86 190.75,85.85 190.74,85.9 190.72,85.94 184.02,92.64 184.02,95.89 184.28,96.14 207.08,96.14
GND on VCC (solid shape): outline of 104 points within 142.88,24 165.1,41.4
GND on VCC (solid shape): outline of 265 points within 228.98,43.05 239.14,59.56
GND on VCC (solid shape): outline of 266 points within 228.09,59.82 239.14,68.58
GND on VCC (solid shape): outline of 268 points within 227.08,25.27 239.01,35.81
GND on VCC (solid shape): outline of 473 points within 206.81,4.83 239.4,18.41
GND on VCC (solid shape): outline of 670 points within 228.52,118.24 239.78,137.16
GND on VCC (solid shape): outline of 860 points within 221.48,88.27 239.78,114.36
GND on VCC (solid shape): outline of 8105 points within 0.51,0.51 243.33,243.33
GND on IN1 (solid shape): outline of 222694 points within 0.51,0.51 243.33,243.33
+0P95V_CPUIO on TOP (solid shape): outline of 96 points within 118.49,101.15 127.76,115.16
+0P95V_CPUIO on TOP (solid shape): 133.36,165.93 133.55,165.41 134.04,165.68 134.05,165.69 134.14,165.78 134.16,165.79 134.34,165.85 134.47,165.99 134.54,166.04 134.63,166.01 134.84,165.79 134.87,165.71 134.83,165.64 134.7,165.5 134.65,165.31 134.62,165.24 134.56,165.21 134.34,165.11 134.23,164.89 134.2,164.82 134.13,164.79 133.98,164.76 133.85,164.67 133.33,164.67 132.82,164.16 130.84,164.16 130.71,164.29 130.71,164.59 130.81,164.69 131.31,164.69 131.94,165.33 131.94,165.34 132.66,166.07 133.23,166.07
+0P95V_CPUIO on TOP (solid shape): 123.33,152.17 123.33,151.3 123.74,150.9 124.03,150.6 124.03,150.35 124.03,150.35 124.03,149.19 123.94,149.16 123.94,149.06 123.78,148.87 123.66,148.77 123.5,148.82 123.44,148.89 123.27,148.89 123.27,148.98 123.31,148.99 123.4,149.68 122.75,149.44 122.74,149.43 122.59,149.28 122.58,149.28 122.41,149.14 122.34,148.94 122.34,148.89 121.98,148.89 121.92,148.82 121.86,148.78 121.79,148.76 121.76,148.77 121.71,148.79 121.67,148.83 121.61,148.91 121.07,148.91 121.01,148.83 120.87,148.76 120.74,148.85 120.68,148.95 120.62,148.95 120.62,149.02 120.64,149.04 120.62,149.71 120,149.44 120,149.43 119.85,149.28 119.84,149.28 119.67,149.15 119.6,148.95 119.6,148.9 119.24,148.9 119.18,148.83 119.06,148.76 118.93,148.82 118.87,148.89 118.84,148.89 118.75,148.96 118.78,149.07 118.73,149.74 118.12,149.47 118.12,149.45 117.8,149.13 117.61,149.31 117.61,149.58 118.71,150.67 118.87,150.67 119.31,151.1 119.81,151.1 119.86,151.16 120.5,151.16 120.7,151.36 120.7,152.37 120.79,152.47 123.03,152.47
+0P95V_CPUIO on BOTTOM (solid shape): outline of 166 points within 122.58,111.28 132.72,136.37
+0P95V_CPUIO on BOTTOM (solid shape): outline of 931 points within 121.44,138.89 133.65,165.99
+1P2V on TOP (solid shape): 38.15,227.38 38.15,226.31 37.81,225.97 35.93,225.97 35.28,226.62 35.28,227.61 35.36,227.69 37.85,227.69
+1P2V_DUAL on TOP (solid shape): 208.53,143.89 208.53,142.54 208.66,142.42 208.66,141.1 208.53,140.97 206.68,140.97 206.5,141.15 206.5,143.79 206.73,144.02 208.41,144.02
+1P2V_DUAL on TOP (solid shape): 212.65,156.57 212.65,152.73 211.96,152.04 211.25,152.04 211.12,152.17 211.12,153.57 211.46,153.9 211.46,156.54 211.58,156.67 212.55,156.67
+1P2V_DUAL on TOP (solid shape): 208.41,119.38 208.41,119.13 208.61,118.92 208.61,113.54 208,112.93 206.48,112.93 206.15,113.26 206.15,113.56 206.15,113.57 206.19,113.8 206.15,114.02 206.15,114.03 206.15,115.26 206.15,115.27 206.19,115.5 206.15,115.72 206.15,115.73 206.15,116.96 206.15,116.97 206.19,117.2 206.15,117.42 206.15,117.43 206.15,118.66 206.17,118.73 206.19,118.81 206.35,118.97 206.5,118.97 206.5,119.13 206.88,119.51 208.28,119.51
+1P2V_DUAL on TOP (solid shape): 131.7,156.44 131.7,153.76 132.69,152.77 133.59,152.77 133.68,152.86 140.36,152.86 141.27,151.94 141.27,151.69 141,151.41 136.33,151.41 135.97,151.62 135.61,151.41 135.41,151.41 135.06,151.62 134.7,151.41 134.49,151.41 134.13,151.63 133.77,151.41 133.14,150.77 131.75,150.77 131.29,151.23 131.29,152.76 130.71,153.34 130.71,156.41 130.84,156.54 131.6,156.54
+1P2V_DUAL on TOP (solid shape): outline of 98 points within 128.1,96.93 167.11,106.92
+1P2V_DUAL on TOP (solid shape): outline of 155 points within 190.12,188.11 191.52,226.11
+1P2V_DUAL on TOP (solid shape): outline of 8732 points within 189.87,112.27 220.09,181.43
+1P2V_DUAL on BOTTOM (solid shape): outline of 488 points within 208.13,160.2 220.68,178.99
+1P2V_DUAL on VCC (solid shape): outline of 1174 points within 139.32,96.39 220.09,185.93
+1P2V_DUAL__LG_D on TOP (solid shape): 213.97,219.89 213.97,219.19 214.71,218.46 214.71,217.22 214.91,217.02 215.39,217.02 215.54,216.87 215.54,216.03 215.38,215.82 215.35,215.56 215.33,215.48 215.25,215.44 214.4,215.44 214.07,215.77 214.07,218.49 213.74,218.82 213.74,219.89 213.77,219.91 213.94,219.91
+1P2V_DUAL__LX_D on TOP (solid shape): 213.49,219.86 213.49,218.8 213.54,218.75 213.79,218.48 213.79,216.74 213.66,216.61 212.78,216.61 212.6,216.79 212.6,217.78 212.72,217.91 213,217.91 213.13,217.78 213.21,217.78 213.26,217.83 213.26,219.86 213.28,219.89 213.46,219.89
+1P2V_DUAL__LX_D on TOP (solid shape): 214.53,200.79 217.52,200.79 217.65,200.66 217.65,198.98 217.99,198.64 219.34,198.64 219.52,198.47 219.52,195.92 218.6,195.01 218.6,187.65 218.82,187.43 219.84,187.43 220.02,187.24 220.02,182.19 218.96,181.13 210.26,181.13 209.28,182.1 212.76,182.1 212.76,184.72 210.15,184.72 210.15,182.1 209.28,182.1 209.09,182.3 209.09,185.14 209.68,185.72 213.06,185.72 213.64,186.31 213.69,186.31 213.69,198.28 213.15,198.82 212.79,198.82 212.28,199.34 212.28,201.3 212.6,201.62 213.69,201.62
+1P2V_DUAL__LX_D on BOTTOM (solid shape): 219.13,197.61 219.13,189.17 219.1,189.16 219.04,189.14 218.98,189.11 218.93,189.07 218.89,189.03 218.85,188.98 218.82,188.93 218.79,188.87 218.78,188.81 218.77,188.75 218.77,188.69 218.78,188.63 218.79,188.57 218.82,188.51 218.85,188.46 218.89,188.41 218.93,188.37 218.98,188.33 219.04,188.3 219.1,188.28 219.13,188.28 219.13,183.03 217.21,181.11 209.77,181.11 209.3,181.58 209.3,182.02 212.85,182.02 212.85,184.81 210.06,184.81 210.06,182.02 209.3,182.02 209.3,185.32 209.85,185.88 212.72,185.88 213.66,186.82 213.66,197.79 213.89,198.02 218.72,198.02
+1P2V_DUAL__VCC_C on TOP (solid shape): 216.71,220.14 216.71,218.24 216.64,218.16 215.29,218.16 214.22,219.23 214.22,219.91 215.24,219.91 215.57,220.24 216.61,220.24
+1P2V_DUAL_BOOT_D on TOP (solid shape): 212.47,219.86 212.47,219.15 212.35,218.89 212.39,218.62 212.39,217.09 212.34,217.04 211.07,217.04 210.95,217.17 210.95,218.44 211.54,219.04 211.54,219.47 211.96,219.89 212.45,219.89
+1P2V_DUAL_BOOTR_D on TOP (solid shape): 213.74,216.13 213.74,215.37 213.63,215.25 210.5,215.25 210.31,215.44 210.31,216.03 210.52,216.23 213.64,216.23
+1P2V_DUAL_LG_R_D on TOP (solid shape): 213.02,187.75 213.02,186.74 212.59,186.31 210.79,186.31 210.41,186.69 210.41,187.73 211.37,187.73 211.53,187.9 212.87,187.9
+1P2V_DUAL_LG_R_D on TOP (solid shape): 213.11,194.13 213.11,192.71 212.93,192.53 212.9,192.51 210.85,192.51 210.52,192.84 210.52,193.45 210.54,193.47 211.23,193.47 211.28,193.52 211.28,194.06 211.46,194.23 213,194.23
+1P2V_DUAL_UG_R_D on TOP (solid shape): 220.47,199.82 221.13,199.82 221.24,199.72 221.24,197.36 220.9,197.03 219.89,197.03 219.79,197.13 219.79,198.88 219.35,199.32 218.21,199.32 218.09,199.44 218.09,200.72 218.16,200.78 219.51,200.78
+1P2V_SUS on TOP (solid shape): 43.79,230.03 43.79,227.25 43.68,227.13 38.76,227.13 38.35,227.53 38.35,228.08 38.76,228.49 40.92,228.49 41.35,228.05 42.95,228.05 43.13,228.23 43.13,230.21 43.61,230.21
+1P05_SA_BOOT_D on TOP (solid shape): 70.94,120.71 70.94,120.69 71.15,120.41 71.5,120.32 71.93,119.89 72.14,119.89 72.14,118.41 70.48,118.41 70.28,118.62 70.28,120.8 70.84,120.8
+1P05_SA_BOOTR_D on TOP (solid shape): 74.75,121.74 74.75,119.38 73.76,118.39 73.25,118.39 73.15,118.49 73.15,119.89 73.69,120.42 73.69,121.82 73.76,121.89 74.6,121.89
+1P05_SA_LG_R_D on TOP (solid shape): 77.22,138.3 77.22,137.19 77.55,136.86 77.55,136.47 77.22,136.14 76.4,136.14 76.33,136.22 76.33,138.43 76.43,138.53 76.99,138.53
+1P05_SA_LX_D on TOP (solid shape): 76.83,135.25 76.83,128.02 76.58,127.76 73.41,127.76 72.14,129.03 72.14,129.64 71.83,129.95 69.6,129.95 69.57,129.92 69.39,129.92 69.34,129.97 69.34,131.83 69.98,132.46 69.98,135.51 70.1,135.64 76.45,135.64
+1P05_SA_LX_D on TOP (solid shape): 73.36,121.69 73.36,120.55 72.92,120.12 72.36,120.12 72.03,120.45 72.03,120.88 71.98,120.93 71.83,121.23 71.53,121.38 71.48,121.44 70.99,121.44 70.89,121.54 70.31,121.54 70.28,121.56 70.28,121.77 70.31,121.79 71.07,121.79 71.15,121.72 71.28,121.72 71.35,121.7 71.42,121.7 72.02,121.7 72.04,121.72 72.16,121.72 72.31,121.87 73.18,121.87
+1P05_SA_LX_D on BOTTOM (solid shape): 76.83,135.25 76.83,128.02 76.58,127.76 73.41,127.76 72.14,129.03 72.14,129.92 71.63,130.43 69.47,130.43 69.34,130.56 69.34,131.83 69.98,132.46 69.98,135.51 70.1,135.64 76.45,135.64
+1P05_SA_LX_D on VCC (solid shape): 76.83,135.28 76.83,127.99 76.6,127.76 73.38,127.76 72.14,129.01 72.14,129.79 72.12,129.89 72.06,129.97 71.68,130.35 71.6,130.41 71.5,130.43 69.47,130.43 69.34,130.56 69.34,131.85 69.9,132.41 69.96,132.49 69.98,132.59 69.98,135.64 76.48,135.64
+1P05_SA_SN on TOP (solid shape): 69.47,135.03 69.47,132.74 68.9,132.17 67.6,132.17 67.54,132.23 67.54,133.81 67.67,133.93 67.97,133.93 68.28,134.24 68.28,134.9 68.5,135.13 69.37,135.13
+1P05_SA_UG_R_D on TOP (solid shape): 69.61,129.5 71.5,129.5 71.59,129.41 71.59,127.81 71.44,127.66 69.24,127.66 69.18,127.72 69.18,129.46 69.28,129.57 69.55,129.57
+1P05V_SA on TOP (solid shape): 91.26,142.97 92.89,142.97 92.89,144.53 94.49,144.53 94.87,144.15 94.87,135.76 89.9,130.8 85.05,130.8 83.12,128.87 78.85,128.87 78.46,129.26 78.46,135.15 78.71,135.41 79.65,135.41 81.57,137.33 83.08,137.33 83.08,135.81 84.71,135.81 84.71,137.36 85.88,138.53 85.88,143.66 86.74,144.53 91.26,144.53
+1P05V_SA on TOP (solid shape): outline of 312 points within 117.38,146.88 128.27,156.74
+1P05V_SA on BOTTOM (solid shape): outline of 256 points within 117.42,147.32 128.3,156.84
+1P05V_SA on VCC (solid shape): 95,144.22 95,135.82 89.99,130.81 85.09,130.81 85.04,130.8 85,130.77 83.13,128.91 78.92,128.91 78.49,129.34 78.49,135.2 78.67,135.38 79.63,135.38 79.68,135.39 79.72,135.42 81.97,137.67 84.84,137.67 84.88,137.68 84.93,137.71 85.81,138.59 85.84,138.64 85.85,138.68 85.85,143.71 86.92,144.78 94.44,144.78
+1P05V_SA on IN1 (solid shape): outline of 4045 points within 91.39,134.21 129.03,160.96
+2P5_VPP_SW on TOP (solid shape): 210.95,124.36 210.95,123.8 211,123.75 211.15,123.75 211.2,123.8 211.2,124.41 211.4,124.41 211.46,124.36 211.46,123.77 211.51,123.72 211.66,123.72 211.71,123.77 211.71,124.41 211.94,124.41 211.96,124.38 211.96,123.8 212,123.76 212,123.3 212.76,122.55 213.5,122.55 213.5,122.54 213.68,122.54 213.79,122.43 213.79,119.53 213.37,119.11 210.48,119.11 209.91,119.68 209.91,123.19 210.16,123.44 210.41,123.44 210.72,123.75 210.72,124.38 210.74,124.41 210.9,124.41
+2P5V_VPP on TOP (solid shape): outline of 1444 points within 172.19,101.45 214.63,116.18
+2P5V_VPP on BOTTOM (solid shape): 212.09,111.53 212.09,105.46 210.26,103.63 209.19,103.63 208.84,103.99 208.84,105.21 209.8,106.17 209.8,111.58 210.06,111.84 211.79,111.84
+2P5V_VPP on BOTTOM (solid shape): outline of 1792 points within 174.65,102.26 206.04,107.04
+3P3V on TOP (solid shape): 44.65,132.16 44.65,131.66 44.13,131.15 42.8,131.15 42.64,131.31 42.64,131.89 43.01,132.26 44.55,132.26
+3P3V on TOP (solid shape): 209.05,108.87 209.05,107.88 208.87,107.7 206.88,107.7 206.63,107.95 206.63,108.89 206.76,109.02 208.9,109.02
+3P3V on TOP (solid shape): 227.81,18.95 227.81,18.59 227.51,18.29 227.51,16.74 227.23,16.74 227.23,18.31 227,18.31 227,16.74 226.72,16.74 226.72,18.37 226.63,18.47 226.31,18.47 226.24,18.54 226.24,18.92 226.34,19.02 227.74,19.02
+3P3V on TOP (solid shape): 223.37,20.32 223.37,20.04 223.55,19.86 225.07,19.86 225.25,19.68 225.25,19.3 225.15,19.21 225.15,18.59 224.99,18.43 224.99,16.74 224.71,16.74 224.71,18.29 224.49,18.29 224.49,16.74 224.23,16.74 224.23,18.29 224,18.29 224,16.74 223.72,16.74 223.72,18.29 223.49,18.29 223.49,16.74 223.22,16.74 223.22,18.39 223.09,18.52 222.73,18.52 222.55,18.69 222.55,20.32 222.68,20.45 223.24,20.45
+3P3V on TOP (solid shape): outline of 103 points within 203.77,14 210.52,18.5
+3P3V on TOP (solid shape): outline of 182 points within 229.64,148.06 240.16,158.19
+3P3V on TOP (solid shape): outline of 1922 points within 49.91,17.69 61.09,86.61
+3P3V on VCC (solid shape): outline of 2668 points within 40.39,1.4 240.92,158.24
+3P3V_DISCHARGE on TOP (solid shape): 228.94,157.58 228.94,156.71 228.02,155.78 228.02,154.31 227.91,154.2 227.46,154.2 227.33,154.33 227.33,157.15 227.94,157.76 228.77,157.76
+3P3V_DP on TOP (solid shape): outline of 139 points within 5.87,170.49 16.89,176.89
+3P3V_LAN on TOP (solid shape): 30.61,228.93 30.61,227.63 30.47,227.5 29.12,227.5 28.85,227.23 28.09,227.23 27.86,227.46 27.86,228.96 28.09,229.18 30.35,229.18
+3P3V_LAN on TOP (solid shape): 25.25,233.55 25.25,232.03 25.1,231.88 23.65,231.88 23.47,232.05 23.47,232.77 23.27,232.97 21.23,232.97 21.01,233.2 21.01,233.76 21.18,233.93 24.87,233.93
+3P3V_LAN on TOP (solid shape): 40.39,224.89 40.39,223.14 39.88,222.63 39.88,219.07 39.62,218.82 39.14,218.82 38.3,217.98 36.88,217.75 36.7,217.75 36.68,217.78 36.68,218.27 38.04,219.01 38.86,219.84 38.86,224.18 38.71,224.33 36.06,224.33 35.43,224.96 35.43,225.3 35.78,225.64 39.64,225.64
+3P3V_UC on TOP (solid shape): 102.46,37.54 102.46,35.03 102.39,34.95 101.96,34.95 101.85,35.05 101.85,36.6 101.8,36.65 101.27,36.65 101.19,36.58 101.19,35.05 101.09,34.95 100.71,34.95 100.61,35.05 100.61,37.52 100.84,37.74 102.26,37.74
+3P3VA on TOP (solid shape): outline of 166 points within 223.27,161.67 230.35,179.3
+3P3VSB on TOP (solid shape): 24.46,107.06 24.46,105.49 24.26,105.28 22.56,105.28 22.38,105.46 22.38,107.24 22.56,107.42 24.1,107.42
+3P3VSB on TOP (solid shape): 25.6,99.01 25.6,98.17 24.97,97.54 24.16,97.54 23.95,97.74 23.95,98.83 24.31,99.19 25.43,99.19
+3P3VSB on TOP (solid shape): 47.75,98.78 47.75,97.46 46.58,96.29 45.75,96.29 44.86,97.18 44.86,98.07 46.05,99.26 47.27,99.26
+3P3VSB on TOP (solid shape): 56.03,15.11 56.03,14.35 55.85,14.17 54.33,14.17 54.2,14.3 54.2,15.21 54.33,15.34 55.8,15.34
+3P3VSB on TOP (solid shape): 190.5,3.84 190.5,3.28 190.25,3.02 188.7,3.02 188.42,3.3 188.42,3.73 188.75,4.06 190.27,4.06
+3P3VSB on TOP (solid shape): 212.52,44.64 212.52,44.35 212.45,44.27 208.46,44.27 208.15,44.58 208.15,44.96 208.65,45.45 211.71,45.45
+3P3VSB on TOP (solid shape): 38.68,83.79 38.68,79.76 37.93,79.01 36.36,79.01 35.59,79.78 35.59,83.74 36.04,84.2 38.28,84.2
+3P3VSB on TOP (solid shape): 240.82,145.14 240.82,140.94 240.37,140.5 233.64,140.5 232.99,141.15 232.99,144.58 233.81,145.39 240.56,145.39
+3P3VSB on TOP (solid shape): 112.9,3.3 112.9,1.65 112.6,1.35 110.46,1.35 110.19,1.63 110.19,3.38 110.59,3.78 112.42,3.78
+3P3VSB on TOP (solid shape): 180.01,13.11 180.01,9.58 179.78,9.35 178.97,9.35 178.82,9.5 178.82,10.9 178.54,11.18 177.11,11.18 176.91,11.38 176.91,13.08 177.16,13.34 179.78,13.34
+3P3VSB on TOP (solid shape): 56.52,77.55 56.52,76.4 57.15,75.77 57.15,75.51 57.56,75.11 57.56,74.78 57.4,74.63 57.15,74.63 55.85,75.92 55.85,77.6 55.93,77.67 56.39,77.67
+3P3VSB on TOP (solid shape): 191.22,42.35 191.22,41.82 191.06,41.66 187.2,41.66 187.07,41.78 187.07,42.29 187.2,42.42 190.78,42.42 190.8,42.44 191.13,42.44
+3P3VSB on TOP (solid shape): 226.17,161.35 229.3,161.35 229.49,161.16 229.49,159.36 229.01,158.88 228.47,158.88 226.95,157.35 226.95,147.19 226.44,146.69 223.9,146.69 223.24,147.35 223.24,156.72 224.13,157.61 224.13,158.09 225.04,159 225.04,161.49 225.15,161.59 225.93,161.59
+3P3VSB on TOP (solid shape): 179.77,40.08 180.06,40.08 180.31,39.83 180.31,39.7 180.49,39.53 180.82,39.53 180.82,39.52 180.95,39.4 180.95,39.19 181.28,38.86 182.14,38.86 182.25,38.76 182.25,38.43 182.14,38.33 180,38.33 179.63,38.7 179.63,39.87 179.23,40.27 179.23,40.38 179.3,40.46 179.39,40.46
+3P3VSB on TOP (solid shape): 182.54,40.86 183.03,40.86 183.31,40.58 183.31,39.7 183.21,39.6 182.87,39.6 182.36,40.11 181.53,40.11 181.41,40.23 181.05,40.23 180.97,40.32 180.97,40.46 181.03,40.52 181.36,40.58 181.53,40.87 182.53,40.87
+3P3VSB on TOP (solid shape): 188.51,9.68 188.89,9.49 189.26,9.68 189.59,9.68 189.81,9.45 189.81,9.17 189.8,9.16 189.8,8.55 189.56,8.3 189.41,8.24 189.3,8.13 188.47,8.13 188.33,8.28 188.09,8.28 187.96,8.41 187.96,9.58 188.06,9.68
+3P3VSB on TOP (solid shape): 27.79,116.58 27.79,115.11 27.84,115.06 27.99,115.06 28.04,115.11 28.04,116.59 28.09,116.64 28.27,116.64 28.3,116.61 28.3,114.78 28.12,114.6 26.67,114.6 26.67,114.65 26.39,115.02 25.95,114.89 24.56,114.89 23.4,116.05 22.89,116.05 22.83,116.12 22.83,116.62 22.87,116.66 27.71,116.66
+3P3VSB on TOP (solid shape): 203.25,36.14 203.15,36.04 203.15,35.71 202.9,35.71 202.49,35.31 202.9,34.9 203.15,34.9 203.15,31.72 203.05,31.62 202.31,31.62 202.06,31.87 202.08,31.91 202.16,32.18 202.06,32.44 202.06,40.13 202.32,40.4 203.25,40.4
+3P3VSB on TOP (solid shape): 53.49,117.35 53.49,116.31 52.75,115.57 51.83,115.57 51.57,115.82 51.04,115.82 51.01,115.85 50.39,115.85 50.34,115.8 50.34,115.75 49.89,115.29 49.89,114.66 49.78,114.56 49.78,113.74 49.17,113.13 46.94,113.13 46.61,113.46 46.61,113.79 46.84,114.02 46.86,114.02 47.32,114.48 48.74,114.48 48.87,114.6 48.87,114.83 48.82,114.88 47.27,114.88 46.29,113.91 45.38,113.91 45.01,114.27 45.01,116.43 45.03,116.46 45.29,116.46 45.31,116.43 45.31,115.14 45.36,115.09 45.49,115.09 45.52,115.11 45.52,116.38 45.57,116.43 45.77,116.43 45.82,116.38 45.82,115.01 45.86,114.97 46.06,114.97 47.55,116.46 48.36,116.46 48.51,116.61 50.01,116.61 50.44,117.04 52.32,117.04 52.83,117.55 53.29,117.55
+3P3VSB on TOP (solid shape): 161.45,40.13 161.51,40.11 161.57,40.11 161.66,40.13 161.7,40.13 161.83,40 161.83,39.72 161.74,39.63 161.72,39.62 161.67,39.59 161.63,39.55 161.58,39.45 161.56,39.33 161.57,39.31 161.52,39.26 161.5,39.26 161.37,39.2 161.26,39.09 161.25,39.08 161.21,39.06 161.18,39.06 161.07,39.09 160.95,39.08 160.84,39.08 160.68,39.24 160.68,39.39 160.86,39.57 160.86,39.97 161.02,40.13 161.13,40.14 161.17,40.16 161.38,40.16
+3P3VSB on TOP (solid shape): 42.32,74.9 42.32,71.36 40.73,71.12 42.32,70.88 42.32,32.79 40.94,31.42 40.94,30.91 40.87,30.57 40.94,30.24 40.94,23.09 42.16,21.87 42.16,14.27 46.43,10.01 46.43,7.06 47.98,5.51 53.49,5.51 54.64,4.36 72.52,4.36 73.25,3.62 73.25,1.63 72.97,1.35 43.1,1.35 42.34,2.11 42.34,5.87 42.42,5.94 42.96,5.94 42.96,6.78 42.35,6.78 42.08,7.06 42.08,7.91 37.12,12.86 37.12,24.6 37.12,58.26 39.03,60.16 39.03,67.73 38.09,68.67 38.09,74.23 39.15,75.29 41.94,75.29
+3P3VSB on BOTTOM (solid shape): 113.61,3.02 113.61,1.35 111.12,1.35 110.69,1.78 110.69,2.79 111,3.1 113.54,3.1
+3P3VSB on BOTTOM (solid shape): 48.29,97.64 48.29,97.08 47.14,95.94 46.56,95.94 45.54,96.95 45.54,97.84 46.43,98.73 47.19,98.73
+3P3VSB on BOTTOM (solid shape): 24.46,107.16 24.46,105.46 24.26,105.26 23.62,105.26 23.39,105.49 23.39,107.33 23.48,107.42 24.21,107.42
+3P3VSB on BOTTOM (solid shape): 24.66,99.5 24.66,97.8 24.46,97.6 23.83,97.6 23.6,97.83 23.6,99.67 23.69,99.76 24.41,99.76
+3P3VSB on BOTTOM (solid shape): 24.73,115.71 24.73,115.05 24.55,114.87 24.55,114.64 24.46,114.55 23.6,114.55 23.48,114.67 23.48,115.74 23.77,116.03 24.41,116.03
+3P3VSB on BOTTOM (solid shape): 38.63,81.06 38.63,71.07 38.36,70.81 37.93,70.81 37.93,70.82 37.31,70.82 35.84,72.29 35.84,81.46 36.04,81.66 38.02,81.66
+3P3VSB on BOTTOM (solid shape): 156.11,2.97 156.11,2.46 154.99,1.35 143.1,1.35 142.85,1.6 142.85,3.02 143.1,3.28 149.33,3.28 149.36,3.31 155.77,3.31
+3P3VSB on BOTTOM (solid shape): 203.23,39.98 203.23,38.2 203.03,38.01 202.98,37.98 202.93,37.95 202.06,37.95 201.78,38.23 201.78,39.83 202.03,40.08 203.12,40.08
+3P3VSB on BOTTOM (solid shape): 48.35,114.41 48.35,113.66 47.88,113.18 47.37,113.18 46.56,112.37 46.56,110.92 46.99,110.49 46.99,108.41 44.55,108.41 44.4,108.56 44.4,113.61 45.77,114.99 47.78,114.99
+3P3VSB on BOTTOM (solid shape): 192.28,3.62 193.66,3.62 193.78,3.51 193.83,3.51 193.83,1.5 193.68,1.35 189.53,1.35 188.98,1.91 188.98,3.73 189.23,3.99 191.91,3.99
+3P3VSB on BOTTOM (solid shape): 242.47,144.81 242.47,144.12 242.44,144.09 242.44,143.56 242.43,143.55 242.25,143.55 241.96,143.26 238.46,143.26 237.85,143.87 237.85,144.88 238.48,145.52 241.76,145.52
+3P3VSB on BOTTOM (solid shape): 55.22,118.9 55.22,116.28 55.08,116.15 54.58,116.15 54.42,116.31 54.41,116.31 54.08,116.64 52.96,116.64 52.53,117.07 52.53,117.3 52.56,117.62 52.35,117.87 52.35,118.21 52.41,118.27 52.53,118.35 52.62,118.48 52.62,118.49 53.19,119.05 55.07,119.05
+3P3VSB on BOTTOM (solid shape): 242.49,96.65 242.49,88.8 242.48,88.79 242.48,85.56 242.02,85.1 239.63,85.1 238.7,85.4 237.73,85.53 236.55,85.45 235.41,85.13 234.68,84.77 234.01,84.3 233.81,84.3 233.07,85.04 233.07,86.89 233.68,87.5 234.8,87.5 236.42,89.12 236.59,89.1 236.75,89.15 238.67,89.15 239.07,89.56 239.1,89.56 240.16,90.61 240.16,97.94 240.18,97.97 241.17,97.97
+3P3VSB on BOTTOM (solid shape): outline of 93 points within 232.28,1.37 239.93,6.1
+3P3VSB on IN1 (solid shape): outline of 694 points within 43.42,1.27 242.51,145.67
+CPUIO_DRV_D on TOP (solid shape): 130.3,101.06 130.3,100.41 130.55,100.17 130.99,100.17 131.2,99.96 131.2,97.97 131.11,97.88 129.93,97.88 129.72,98.09 129.72,99.47 129.54,99.64 129.44,99.64 129.36,99.72 129.36,101.14 129.39,101.17 130.2,101.17
+CPUIO_DRVR_D on TOP (solid shape): 127.67,102.68 127.67,101.39 127.91,101.15 128.44,101.15 128.44,99.85 128.31,99.71 127.88,99.71 127.36,100.23 127.36,100.57 126.83,101.09 126.5,101.09 125.81,101.78 124.84,101.78 124.7,101.92 124.7,103.05 127.3,103.05
+CPUIO_RC2 on TOP (solid shape): 132.7,100.93 132.7,100.69 132.63,100.58 132.59,100.46 132.12,100.46 132.08,100.5 130.6,100.5 130.52,100.58 130.52,100.81 130.76,101.05 132.58,101.05
+USB_TYPEC on TOP (solid shape): 9.49,148.08 9.49,147.53 9.07,147.11 8.43,147.11 8.2,147.35 8.2,148.12 8.32,148.24 9.33,148.24
+USB_TYPEC on TOP (solid shape): outline of 87 points within 11.71,153.47 34.9,165.51
+USB_TYPEC on BOTTOM (solid shape): outline of 145 points within 7.44,143.99 13.73,155.85
+VCORE on TOP (solid shape): 133.93,170.43 133.93,170.24 133.74,169.89 133.93,169.54 133.93,167.49 133.74,167.14 133.93,166.79 133.93,166.55 133.85,166.5 133.78,166.43 133.36,166.43 132.75,167.04 132.75,169.94 133.18,170.38 133.42,170.42 133.6,170.58 133.78,170.58
+VCORE on TOP (solid shape): outline of 4831 points within 73.29,140.46 134.78,200.66
+VCORE on BOTTOM (solid shape): outline of 4289 points within 73.36,140.69 133.87,195.82
+VCORE on VCC (solid shape): outline of 180 points within 73.28,140.45 133.73,200.66
+VTT_DDR on TOP (solid shape): 209.88,158.62 209.88,157.56 209.74,157.42 209.72,157.42 209.52,157.23 209.52,156.5 209.36,156.34 208.84,156.34 208.64,156.13 208.64,154.15 207.95,153.47 207.95,152.25 207.77,152.07 207.19,152.07 207.04,152.22 207.04,153.75 207.59,154.31 207.59,156.13 207.77,156.31 207.77,157.71 207.7,157.78 207.7,158.72 209.78,158.72
+VTT_DDR on TOP (solid shape): 193.49,166.09 193.98,165.86 194.47,166.09 197.29,166.09 197.78,165.86 198.27,166.09 201.27,166.09 201.76,165.86 202.25,166.09 204.55,166.09 206.27,164.36 208.05,164.36 208.15,164.26 208.15,163.47 207.68,163 205.83,163 203.91,164.92 191.95,164.92 191.41,164.39 187.71,164.39 187.1,165 187.1,165.71 187.27,165.89 188.96,165.89 189.15,165.86 189.34,165.89 191.19,165.89 191.39,166.09
+VTT_DDR on IN1 (solid shape): 177.02,166.19 177.58,165.86 178.14,166.19 180.82,166.19 181.38,165.86 181.94,166.19 184.79,166.19 185.35,165.86 185.91,166.19 187.63,166.19 188.04,165.79 188.04,165.48 187.66,165.1 175.97,165.1 175.49,165.58 175.49,166.09 175.59,166.19
DP_3P3V_PWR_FUSE on TOP (solid shape): 20.07,176.61 20.07,176.17 19.02,175.13 18.03,175.13 17.91,175.26 17.91,176.53 18.14,176.76 19.91,176.76
H7_SCREW on TOP (solid shape): outline of 238 points within 5.41,30.29 14.16,41.55
H7_SCREW on BOTTOM (solid shape): outline of 258 points within 6.16,30.29 14.16,38.29
H8_SCREW on TOP (solid shape): outline of 261 points within 6.16,72.34 14.38,84.01
H8_SCREW on BOTTOM (solid shape): outline of 258 points within 6.16,76.01 14.16,84.01
PE4_2_A6 on TOP (solid shape): 52.7,66.37 52.7,65.67 52.18,65.14 51.95,64.98 51.8,64.74 51.8,64.73 51.28,64.21 51.03,64.21 50.98,64.16 50.27,64.16 50.04,64.39 50.04,64.97 50.24,65.18 51.28,65.18 51.84,65.74 51.84,66.34 51.99,66.5 52.58,66.5
PE4_2_A8 on TOP (solid shape): 53.67,66.29 53.67,65.23 52.7,64.26 52.2,64.26 52.07,64.39 52.07,64.74 52.91,65.58 52.91,66.32 53.01,66.42 53.54,66.42
VGT_PWM1_BOT_C on TOP (solid shape): 95.07,230.1 95.07,228.95 94.84,228.72 94.84,228.35 94.82,228.34 94.82,228.09 94.81,228.07 94.35,228.07 94.12,228.3 94.12,228.31 94.02,228.44 93.89,228.53 93.89,228.54 93.54,228.88 93.54,230.33 93.69,230.48 94.69,230.48
VGT_PWM1_BOTR_C on TOP (solid shape): 98.28,230.25 98.99,229.54 98.99,229.24 97.47,229.24 97.16,229.55 96.53,229.55 96.37,229.39 95.89,229.39 95.65,229.62 95.65,230.35 95.89,230.58 98.28,230.58
VGT_PWM1_HG_D on TOP (solid shape): 97.18,229.07 97.18,228.59 96.73,228.14 96.19,228.14 96.13,228.21 96.13,228.66 96.64,229.18 97.07,229.18
VGT_PWM1_HGR_D on TOP (solid shape): 121.4,220.63 121.4,218.59 121.92,218.07 121.92,215.65 121.21,214.93 120.7,214.93 119.94,215.7 119.94,216.61 120.4,217.07 120.4,220.7 120.5,220.8 121.23,220.8
VGT_PWM1_LG_D on TOP (solid shape): 103.17,228.25 103.17,226.67 103,226.5 102.75,226.5 102.48,226.23 102.48,224.78 102.36,224.66 101.62,224.66 100.81,225.47 100.81,225.89 100.98,226.06 101.45,226.06 102.49,227.11 102.49,228.23 102.63,228.37 103.04,228.37
VGT_PWM1_LG_D on TOP (solid shape): 108.84,227.2 108.84,224.79 108.71,224.66 107.19,224.66 107.06,224.79 107.06,225.17 107.82,225.93 107.82,226.64 107.85,226.76 107.85,226.89 107.85,226.99 107.83,227.1 108.08,227.34 108.7,227.34
VGT_PWM1_SN on TOP (solid shape): 115.82,224.03 115.82,221.84 115.4,221.42 113.8,221.42 113.67,221.55 113.67,222.42 114.55,223.31 114.55,224.03 114.68,224.16 115.7,224.16
VGT_PWM1_SW_C on TOP (solid shape): 100.25,227.85 100.25,226.69 99.92,226.36 99.24,226.36 99.23,226.38 99,226.38 97.79,227.59 96.19,227.59 96.14,227.64 96.14,227.81 96.16,227.83 96.86,227.83 97.4,228.38 99.73,228.38
VGT_PWM1_SW_C on TOP (solid shape): 114.17,224.03 114.17,223.27 113.54,222.63 113.54,222.63 113.42,222.51 113.42,221.51 113.85,221.08 116.1,221.08 116.33,220.85 119.63,220.85 119.89,220.6 119.89,217.3 119.38,216.79 115.06,216.79 111.51,213.23 109.22,213.23 108.28,214.17 111.29,214.17 111.29,216.58 108.87,216.58 108.87,214.17 108.28,214.17 105.16,217.3 102.87,217.3 101.73,218.44 101.73,223.77 102.11,224.16 114.05,224.16
VGT_PWM1_SW_C on BOTTOM (solid shape): 114.17,224.03 114.17,223.27 113.54,222.63 113.54,221.74 114.05,221.23 115.95,221.23 116.33,220.85 117.22,220.85 118.12,219.95 119.59,219.95 119.8,219.74 119.8,217.21 119.38,216.79 115.06,216.79 111.51,213.23 109.22,213.23 108.37,214.08 111.38,214.08 111.38,216.67 108.78,216.67 108.78,214.08 108.37,214.08 105.16,217.3 102.87,217.3 101.85,218.31 101.85,223.77 102.23,224.16 114.05,224.16
VGT_PWM1_SW_C on VCC (solid shape): 115.82,224.03 115.82,221.49 115.84,221.39 115.9,221.31 116.28,220.93 116.36,220.87 116.46,220.85 119.76,220.85 119.89,220.73 119.89,217.28 119.4,216.79 115.19,216.79 115.09,216.77 115.01,216.71 111.53,213.23 109.2,213.23 105.21,217.22 105.13,217.28 105.03,217.3 102.85,217.3 101.73,218.42 101.73,223.8 102.09,224.16 115.7,224.16
VGT_PWM2_BOT_C on TOP (solid shape): 152.83,230.45 152.73,230.35 152.25,230.35 150.86,228.96 149.59,228.96 149.33,229.23 148.37,229.23 148.37,229.78 148.45,229.87 150.5,229.87 150.83,230.2 150.83,231.11 151.03,231.32 152.83,231.32
VGT_PWM2_BOTR_C on TOP (solid shape): 152.78,228.09 152.78,227.13 152.03,226.38 151.11,226.38 150.71,225.98 149.88,225.98 149.79,226.07 149.79,226.69 150.13,227.04 150.13,228.08 150.37,228.32 152.55,228.32
VGT_PWM2_HG_D on TOP (solid shape): 141.1,213.82 141.1,213.33 140.26,212.5 139.55,212.5 138.71,213.33 138.71,213.84 139.85,214.99 139.93,214.99
VGT_PWM2_HGR_D on TOP (solid shape): 143.64,219.79 143.64,216.51 142.01,214.88 141.99,214.88 141.81,214.71 141.69,214.71 140.68,215.72 140.68,215.89 141.91,217.12 141.91,220.68 142.75,220.68
VGT_PWM2_LG_D on TOP (solid shape): 130.08,227.25 130.08,224.77 129.97,224.66 128.8,224.66 128.42,225.04 128.42,225.65 129.21,226.44 129.21,226.95 129.56,227.3 130.03,227.3
VGT_PWM2_LG_D on TOP (solid shape): 123.7,228.14 123.7,224.81 123.57,224.69 122.17,224.69 122.03,224.83 122.03,225.27 122.89,226.13 122.89,227.86 123.22,228.18 123.66,228.18
VGT_PWM2_SN on TOP (solid shape): 137.29,223.9 137.29,222.28 137.29,222.28 137.29,221.74 136.91,221.36 135.18,221.36 135.05,221.49 135.05,222.38 135.76,223.09 135.76,224.03 137.16,224.03
VGT_PWM2_SW_C on TOP (solid shape): 148.12,227.42 148.17,227.37 148.17,227.14 148.42,226.9 149.09,226.9 149.17,226.82 149.17,226.01 149.12,225.96 148.21,225.96 147.78,226.39 147.78,227.35 147.85,227.42 147.85,227.87 148.12,227.87
VGT_PWM2_SW_C on TOP (solid shape): 135.25,224.03 135.25,222.88 134.82,222.45 134.82,221.28 135.26,220.85 137.67,220.85 137.79,220.73 137.97,220.73 141.1,220.73 141.35,220.47 141.35,217.3 140.97,216.92 137.41,216.92 133.86,213.36 130.68,213.36 129.87,214.17 133,214.17 133,216.58 130.59,216.58 130.59,214.17 129.87,214.17 127.13,216.92 123.95,216.92 121.92,218.95 121.92,221.4 121.92,223.9 122.17,224.16 135.13,224.16
VGT_PWM2_SW_C on BOTTOM (solid shape): 135.25,224.03 135.25,221.23 135.64,220.85 137.67,220.85 137.79,220.73 141.1,220.73 141.35,220.47 141.35,217.3 140.97,216.92 137.41,216.92 133.86,213.36 130.68,213.36 129.96,214.08 133.09,214.08 133.09,216.67 130.5,216.67 130.5,214.08 129.96,214.08 127.13,216.92 123.95,216.92 121.92,218.95 121.92,223.9 122.17,224.16 135.13,224.16
VGT_PWM2_SW_C on VCC (solid shape): 137.29,223.8 137.29,221.36 137.31,221.26 137.36,221.18 137.74,220.8 137.82,220.75 137.92,220.73 141.35,220.73 141.35,217.28 140.99,216.92 137.54,216.92 137.44,216.9 137.36,216.84 133.88,213.36 130.66,213.36 127.18,216.84 127.1,216.9 127,216.92 123.93,216.92 121.92,218.93 121.92,224.03 122.05,224.16 136.93,224.16
VGT_PWM2_VCC_C on TOP (solid shape): 147.11,229.85 147.11,229.22 147.03,229.22 147.01,229.21 146.2,229.21 145.54,228.55 145.54,227.05 145.44,226.95 144.98,226.95 144.93,227 144.93,229.77 145.14,229.97 146.99,229.97
VRM_PWM1_BOT_C on TOP (solid shape): 74.17,187.32 73.97,187.13 72.36,187.13 72.29,187.2 71.33,187.2 71.33,187.73 72.84,189.23 74.17,189.23
VRM_PWM1_BOTR_C on TOP (solid shape): 74.32,186.04 74.32,184.09 73.47,183.24 72.06,183.24 72.03,183.27 72.03,184.06 72.08,184.11 72.6,184.11 72.73,184.24 72.73,186.01 72.78,186.07 74.3,186.07
VRM_PWM1_HGR_D on TOP (solid shape): 65.13,183.17 65.08,183.11 63.56,183.11 62.82,182.37 61.93,182.37 61.82,182.48 61.82,183.93 61.9,184.01 63.01,184.01 63.7,184.71 65.13,184.71
VRM_PWM1_LG_D on TOP (solid shape): 70.05,185.43 69.63,185 68.55,185 68.55,185.9 70.05,185.9
VRM_PWM1_LG_D on TOP (solid shape): 66.24,175.95 66.24,173.99 65.94,173.69 64.62,173.69 64.52,173.79 64.52,175.9 64.52,176.28 64.64,176.4 65.79,176.4
VRM_PWM1_LG_D on TOP (solid shape): 59.94,176.28 59.94,174.16 59.52,173.74 58.8,173.74 58.67,173.86 58.67,174.24 58.31,174.61 58.31,176.29 58.42,176.4 59.82,176.4
VRM_PWM1_SN on TOP (solid shape): 67.8,173.75 67.8,173.06 68.61,172.25 68.61,171.72 68.47,171.58 65.84,171.58 65.73,171.68 65.73,172.23 66.25,172.75 66.25,173.64 66.58,173.97 67.58,173.97
VRM_PWM1_SW_C on TOP (solid shape): 61.19,183.89 61.19,182.25 61.58,181.86 62.99,181.86 63.88,182.75 68.71,182.75 70.61,180.85 70.61,172.36 70.48,172.23 69.49,172.23 68.11,173.6 68.11,174.16 67.8,174.47 67.03,174.47 66.8,174.7 66.8,176.15 66.47,176.48 69.77,176.48 69.77,178.9 67.35,178.9 67.35,176.48 66.47,176.48 66.02,176.93 54.77,176.93 54.51,177.2 54.51,181.73 54.48,181.76 54.48,183.51 54.97,184 61.09,184
VRM_PWM1_SW_C on BOTTOM (solid shape): 61.19,182.25 61.58,181.86 62.99,181.86 63.88,182.75 68.71,182.75 70.61,180.85 70.61,173.86 70.23,173.48 67.06,173.48 66.8,173.74 66.8,176.15 66.56,176.39 69.85,176.39 69.85,178.99 67.26,178.99 67.26,176.39 66.56,176.39 66.02,176.93 54.77,176.93 54.51,177.2 54.51,181.73 54.48,181.76 54.48,183.51 54.97,184 61.19,184
VRM_PWM1_SW_C on VCC (solid shape): 61.21,183.9 61.21,182.37 61.23,182.27 61.29,182.19 61.54,181.94 61.62,181.88 61.72,181.86 62.87,181.86 62.96,181.88 63.04,181.94 63.86,182.75 68.73,182.75 70.61,180.87 70.61,174.35 69.74,173.48 67.03,173.48 66.8,173.71 66.8,176.02 66.78,176.12 66.73,176.2 66.09,176.84 66.01,176.89 65.91,176.91 54.61,176.91 54.48,177.04 54.48,183.54 54.97,184.02 61.09,184.02
VRM_PWM2_BOT_C on TOP (solid shape): 70.36,206.04 70.36,205.36 70.1,205.1 69.18,205.1 68.58,205.7 67.68,205.7 67.62,205.76 67.62,206.23 67.71,206.31 68.5,206.31 68.75,206.56 68.75,206.76 68.87,206.88 69.52,206.88
VRM_PWM2_BOTR_C on TOP (solid shape): 70.38,202.87 70.38,201.7 69.62,200.94 68.5,200.94 68.49,200.95 68.03,200.95 67.82,201.17 67.82,202.44 68.07,202.69 68.71,202.69 68.96,202.95 70.31,202.95
VRM_PWM2_HGR_D on TOP (solid shape): 65.05,202.1 65.05,200.8 63.44,200.8 62.74,200.1 61.96,200.1 61.82,200.24 61.82,201.5 61.87,201.56 62.59,201.56 63.32,202.29 64.86,202.29
VRM_PWM2_LG_D on TOP (solid shape): 59.86,193.55 59.86,191.52 59.68,191.33 59.21,191.33 59.17,191.37 59.17,191.86 58.71,192.32 58.33,192.32 58.32,192.34 58.32,193.81 59.6,193.81
VRM_PWM2_LG_D on TOP (solid shape): 66.14,193.56 66.14,192.15 65.91,191.92 65.91,191.39 65.86,191.34 64.54,191.34 64.49,191.39 64.49,193.81 65.9,193.81
VRM_PWM2_LG_D on TOP (solid shape): 65.7,204.58 66.1,204.58 66.29,204.39 66.37,204.39 66.38,204.38 66.38,203.94 66.36,203.91 65.87,203.91 65.86,203.91 65.67,203.91 65.41,204.17 64.77,204.17 64.57,204.37 64.57,204.83 64.77,205.03 65.25,205.03
VRM_PWM2_SN on TOP (solid shape): 67.61,191.59 67.61,189.97 67.18,189.53 67.18,188.47 67.03,188.32 66.4,188.32 65.76,188.95 65.76,189.7 66.29,190.23 66.29,191.64 66.42,191.77 67.44,191.77
VRM_PWM2_SW_C on TOP (solid shape): 61.24,201.4 61.24,199.76 61.53,199.47 63.32,199.47 63.46,199.61 63.46,200.11 63.63,200.28 69.09,200.28 70.87,198.5 70.87,190.96 70.64,190.73 70.64,190.02 70.54,189.92 68.63,189.92 68.43,190.12 68.43,191.24 66.67,192.99 66.67,193.8 66.39,194.08 69.77,194.08 69.77,196.5 67.35,196.5 67.35,194.08 66.39,194.08 65.99,194.49 54.84,194.49 54.58,194.74 54.58,194.82 54.48,194.92 54.48,200.25 54.79,200.56 56.34,200.56 57.33,201.55 61.09,201.55
VRM_PWM2_SW_C on BOTTOM (solid shape): 56.02,201.54 56.65,201.54 56.67,201.55 61.09,201.55 61.24,201.4 61.24,199.76 61.53,199.47 63.32,199.47 63.46,199.61 63.46,200.11 63.63,200.28 69.09,200.28 70.48,198.88 70.48,192.66 70.38,192.56 67.13,192.56 66.67,193.01 66.67,193.8 66.48,194 69.85,194 69.85,196.59 67.26,196.59 67.26,194 66.48,194 65.99,194.49 54.84,194.49 54.58,194.74 54.58,194.82 54.48,194.92 54.48,201.17 54.54,201.22 54.55,201.2 54.58,201.15 54.63,201.11 54.67,201.08 54.72,201.05 54.78,201.03 54.83,201.02 54.89,201.01 54.95,201.02 55,201.03 55.05,201.05 55.11,201.08 55.15,201.11 55.19,201.15 55.23,201.19 55.26,201.24 55.28,201.3 55.29,201.35 55.3,201.41 55.29,201.47 55.28,201.52 55.28,201.55 56.01,201.55
VRM_PWM2_SW_C on VCC (solid shape): 61.34,201.55 61.34,200.03 61.36,199.93 61.42,199.85 61.67,199.59 61.75,199.54 61.85,199.52 62.74,199.52 62.84,199.54 62.92,199.59 63.61,200.28 69.11,200.28 70.61,198.78 70.61,192.89 70.25,192.53 66.91,192.53 66.67,192.76 66.67,193.68 66.66,193.77 66.6,193.85 66.09,194.36 66.01,194.42 65.91,194.44 54.61,194.44 54.48,194.56 54.48,201.32 54.84,201.68 61.21,201.68
VRM_PWM3_BOT_C on TOP (solid shape): 73.91,171.07 73.91,169.67 73.79,169.54 72.77,169.54 72.52,169.8 71.2,169.8 71.16,169.84 71.16,170.36 72.12,171.32 73.66,171.32
VRM_PWM3_BOTR_C on TOP (solid shape): 73.84,168.1 73.84,166.67 72.9,165.74 71.88,165.74 71.73,165.89 71.73,166.6 71.88,166.75 72.14,166.75 72.32,166.94 72.32,168.06 72.52,168.25 73.68,168.25
VRM_PWM3_HG_D on TOP (solid shape): 69.01,166.95 69.01,166.78 68.81,166.57 67.01,166.57 66.47,167.11 66.47,168.15 66.55,168.22 67.74,168.22
VRM_PWM3_HGR_D on TOP (solid shape): 65.13,168.12 65.13,165.79 65.08,165.74 63.43,165.74 62.67,164.99 62.01,164.99 61.88,165.12 61.88,166.39 62.03,166.54 62.05,166.53 62.77,166.53 63.37,167.13 63.37,167.97 63.65,168.25 65,168.25
VRM_PWM3_LG_D on TOP (solid shape): 66.12,158.36 66.12,156.34 65.99,156.21 64.64,156.21 64.55,156.31 64.55,158.74 65.74,158.74
VRM_PWM3_LG_D on TOP (solid shape): 59.76,158.42 59.76,156.59 59.32,156.16 58.88,156.16 58.26,156.78 58.26,158.66 58.32,158.72 59.45,158.72
VRM_PWM3_SN on TOP (solid shape): 67.82,156.23 67.82,154.1 67.77,154.05 65.8,154.05 65.74,154.11 65.74,154.52 66.33,155.12 66.33,155.77 66.55,155.99 66.55,156.27 66.69,156.4 67.65,156.4
VRM_PWM3_SW_C on TOP (solid shape): 61.34,166.37 61.34,164.85 61.72,164.47 62.87,164.47 62.91,164.51 63.25,164.51 63.96,165.22 68.08,165.22 70.36,162.94 70.36,156.92 70.7,156.59 70.7,155.05 70.47,154.82 69.42,154.82 69.09,155.16 69.09,155.77 68.01,156.85 67.23,156.85 66.93,157.15 66.93,158.88 67.35,158.88 69.77,158.88 69.77,161.29 67.35,161.29 67.35,158.88 66.93,158.88 66.55,159.26 66.55,159.26 66.42,159.38 54.74,159.38 54.47,159.65 54.47,166.23 54.86,166.62 61.09,166.62
VRM_PWM3_SW_C on BOTTOM (solid shape): 61.34,166.37 61.34,164.85 61.72,164.47 62.87,164.47 63.63,165.23 63.74,165.23 63.75,165.22 68.08,165.22 70.36,162.94 70.36,156.46 69.6,155.7 67.31,155.7 66.93,156.08 66.93,158.79 69.85,158.79 69.85,161.38 67.26,161.38 67.26,158.79 66.93,158.79 66.93,158.88 66.55,159.26 66.55,159.26 66.42,159.38 54.74,159.38 54.47,159.65 54.47,166.23 54.86,166.62 61.09,166.62
VRM_PWM3_SW_C on VCC (solid shape): 61.34,166.5 61.34,164.97 61.36,164.88 61.42,164.79 61.67,164.54 61.75,164.48 61.85,164.47 62.74,164.47 62.84,164.48 62.92,164.54 63.61,165.23 69.62,165.23 70.36,164.49 70.36,156.44 69.62,155.7 67.29,155.7 66.93,156.06 66.93,158.75 66.91,158.85 66.85,158.93 66.47,159.31 66.39,159.37 66.29,159.38 54.61,159.38 54.48,159.51 54.48,166.26 54.84,166.62 61.21,166.62
VRM_PWM4_BOT_C on TOP (solid shape): 75.23,153.59 75.23,152.86 75,152.62 73.05,152.62 72.87,152.8 71.93,152.8 71.9,152.83 71.9,153.27 71.94,153.31 72.21,153.31 72.29,153.38 72.29,153.59 72.47,153.77 75.06,153.77
VRM_PWM4_BOTR_C on TOP (solid shape): 74.93,151.24 74.93,149.33 73.86,148.26 72.74,148.26 72.67,148.34 72.67,149.73 72.8,149.86 72.96,149.86 73.46,150.36 73.46,151.18 73.66,151.38 74.79,151.38
VRM_PWM4_HG_D on TOP (solid shape): 72.95,150.85 72.95,150.6 72.75,150.39 72.39,150.39 71.93,150.85 71.93,151.33 72.06,151.46 72.34,151.46
VRM_PWM4_HGR_D on TOP (solid shape): 65.39,150.81 65.39,149.41 65.03,149.05 65.03,148.19 64.81,147.98 63.64,147.98 62.82,147.16 61.87,147.16 61.86,147.17 61.86,148.65 62.88,148.65 63.63,149.4 63.63,150.75 63.88,151 65.2,151
VRM_PWM4_LG_D on TOP (solid shape): 70.68,151.35 70.68,151.01 70.41,151.01 70.1,150.7 70.1,150.7 69.9,150.5 69.47,150.5 69.27,150.7 69.27,151.01 69.7,151.44 70.59,151.44
VRM_PWM4_LG_D on TOP (solid shape): 59.59,140.94 59.74,140.94 59.84,140.85 59.84,138.96 59.41,138.53 58.85,138.53 58.28,139.1 58.28,140.94 58.3,140.95 59.58,140.95
VRM_PWM4_LG_D on TOP (solid shape): 66.2,140.8 66.2,140.22 66.04,140.06 66.04,138.68 65.81,138.46 64.59,138.46 64.47,138.58 64.47,139.19 64.64,139.37 64.64,140.88 64.69,140.94 66.07,140.94
VRM_PWM4_SN on TOP (solid shape): 67.77,139.68 67.77,137.06 67.03,136.32 66.09,136.32 66.04,136.37 66.04,137.92 66.48,138.36 66.48,139.77 66.57,139.87 67.58,139.87
VRM_PWM4_SW_C on TOP (solid shape): 61.33,148.71 61.33,146.9 61.67,146.57 62.99,146.57 63.8,147.37 65.84,147.37 65.95,147.48 69.82,147.48 70.87,146.43 70.87,141.1 70.85,141.08 70.85,138.46 70.63,138.24 69.71,138.24 68.77,139.18 68.77,139.91 68.48,140.21 67,140.21 66.8,140.4 66.8,141.1 66.29,141.6 54.61,141.6 54.36,141.86 54.36,142.29 69.89,142.29 69.89,144.71 67.48,144.71 67.48,142.29 54.36,142.29 54.36,148.46 54.61,148.72 61.32,148.72
