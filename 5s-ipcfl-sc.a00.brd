# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAD_ESPI3: length 98.1
  TOP w0.102: SR83.1 160.13,24.16 159.33,23.36 158.19,23.36 157.7,22.87 v1(157.7,22.4) ; P118.8 196.2,10.1 196.11,10.19 v1(196.11,10.64) 198.26,12.79 198.26,17.31 195.82,19.74 195.82,28.16 195.22,28.75 v1(195.22,29.51) 195.22,30.21 195.52,30.51 196.57,30.51 197.82,29.26 197.82,25.52 198.65,24.69 198.65,23.28 200.81,21.13 203.85,21.13 204.61,20.37 210.65,20.37 211.68,21.4 211.68,22.38 212.94,23.63 U104.11
  BOTTOM w0.102: v1(196.11,10.64) 196.11,10.15 196.76,9.5 v2(197.26,9.5) ; v1(157.7,22.4) 157.88,22.57 161.33,22.57 161.75,23 166.47,23 166.88,23.41 171.59,23.41 172.93,24.75 173.93,24.75 176.42,27.24 178.48,27.24 180.4,29.16 184.85,29.16 185.84,30.15 193.41,30.15 193.76,30.49 194.25,30.49 v1(195.22,29.51)
LAN_ACT#: length 56.9
  TOP w0.203: v1(38.3,216.76) 38.16,216.62 U10.38 ; v1(26.64,225.43) 26.64,219.98 26.34,219.67 LC8.1 LC44.1 24.33,219.11 v1(24.33,218.9)
  TOP w0.254: J9.L1 27.25,198.03 UD8881.2 27.11,199.47 v1(26.77,199.47)
  BOTTOM w0.203: v1(38.3,216.76) 38.75,217.21 38.75,223.23 37.78,224.19 34.34,224.19 33.46,225.07 32.46,225.07 32.11,225.43 v2(28.32,225.43) v1(26.64,225.43)
  BOTTOM w0.254: v1(26.77,199.47) 27.95,200.65 27.95,206.14 30,208.18 30,210.57 26.44,214.12 26.44,216.79 v1(24.33,218.9)
LAN_CLKREQ#: length 21.5
  TOP w0.089: v1(170.64,42.49) 171.04,42.09 171.04,41.66 170.76,41.38 170.64,41.38 170.33,41.07 PCH.BD22
  TOP w0.102: SR18.1 168.86,28.08 168.94,28.16 168.94,30.71 170.38,32.15 171.29,32.15 v1(171.29,32.16)
  BOTTOM w0.102: v1(170.64,42.49) 170.31,42.49 170,42.81 169.54,42.81 169.28,42.55 169.28,41.37 170.15,40.49 170.15,38.76 171.48,37.44 v2(171.48,36.83) 171.48,32.34 v1(171.29,32.16)
LAN_CLKREQ#_R: length 7.2
  TOP w0.102: LR2.2 36.32,223.22 v1(36.32,222.3) 36.32,219.48 35.58,218.74 U10.4
  BOTTOM w0.102: v1(36.32,222.3) 35.94,222.68 v2(35.94,223.01)
LAN_CTR: length 14.3
  TOP w0.102: LC12.1 26.63,206.98 v1(26.61,207.01)
  BOTTOM w0.102: v1(26.61,207.01) 26.61,205.17 26.44,205 25.6,205 25.37,204.77 25.37,203.94 25.86,203.45 25.86,202.69 25.37,202.21 25.07,202.21 22.38,199.52 J9.R1
LAN_LED1: length 23.7
  TOP w0.203: LC7.1 41.14,218.57 39.24,218.57 37.7,217.02 U10.39
  TOP w0.254: MQ18.1 38.55,204.79 v1(40.91,207.15) ; LC7.1 LR9.1 42.85,212.14 v1(41.66,210.95)
  BOTTOM w0.254: v1(40.91,207.15) 41.07,207.31 41.07,208.84 v2(41.48,209.25) 41.48,210.77 v1(41.66,210.95)
LAN_LED1_R: length 21.5
  TOP w0.254: v1(26.62,204.33) 26.97,204.69 27.25,204.69 UD8878.2 28.04,204.28 28.04,204.39 28.33,204.69 31.79,204.69 32.43,205.32 LR5.2 34.31,205.32 34.72,205.74 MQ18.3
  BOTTOM w0.254: v1(26.62,204.33) 26.9,204.61 26.9,206.43 28.93,208.47 28.93,210.16 28.32,210.77 25.74,210.77 J9.L3
LAN_LED2: length 13.8
  TOP w0.203: U10.23 33.98,212.79 v1(34.92,211.84) LR10.1 35.48,210.43 35.48,208.84 35.31,208.66 33.4,208.66 32.84,208.1 32.21,208.1
  TOP w0.254: 32.21,208.1 31.62,208.1 30.65,207.12 LC6.1 31.2,206.2 LR4.1
  BOTTOM w0.102: v1(34.92,211.84) 36.02,211.84 v2(36.25,212.06)
LAN_LED2_R: length 19.2
  TOP w0.254: LR4.2 29.44,205.54 29.16,205.26 28.27,205.26 28.07,205.46 28.07,205.63 UD8880.1 27.27,205.26 26.77,205.26 25.88,204.37 v1(25.88,204.34)
  BOTTOM w0.254: J9.L4 26.14,211.15 28.51,211.15 29.36,210.3 29.36,208.38 27.3,206.32 27.3,204.24 26.85,203.78 26.39,203.78 25.88,204.29 v1(25.88,204.34)
LAN_MDI0_N: length 29.2
  TOP w0.091: v1(21.84,202.11) 21.82,202.13 21.41,202.13 21.18,202.36 21.18,211.38 22.28,212.48 22.28,214.13 22.65,214.5 24.4,214.5 25.2,215.3 M1U8.2 M1U8.9 25.2,216.75 26.25,217.8 31.56,217.8 32.33,217.02 U10.12
  BOTTOM w0.091: J9.R3 20.1,201.45 20.32,201.45 20.45,201.57 20.45,201.9 20.81,202.26 21.34,202.26 21.49,202.11 v1(21.84,202.11)
LAN_MDI0_P: length 29.2
  TOP w0.091: U10.11 32.43,217.42 31.7,218.15 26.1,218.15 24.85,216.9 24.85,216.7 24.7,216.55 M1U8.10 M1U8.1 24.7,215.31 24.26,214.86 22.5,214.86 21.92,214.27 21.92,212.63 20.82,211.53 20.82,202.22 v1(21.31,201.73)
  BOTTOM w0.091: v1(21.31,201.73) 21.13,201.9 20.95,201.9 20.8,201.75 20.8,201.19 21.21,200.79 J9.R2
LAN_MDI1_N: length 28.8
  TOP w0.091: v1(24.82,203.61) 24.51,203.91 24.51,204.6 23.8,205.31 23.8,212.68 24.35,213.23 26.26,213.23 26.59,213.57 26.59,215.24 26.7,215.35 M1U8.5 M1U8.6 26.7,216.54 26.87,216.71 27.54,216.71 28.22,216.03 31.62,216.03 31.83,215.82 U10.15
  BOTTOM w0.091: v1(24.82,203.61) 24.59,203.84 24.59,204.36 24.12,204.83 21.32,204.83 20.48,203.99 20.1,203.99 J9.R5
LAN_MDI1_P: length 28.8
  TOP w0.091: U10.14 32.32,216.22 32.28,216.18 31.98,216.18 31.77,216.38 28.37,216.38 27.69,217.07 26.49,217.07 26.2,216.78 M1U8.7 M1U8.4 26.2,215.3 26.24,215.27 26.24,213.72 26.11,213.59 24.21,213.59 23.44,212.83 23.44,205.16 24.16,204.45 v1(24.16,203.63)
  BOTTOM w0.091: v1(24.16,203.63) 24.23,203.71 24.23,204.22 23.98,204.47 21.46,204.47 20.73,203.73 20.73,203.5 20.9,203.33 J9.R4
LAN_MDI2_N: length 23.1
  TOP w0.091: v1(25.96,206.22) 25.83,206.35 25.83,208.87 26.19,209.22 26.19,211.41 27.09,212.31 27.54,212.31 27.62,212.23 M1U9.2 M1U9.9 28.95,212.23 29.03,212.32 29.54,212.32 29.87,212.65 29.87,213.35 29.44,213.78 29.44,214.3 29.62,214.48 30.43,214.48 30.97,213.94 31.67,213.94 32.35,214.62 U10.18
  BOTTOM w0.091: v1(25.96,206.22) 25.83,206.35 25.83,206.95 25.42,207.37 21.32,207.37 20.45,206.5 20.12,206.5 J9.R7
LAN_MDI2_P: length 23.1
  TOP w0.091: v1(25.32,206.22) 25.48,206.38 25.48,209.02 25.83,209.37 25.83,211.55 26.94,212.67 27.52,212.67 27.59,212.73 M1U9.1 M1U9.10 28.95,212.73 29.01,212.67 29.39,212.67 29.51,212.8 29.51,213.2 29.08,213.63 29.08,214.45 29.47,214.83 30.58,214.83 31.11,214.3 31.52,214.3 32.24,215.02 U10.17
  BOTTOM w0.091: v1(25.32,206.22) 25.48,206.38 25.48,206.81 25.27,207.01 21.46,207.01 20.83,206.38 20.83,205.99 20.96,205.87 J9.R6
LAN_MDI3_N: length 19.4
  TOP w0.091: v1(28.19,209.3) 28.02,209.47 28.02,209.78 27.29,210.51 27.29,210.69 27.41,210.82 27.59,210.82 27.68,210.73 M1U9.5 M1U9.6 28.72,210.79 29.56,210.79 30.78,212.01 32.48,212.01 33.18,212.71 U10.21
  BOTTOM w0.091: v1(28.19,209.3) 27.69,209.8 26.42,209.8 25.4,208.79 24.05,208.79 22.83,210.01 21.23,210.01 20.5,209.27 19.89,209.27 J9.R9
LAN_MDI3_P: length 19.4
  TOP w0.091: U10.20 32.61,213.61 32.82,213.39 32.82,212.86 32.33,212.37 30.63,212.37 29.41,211.15 28.74,211.15 M1U9.7 M1U9.4 27.62,211.23 27.56,211.18 27.27,211.18 26.93,210.84 26.93,210.37 27.66,209.64 27.66,209.42 v1(27.55,209.31)
  BOTTOM w0.091: J9.R8 21.06,208.41 20.83,208.64 20.83,209.1 21.38,209.65 22.68,209.65 23.9,208.43 25.54,208.43 26.56,209.45 27.41,209.45 v1(27.55,209.31)
LAN_RXN: length 272.7
  TOP w0.102: PCH.E19 168.96,59.98 168.96,59.83 169.15,59.64 169.39,59.64 169.54,59.79 v1(169.59,59.79) ; LC10.1 37.64,208.67 37.64,208.41 v1(37.34,208.1)
  BOTTOM w0.089: 170.08,61.29 170.1,61.26 170.1,60.68 169.83,60.4 169.83,60.03 v1(169.59,59.79)
  BOTTOM w0.102: 170.08,61.29 169.98,61.39 169.98,63.25 165.18,68.05 165.18,70.24 160.3,75.12 136.63,75.12 132.56,71.05 79.67,71.05 74.2,76.53 57.79,76.53 54.41,79.91 54.41,83.46 55.3,84.35 55.3,94.81 53.46,97.64 53.46,101.45 50.68,114.78 49.3,116.15 49.3,120.4 48.03,121.67 48.03,131.81 44.18,135.65 44.18,142.3 41.58,144.9 41.58,146.53 42.06,147.02 42.06,153.41 41.36,154.11 41.36,158.29 39.93,159.72 39.93,162.59 36.47,166.05 36.47,173.63 35.98,174.12 35.98,176.64 38.3,178.96 38.3,183.13 39.09,183.92 39.09,187.53 38,188.62 38,206.15 37.67,206.48 37.67,207.77 v1(37.34,208.1)
LAN_RXN_C: length 2.4
  TOP w0.102: U10.29 36.38,213 36.47,212.9 36.47,211.44 LC10.2
LAN_RXP: length 272.7
  TOP w0.102: v1(37.97,208.08) 37.85,208.2 37.85,208.76 36.75,209.86 36.75,209.96 LC9.1 ; PCH.G19 169.24,59.15 v1(169.61,59.15)
  BOTTOM w0.089: v1(169.61,59.15) 169.61,59.22 170,59.62 170,60.31 170.29,60.6 170.29,61.36 170.21,61.45
  BOTTOM w0.102: v1(37.97,208.08) 37.87,207.98 37.87,206.56 38.2,206.23 38.2,188.7 39.29,187.61 39.29,183.84 38.5,183.04 38.5,178.88 36.18,176.56 36.18,174.21 36.68,173.71 36.68,166.13 40.13,162.68 40.13,159.81 41.57,158.37 41.57,154.19 42.27,153.49 42.27,146.93 41.78,146.45 41.78,144.98 44.39,142.38 44.39,135.74 48.23,131.89 48.23,121.75 49.5,120.48 49.5,116.24 50.86,114.88 53.66,101.47 53.66,97.7 55.5,94.87 55.5,84.27 54.61,83.38 54.61,80 57.88,76.73 74.28,76.73 79.75,71.25 132.48,71.25 136.55,75.32 160.38,75.32 165.38,70.33 165.38,68.14 170.18,63.34 170.18,61.48 170.21,61.45
LAN_RXP_C: length 2.4
  TOP w0.102: U10.30 36.78,212.98 36.68,212.88 36.68,211.39 LC9.2
LAN_TXN: length 277.9
  TOP w0.089: PCH.B21 169.77,61.6 169.52,61.85 169.52,62.17 169.54,62.2 169.54,63.15 169.7,63.3
  TOP w0.102: v1(41.53,215.8) 41.43,215.7 41.03,215.7 LC48.1 ; v1(165.18,71.84) 165.4,72.06 166.6,72.06 168.32,70.34 168.55,70.34 169.67,69.21 169.67,67.77 169.77,67.67 169.77,63.38 169.7,63.3
  BOTTOM w0.102: v1(165.18,71.84) 164.73,72.29 164.12,72.29 160.6,75.82 136.36,75.82 132.28,71.74 79.95,71.74 74.47,77.22 60.06,77.22 59.36,77.92 59.36,78.66 58.34,79.67 58.34,80.66 58.65,80.97 58.65,82.16 58.42,82.39 58.42,82.62 57.68,83.36 57.37,83.36 56.57,84.16 56.57,95.76 54.74,97.59 54.74,111.7 49.99,116.45 49.99,130.85 44.87,135.96 44.87,142.59 42.75,144.71 42.75,153.71 42.05,154.41 42.05,158.57 40.61,160.01 40.61,162.88 37.19,166.31 37.19,173.98 36.66,174.5 36.66,176.34 38.99,178.66 38.99,182.7 40.06,183.77 40.06,192.88 38.73,194.2 38.73,206.81 40.26,208.34 40.26,215.45 40.61,215.8 v1(41.53,215.8)
LAN_TXN_C: length 2.7
  TOP w0.102: LC48.2 39.48,215.7 37.79,215.7 37.67,215.82 U10.36
LAN_TXP: length 277.8
  TOP w0.089: 169.98,63.29 169.72,63.04 169.72,62.03 PCH.A21
  TOP w0.102: 169.98,63.29 169.98,67.75 169.88,67.85 169.88,69.3 168.63,70.54 168.4,70.54 166.68,72.26 165.42,72.26 v1(165.19,72.5) ; LC47.1 41.03,215.49 41.17,215.49 v1(41.54,215.13)
  BOTTOM w0.102: v1(41.54,215.13) 41.14,214.73 41.05,214.73 40.98,214.8 40.98,215.51 40.89,215.6 40.7,215.6 40.46,215.36 40.46,208.26 38.94,206.73 38.94,194.28 40.26,192.96 40.26,183.68 39.19,182.62 39.19,178.58 36.87,176.26 36.87,174.59 37.39,174.07 37.39,166.4 40.82,162.97 40.82,160.09 42.25,158.66 42.25,154.5 42.95,153.8 42.95,144.8 45.07,142.67 45.07,136.05 50.19,130.93 50.19,116.54 54.94,111.79 54.94,97.67 56.77,95.84 56.77,84.25 57.45,83.57 57.76,83.57 58.62,82.7 58.62,82.47 58.85,82.25 58.85,80.88 58.55,80.58 58.55,79.76 59.56,78.74 59.56,78 60.14,77.42 74.56,77.42 80.04,71.94 132.19,71.94 136.28,76.02 160.68,76.02 164.21,72.5 v1(165.19,72.5)
LAN_TXP_C: length 2.7
  TOP w0.102: LC47.2 39.48,215.49 37.64,215.49 37.57,215.42 U10.35
LAN_WAKE#: length 374
  TOP w0.089: 163.7,38.4 163.7,38.52 164.24,39.06 164.24,39.46 164.14,39.63 164.14,39.83 164.16,39.93 PCH.BE10
  TOP w0.102: 163.7,38.4 163.7,37.93 162.88,37.11 162.88,36.89 160.27,34.28 160.27,33.61 159,32.34 159,31.57 v1(158.5,31.07) 158.87,30.71 158.89,30.71 SR365.2 ; LR6.1 v1(37.21,221.55)
  BOTTOM w0.102: v1(158.5,31.07) 158.5,30.76 157.93,30.19 157.18,30.19 156.95,30.42 152.82,30.42 152.52,30.12 149.67,30.12 146.39,26.84 138.57,26.84 135.13,23.4 132.39,23.4 131.17,22.17 129.31,22.17 128.19,21.06 97.11,21.06 96.44,21.73 96.44,22.43 95.38,23.5 95.38,24.09 94.79,24.68 35.89,24.68 31.57,29 31.57,36.44 23.94,44.07 23.94,57.63 22.39,59.18 22.39,113.22 22.11,113.5 22.11,119.3 23.89,121.08 23.89,123 24.35,123.46 24.35,124.63 24.18,124.79 24.18,126.76 25.06,127.64 25.06,136.03 24.4,136.68 24.4,137.97 21.95,140.42 21.95,142.51 23.13,143.69 23.13,148.2 23.37,148.44 23.37,150.09 24.07,150.79 24.07,154.8 18.88,159.98 18.88,174.64 20.86,176.62 21.85,176.62 23.37,178.13 23.37,193.73 30.09,200.45 30.09,202.17 31.51,203.59 31.51,211.33 28.32,214.52 28.32,217.44 26.95,218.82 v2(26.95,222.43) 26.95,223.98 27.45,224.49 29.95,224.49 30.86,223.57 36.35,223.57 37.21,222.71 v1(37.21,221.55)
LAN_XTAL_IN: length 10.2
  TOP w0.102: Y10.1 31.28,224.78 31.28,223.38 31.41,223.25 LC4.1 31.94,222.1 32.28,222.1 32.89,221.49 v1(32.89,220.68) 32.89,220.52 34.38,219.04 U10.7
  BOTTOM w0.102: v1(32.89,220.68) v2(32.89,219.96)
LAN_XTAL_OUT: length 6.8
  TOP w0.102: LR22.1 31.45,221.69 31.67,221.46 32,221.46 v1(32.13,221.34) 32.13,220.83 33.98,218.98 U10.8
  BOTTOM w0.102: v1(32.13,221.34) v2(31.5,221.97)
LAN_Y4_25M: length 4.3
  TOP w0.102: v1(28.96,221.69) LR22.2 29.97,222.03 29.97,222.24 LC5.1 30.37,223.66 Y10.3
  BOTTOM w0.102: v2(28.42,221.16) v1(28.96,221.69)
LANWAKE_N: length 3.5
  TOP w0.102: U10.3 35.98,218.55 36.8,219.38 v1(36.93,219.38) 37.21,219.66 LR6.2
  BOTTOM w0.102: v1(36.93,219.38) 37.21,219.38 v2(37.62,218.97)
LED_CTRL: length 487.7
  TOP w0.102: SR7702.2 196.49,42.57 v1(196.62,42.44) ; PCH.BB44 180.75,41.55 v1(180.62,41.68) ; v1(207.65,56.03) 208,56.03 210.25,53.78 212.45,53.78 215.13,51.1 221.03,51.1 222.39,49.75 224.07,49.75 226.91,52.59 226.91,66.79 228.07,67.95 228.07,70.72 230.38,73.03 230.38,82.91 234.69,87.22 237.61,87.22 238.86,87.23 240.37,88.74 240.37,112.86 v1(239.42,113.82) ; SR7703.1 v1(25.73,228.09)
  BOTTOM w0.102: v1(207.65,56.03) 207.65,52.45 203.68,48.49 203.68,46.04 202.2,44.55 198.73,44.55 v1(196.62,42.44) 195.44,41.26 193.26,41.26 193.06,41.47 190.31,41.47 190.09,41.68 v1(180.62,41.68) ; v1(25.73,228.09) v2(26.49,228.09) 27.81,229.41 34.2,229.41 39.66,234.87 39.66,237.2 42.5,240.04 48.2,240.04 49.59,238.65 61.39,238.65 62.47,239.73 78.87,239.73 79.17,239.42 82.21,239.42 83.39,240.6 156.07,240.6 157.31,239.36 157.31,235.33 162.23,230.42 168.1,230.42 172.9,235.21 172.9,236.76 176.13,239.98 207.21,239.98 208.54,238.66 213.77,238.66 218.52,233.91 226.14,233.91 228.38,231.67 232.66,231.67 233.91,230.43 236.5,230.43 240.08,226.85 240.08,217.37 239.36,216.65 239.36,212.97 236.52,210.13 236.52,205.03 236.18,204.68 236.18,199.3 236.7,198.78 236.7,149.62 235.84,148.75 235.84,144.6 236.75,143.69 236.75,138.74 238.2,137.28 238.2,114.45 238.84,113.82 v1(239.42,113.82)
LED_CTRL_1_C: length 27.3
  TOP w0.102: J9.L2 25.35,200.08 UD8879.2 27.33,200.65 v1(27.33,200.86) ; v1(24.77,217.68) 26.19,219.1 26.61,219.1 LR3.1
  BOTTOM w0.102: v1(24.77,217.68) 24.77,217.53 v2(25.53,216.76) 26.14,216.15 26.14,214.01 29.67,210.48 29.67,208.27 27.66,206.26 27.66,201.19 v1(27.33,200.86)
LED_CTRL_R1: length 4.3
  TOP w0.102: v1(26.43,229.63) SR7703.2
  TOP w0.254: MQ22.1 24.26,229.07 SC170.1 SR7703.2
  BOTTOM w0.102: v1(26.43,229.63) v2(25.67,229.63)
LED_CTRL_R2: length 5.1
  TOP w0.102: v1(21.06,229.24) v2(21.06,230.02)
  TOP w0.254: SR7705.2 SR7704.1 20.71,231.23 21.06,230.89 v2(21.06,230.02)
  BOTTOM w0.102: v1(21.06,229.24) v2(21.06,230.02)
LED_CTRL_R3: length 12
  TOP w0.254: MQ23.1 18.09,234.48 17.73,234.11 SR7706.2 SC172.2 15.84,233.42 15.65,233.22 15.65,231.29 16.55,230.39 v1(18.67,230.39) SR7704.2 SC171.1
  BOTTOM w0.102: v1(18.67,230.39) v2(18.67,229.62)
LFE: length 13.1
  TOP w0.254: AR208.1 17.58,64.62 v1(17.58,64.26) ; v1(16.59,59.11) 16.59,57.35 14.47,55.23 AC168.2
  BOTTOM w0.254: v1(16.59,59.11) 16.97,59.49 16.97,62 17.58,62.61 v1(17.58,64.26)
LFE_B: length 48
  TOP w0.254: AL5.2 17.48,68.33 AC177.1 17.23,69.06 17.26,69.09 AD17.1 17.26,70.09 16.9,70.45 16.9,83.68 v1(17.32,84.1)
  BOTTOM w0.254: v1(17.32,84.1) 17.32,85.01 17.88,85.57 17.88,87.06 19.87,89.05 19.87,103.3 19.05,104.13 19.05,110.91 J83.45
LFE_C: length 55.2
  TOP w0.254: AC168.1 11.34,53.73 9.23,51.63 9.23,48.43 10.41,47.24 12.3,47.24 13.43,46.11 13.43,40.36 16.08,37.7 16.08,31.84 12.55,28.3 v1(12.55,27.1) ; v1(14.15,14.35) 15.04,14.35 16.75,12.64 AU1.44
  BOTTOM w0.254: v1(12.55,27.1) 12.43,27.22 11.78,27.22 11.4,26.84 11.4,25.83 10.97,25.4 10.97,18.11 10.83,17.97 v2(10.83,17.09) 10.83,16.77 13.02,14.58 13.92,14.58 v1(14.15,14.35)
LFE_MUTE: length 3.2
  TOP w0.254: AQ1.5 14.86,62.87 15.19,62.53 15.19,61.98 v1(15.32,61.85) 15.32,61.35 AR62.2
  BOTTOM w0.254: v2(15.88,61.29) v1(15.32,61.85)
LFE_R: length 5.4
  TOP w0.254: AQ1.3 16.81,64.08 v1(16.39,64.5) 16.08,64.81 AR208.2 AR206.1 16.08,66.75 16.14,66.81 AL5.1
  BOTTOM w0.254: v2(16.39,65.66) v1(16.39,64.5)
LFRAME#_ESPI_CS0#: length 20.8
  TOP w0.089: PCH.BF14 166.12,39.88 166.12,39.58 166.03,39.49 166.03,38.77 165.86,38.61 165.86,38.2 166.09,37.97
  TOP w0.102: SR84.2 159.72,24.5 159.72,25.68 160.07,26.04 160.07,26.3 160.38,26.6 160.38,27.13 160.63,27.39 160.63,28.04 161.02,28.44 161.02,29.51 161.91,30.4 161.91,32.22 162.88,33.19 163.56,33.19 163.73,33.02 164.21,33.02 165.63,34.45 v1(165.63,34.57) 166.24,35.18 166.24,37.82 166.09,37.97
  BOTTOM w0.102: v1(165.63,34.57) 165.15,34.09 v2(165.05,34.09)
LINE1-L: length 68.5
  TOP w0.254: AC165.2 6.15,28.98 v1(4.29,30.84) ; v1(13.46,74.17) 13.46,75.44 15.29,77.26 15.29,84.76 16.53,86 17.42,86 17.82,86.4 AR209.2
  BOTTOM w0.254: v1(13.46,74.17) 13.17,73.88 11.07,73.88 v2(10.07,72.88) 8.5,71.31 8.5,70.64 7.08,69.22 6.31,69.22 4.48,67.39 4.23,67.39 3.45,66.61 3.45,59.78 3.45,31.68 v1(4.29,30.84)
LINE1-L_C: length 11.8
  TOP w0.254: v1(7.44,23.16) 9.08,21.53 13.27,21.53 13.75,21.05 AU1.23
  BOTTOM w0.254: AC165.1 7.44,24.88 v1(7.44,23.16)
LINE1-R: length 76.3
  TOP w0.254: AC166.2 4.81,22.52 3.61,23.72 v1(3.61,26.42) ; AR210.2 16.72,85.47 15.79,84.55 15.79,76.88 14.22,75.31 v1(14.22,74.17)
  BOTTOM w0.254: v1(14.22,74.17) 14.22,74.55 13.97,74.8 13.18,74.8 12.77,74.39 10.74,74.39 7.6,71.25 v2(7.6,70.89) 7.6,70.53 6.79,69.72 6.09,69.72 4.27,67.89 4.02,67.89 2.95,66.82 2.95,59.99 2.95,31.47 4.19,30.23 4.51,30.23 4.89,29.85 4.89,29.34 3.61,28.06 v1(3.61,26.42)
LINE1-R_C: length 8.1
  TOP w0.254: AU1.24 13.25,20.83 13.06,21.02 AC166.1
LINE1_JD: length 96.6
  TOP w0.254: v1(4.39,29.64) 4.39,27.56 5.16,26.8 5.16,25.4 5.49,25.07 7.14,25.07 8.18,26.11 13.49,26.11 14.61,27.23 17.03,27.23 AR15.2
  BOTTOM w0.254: v1(4.39,29.64) 3.9,29.64 2.44,31.11 2.44,57.5 2.44,60.2 2.44,60.21 2.44,87.07 2.77,87.4 3.18,87.4 5.98,90.2 6.77,90.2 8.19,91.62 8.19,92.72 10.11,94.64 16.01,94.64 J83.33
LINE1_L: length 5.9
  TOP w0.254: J83.32 17.92,92.54 AD19.1 17.92,89.55 17.74,89.37 AC179.1 18.07,88.67 AL4.1
LINE1_L_B: length 2.7
  TOP w0.254: v1(16.32,86.74) AR209.1 16.98,87.34 16.73,87.59 AL4.2
  BOTTOM w0.254: v1(16.32,86.74) 16.32,86.04 v2(16.38,85.98)
LINE1_R: length 14.1
  TOP w0.254: J83.35 18.52,99.44 18.52,92.4 19.88,91.05 AD3.1 19.88,89.45 19.98,89.34 AC180.1 19.98,88.9 19.56,88.48 AL6.1
LINE1_R_B: length 2.7
  TOP w0.254: AL6.2 19.56,86.41 v1(19.04,85.89) 18.75,85.89 AR210.1
  BOTTOM w0.254: v2(19.04,86.65) v1(19.04,85.89)
LINE2-L: length 54.7
  TOP w0.254: AR7.1 21.44,8.56 v1(20.7,7.82) ; ACE7.2 16.24,53.07 v1(13.97,50.8)
  BOTTOM w0.254: v1(13.97,50.8) v2(13.97,49.56) 13.97,42.5 15.5,40.97 15.5,36.87 15.88,36.5 15.88,33.35 15.7,33.18 15.7,28.53 16.32,27.92 16.32,12.36 17.61,11.06 17.61,9.61 19.4,7.82 v1(20.7,7.82)
LINE2-L_C: length 36
  TOP w0.254: AU1.14 18.25,21.17 v1(18.41,21.34) ; v1(15.75,50.8) 17.35,50.8 17.58,50.57 ACE7.1
  BOTTOM w0.254: v1(15.75,50.8) 15.85,50.7 15.85,42.96 17.93,40.87 17.93,33.5 v2(18.03,33.4) 18.52,32.92 18.52,29.31 19,28.83 19,25.95 19.68,25.27 19.68,22.61 v1(18.41,21.34)
LINE2-L_MUTE: length 3.6
  TOP w0.254: AQ18.5 12.52,58.48 12.7,58.66 12.7,59.33 v1(12.9,59.54) 12.9,60.06 AR204.2
  BOTTOM w0.254: v2(12.57,60.35) 12.9,60.02 v1(12.9,59.54)
LINE2-R: length 49.8
  TOP w0.254: ACE4.2 16.28,43.69 v1(16.28,39.95) ; v1(26.54,9.78) 26.54,9.72 AR8.1
  BOTTOM w0.254: v1(16.28,39.95) 16.1,39.78 16.1,37.06 16.38,36.78 16.38,33.14 16.21,32.97 16.21,28.74 16.83,28.13 16.83,12.57 18.12,11.28 18.12,9.82 19.57,8.37 20.94,8.37 21.93,7.38 22.8,7.38 25.2,9.78 v2(25.63,9.78) v1(26.54,9.78)
LINE2-R_C: length 25.2
  TOP w0.254: v1(19.05,22.86) 19.05,22.35 18.54,21.84 18.03,21.84 17.74,21.55 17.74,21.5 17.75,21.49 AU1.15 ; v1(17.77,32.13) 17.77,42.69 ACE4.1
  BOTTOM w0.254: v1(19.05,22.86) 19.05,24.38 v2(18.49,24.94) 18.49,28.62 18.01,29.1 18.01,31.9 v1(17.77,32.13)
LINE2-R_MUTE: length 5.1
  TOP w0.254: v1(15.2,58.2) 14.91,58.48 AQ18.2 ; AR203.2 v1(14.35,61.13)
  BOTTOM w0.254: v1(15.2,58.2) 14.35,59.04 v2(14.35,60.17) v1(14.35,61.13)
LINE2_JD: length 25.1
  TOP w0.254: AR25.2 7.7,11.73 v1(7.75,11.68)
  BOTTOM w0.254: 27.81,3.05 22.91,3.05 20.27,5.69 18.52,5.69 17.02,7.19 15.42,7.19 14.88,7.72 13.89,7.72 13.79,7.62 11.42,7.62 9.62,9.42 8.89,9.42 7.75,10.57 v2(7.75,10.87) v1(7.75,11.68)
LINE2_L_C: length 5.3
  TOP w0.254: 27.81,5.59 27.6,5.8 27.6,7.13 27.65,7.18 AC74.1 26.43,8.97 26.11,8.97 25.94,8.8 AL18.2
LINE2_R_C: length 5.1
  TOP w0.254: AL17.2 30.57,8.39 30.44,8.27 AC75.1 30.44,7.28 31.11,6.6 31.88,6.6 P23.5
LP1+: length 14.4
  TOP w0.102: UL66.1 26.54,182.02 26.39,182.17 25.65,182.17 25.53,182.04 M1U4.9 M1U4.2 24.31,182.04 24.16,182.19 22.63,182.19 21.81,183.01 16.83,183.01 15.77,184.07 15.77,184.37 15.15,184.99 14.71,184.99 14.61,184.89 J10.23
LP1-: length 14.4
  TOP w0.102: UL66.4 26.53,182.57 26.33,182.37 25.7,182.37 25.54,182.54 M1U4.10 M1U4.1 24.32,182.54 24.17,182.39 22.71,182.39 21.89,183.21 16.91,183.21 15.97,184.15 15.97,184.45 15.23,185.19 14.95,185.19 14.61,185.53 J10.22
LP2+: length 19.4
  TOP w0.102: J10.13 11.99,184.92 12.14,185.06 12.52,185.06 13.1,184.48 13.1,181.63 14.24,180.49 22.51,180.49 22.71,180.69 24.16,180.69 24.31,180.54 M1U4.5 M1U4.6 25.52,180.54 25.68,180.7 26.37,180.7 26.54,180.52 UL65.1
LP2-: length 19.4
  TOP w0.102: J10.12 11.99,185.38 12.1,185.27 12.6,185.27 13.3,184.56 13.3,181.71 14.32,180.7 22.43,180.7 22.62,180.89 24.17,180.89 24.32,181.04 M1U4.4 M1U4.7 25.54,181.04 25.68,180.9 26.37,180.9 26.54,181.07 UL65.4
LP3+: length 12.2
  TOP w0.102: UL67.1 26.52,185.32 26.34,185.5 25.68,185.5 25.51,185.32 M1U5.9 M1U5.2 24.3,185.32 24.15,185.47 23.11,185.47 21.51,187.07 19.31,187.07 18.66,186.43 18.66,185.88 17.89,185.1 17.53,185.1 17.23,184.8 J10.33
LP3-: length 12.2
  TOP w0.102: J10.32 17.23,185.42 17.34,185.31 17.8,185.31 18.46,185.96 18.46,186.51 19.22,187.27 21.6,187.27 23.2,185.67 24.18,185.67 24.33,185.82 M1U5.1 M1U5.10 25.56,185.82 25.68,185.7 26.34,185.7 26.52,185.87 UL67.4
LP4+: length 8.3
  TOP w0.102: J10.43 19.85,184.9 19.99,185.04 21.49,185.04 22.56,183.97 24.18,183.97 24.33,183.82 M1U5.5 M1U5.6 25.53,183.82 25.68,183.97 26.32,183.97 26.56,183.74 URN140.2
LP4-: length 8.4
  TOP w0.102: URN140.4 26.57,184.39 26.36,184.17 25.68,184.17 25.53,184.32 M1U5.7 M1U5.4 24.35,184.32 24.21,184.17 22.64,184.17 21.58,185.24 19.99,185.24 19.85,185.38 J10.42
LP5+: length 24.1
  TOP w0.102: UL8.1 29.59,195.23 29.39,195.43 28.85,195.43 28.69,195.27 M1U3.6 M1U3.5 27.75,195.27 27.61,195.4 22.8,195.4 19.98,198.22 18.64,198.22 17.02,199.85 17.02,201.46 15.49,203 14.17,203 13.39,203.78 13.39,204.46 12.72,205.13 12.2,205.13 12.05,204.98 J9.U3
LP5-: length 24.1
  TOP w0.102: UL8.4 29.59,195.78 29.44,195.63 28.85,195.63 28.72,195.77 M1U3.7 M1U3.4 27.74,195.77 27.58,195.61 22.89,195.61 20.07,198.42 18.73,198.42 17.22,199.93 17.22,201.55 15.57,203.2 14.26,203.2 13.59,203.87 13.59,204.55 12.8,205.33 12.15,205.33 12.05,205.43 J9.U2
LP6+: length 19.9
  TOP w0.102: UL7.1 29.59,196.75 29.41,196.93 28.92,196.93 28.76,196.77 M1U3.9 M1U3.2 27.72,196.77 27.56,196.93 24.05,196.93 20.19,200.79 18.76,200.79 18.08,201.46 18.08,202.16 15.11,205.13 14.82,205.13 14.67,204.98 J9.U7
LP6-: length 19.9
  TOP w0.102: UL7.4 29.59,197.3 29.41,197.13 28.88,197.13 28.74,197.27 M1U3.10 M1U3.1 27.72,197.27 27.58,197.13 24.14,197.13 20.28,200.99 18.85,200.99 18.29,201.55 18.29,202.24 15.2,205.33 14.8,205.33 14.67,205.46 J9.U6
LP7+: length 8.6
  TOP w0.102: UL64.1 231.21,107.16 230.86,106.81 230.86,106.65 231.12,106.39 231.98,106.39 232.28,106.69 UU4.6 UU4.5 233.32,106.69 233.49,106.52 233.98,106.52 236.44,105.19 237.02,105.19 237.13,105.3 P24.5
LP7-: length 8.7
  TOP w0.102: UL64.4 230.66,106.57 231.04,106.19 UU4.7 UU4.4 233.29,106.19 233.41,106.31 233.93,106.31 236.39,104.99 237.02,104.99 237.13,104.89 P24.7
LP9+: length 10.8
  TOP w0.102: P150.2 239.12,135.43 239,135.31 234.37,135.31 234.03,135.65 UU5.10 UU5.1 231.52,135.65 230.53,134.65 230.53,134.21 230.36,134.04 UL74.1
LP9-: length 10.8
  TOP w0.102: P150.4 239.12,134.95 238.97,135.1 234.29,135.1 233.95,135.44 233.77,135.44 233.47,135.15 UU5.9 UU5.2 232.44,135.15 232.15,135.44 231.61,135.44 230.73,134.57 230.73,134.21 230.91,134.04 UL74.4
LP10+: length 23.8
  TOP w0.102: J133.43 20.24,129.03 20.11,129.16 19.97,129.16 18.88,128.07 18.35,128.07 17.38,127.1 16.6,127.1 15.77,127.94 15.02,127.94 13.08,126 13.03,125.61 13.19,125.17 13.74,124.61 14.59,124.61 15.86,123.96 18.99,120.88 19.43,120.44 19.43,120.01 19.59,119.84 M1U7.1 M1U7.10 19.59,118.9 19.44,118.75 19.44,118.67 19.56,118.54 21.27,118.54 21.79,118.02 UL10.2
LP10-: length 23.8
  TOP w0.102: J133.42 20.24,129.51 20.09,129.36 19.89,129.36 18.8,128.27 18.26,128.27 17.3,127.3 16.69,127.3 15.85,128.14 14.94,128.14 12.89,126.1 12.82,125.59 13.01,125.06 13.66,124.41 14.54,124.41 15.74,123.8 18.85,120.73 19.23,120.35 19.23,120.02 19.09,119.88 M1U7.2 M1U7.9 19.09,118.85 19.23,118.72 19.23,118.58 19.48,118.34 21.18,118.34 21.36,118.16 21.36,118.05 21.24,117.93 UL10.3
LP11+: length 8.3
  TOP w0.102: P150.3 237.13,133.53 237,133.4 234.78,133.4 234.18,134.01 233.58,134.01 233.44,134.15 UU5.7 UU5.4 232.42,134.15 232.31,134.04 231.97,134.04 231.75,133.82 231.75,133.37 232.23,132.88 232.23,132.66 232.01,132.44 URN144.2
LP11-: length 8.3
  TOP w0.102: URN144.4 232.66,132.47 232.44,132.69 232.44,132.97 231.95,133.45 231.95,133.73 232.05,133.83 232.28,133.83 232.47,133.65 UU5.5 UU5.6 233.44,133.65 233.6,133.8 234.09,133.8 234.7,133.2 237,133.2 237.13,133.07 P150.5
LP12+: length 28.5
  TOP w0.102: UL9.2 13.24,118.49 13.07,118.31 12.29,118.31 12.18,118.43 11.88,118.43 11.73,118.58 M1U6.2 M1U6.9 10.75,118.58 10.57,118.39 9.67,118.39 6.91,121.15 6.91,125.27 9.09,127.46 9.09,129.35 9.73,129.99 9.73,130.35 10.31,130.94 10.95,130.94 11.76,130.12 12.61,130.12 13.44,130.96 14.12,130.96 15.01,130.07 15.64,130.07 16.5,129.21 17.14,129.21 17.27,129.08 17.27,128.38 J133.33
LP12-: length 28.5
  TOP w0.102: J133.32 17.04,129.51 16.94,129.41 16.59,129.41 15.72,130.28 15.1,130.28 14.21,131.17 13.36,131.17 12.52,130.33 11.84,130.33 11.03,131.14 10.23,131.14 9.53,130.44 9.53,130.07 8.89,129.44 8.89,127.54 6.71,125.36 6.71,121.07 9.59,118.19 10.62,118.19 10.73,118.08 M1U6.10 M1U6.1 11.73,118.08 11.87,118.22 12.1,118.22 12.21,118.11 13.06,118.11 13.23,117.94 UL9.3
LP13+: length 14.4
  TOP w0.102: UL22.1 231.6,104.83 231.83,105.05 232.15,105.05 232.29,105.19 UU4.9 UU4.2 234.19,105.19 236.18,103.2 237.58,103.2 238.02,103.64 238.02,106.96 238.26,107.19 239.02,107.19 239.12,107.3 P24.4
LP13-: length 14.3
  TOP w0.102: UL22.4 232.15,103.53 231.8,103.88 231.8,104.74 231.91,104.85 232.13,104.85 232.29,104.69 UU4.10 UU4.1 233.29,104.69 233.59,104.99 234.1,104.99 236.09,103 237.67,103 238.23,103.56 238.23,106.88 238.34,106.99 239.02,106.99 239.12,106.89 P24.6
LP14+: length 25.5
  TOP w0.102: UL75.2 21.17,114.88 21.08,114.79 20.93,114.79 17.96,117.76 17.96,118.75 18.09,118.88 M1U7.7 M1U7.4 18.09,119.88 17.96,120.01 17.96,120.35 17.48,120.83 13.41,120.83 11.61,122.63 11.61,123.3 9.86,125.05 9.86,126.03 11.77,127.94 12.27,127.94 13.56,129.23 13.95,129.23 14.17,129.01 14.17,128.48 J133.23
LP14-: length 25.5
  TOP w0.102: J133.22 13.84,129.53 13.74,129.43 13.47,129.43 12.18,128.14 11.68,128.14 9.65,126.11 9.65,124.97 11.4,123.22 11.4,122.55 13.33,120.62 17.39,120.62 17.75,120.26 17.75,120.04 17.59,119.88 M1U7.5 M1U7.6 17.59,118.91 17.75,118.74 17.75,117.68 20.85,114.58 20.95,114.58 21.2,114.33 UL75.3
M_CHA_ACT#: length 57.8
  TOP w0.102: XU1.AU24 141,165.29 141.1,165.19 146.95,165.19 147.24,165.48 147.32,165.48
  TOP w0.159: 174.74,178.44 175.29,178.44 175.51,178.22 177.41,178.22 CON_XMM3.62 177.75,178.57 180.06,178.57 180.08,178.59 180.09,178.59 180.29,178.79 180.81,178.79 181.09,179.07 181.94,179.07 182.2,178.81 183.15,178.81 183.41,178.54 183.81,178.54 183.94,178.42 183.94,178.29 184.07,178.17 184.22,178.17 184.35,178.29 184.35,178.42 184.47,178.54 184.65,178.54 184.8,178.4 CON_XMM1.62
  TOP w0.203: 147.32,165.48 154.83,165.48 159.47,170.12 159.87,170.12 160.08,170.33 160.08,170.75 161.78,172.44 162.04,172.44 162.47,172.01 162.65,172.01 163.01,172.37 163.01,172.55 162.54,173.02 162.54,173.2 163.17,173.84 163.46,173.84 163.82,173.47 164.11,173.47 164.51,173.87 164.51,174.15 164.14,174.52 164.14,174.81 164.54,175.2 164.82,175.2 165.19,174.84 165.48,174.84 165.87,175.23 165.87,175.52 165.51,175.88 165.51,176.17 167.21,177.88 167.51,177.88 167.86,177.52 168.16,177.52 168.36,177.72 168.36,177.99 167.94,178.41 167.94,178.61 168.19,178.86 172.81,178.86 173.22,178.44 174.74,178.44
M_CHA_ALERT#: length 58.4
  TOP w0.102: 146.98,164.31 146.33,164.31 145.93,163.92 143.44,163.92 143.07,164.29 142.54,164.29 142.32,164.5 140.78,164.5 140.44,164.84 XU1.AT23
  TOP w0.159: 175.02,176.52 176.27,176.52 176.47,176.32 176.98,176.32 177.28,176.02 177.87,176.02 178.72,176.87 181.2,176.87 CON_XMM3.208 181.55,176.52 184.03,176.52 184.56,176 185.74,176 186.44,176.7 CON_XMM1.208
  TOP w0.203: 146.98,164.31 148.79,164.31 149.01,164.1 156.61,164.1 156.83,164.31 156.83,165.09 156.63,165.3 156.63,165.65 159.05,168.07 160.31,168.07 160.4,167.98 161.11,167.98 163.04,169.91 163.04,170.76 167.07,174.79 168.53,174.79 169.25,175.51 169.25,176.1 170.1,176.95 174.56,176.95 175,176.51 175.01,176.51 175.02,176.52
M_CHA_BA0: length 55.6
  TOP w0.102: XU1.AY13 145.32,155.7 147.32,153.71
  TOP w0.159: CON_XMM3.81 176.15,156.98 177.86,156.98 178.09,156.75 179.15,156.75 179.43,156.47 180.1,156.47 180.61,156.98 182.01,156.98 182.27,156.72 183.32,156.72 CON_XMM1.81
  TOP w0.203: CON_XMM3.81 174.98,157.15 174.91,157.08 173.34,157.08 171.46,155.2 167.04,155.2 166.78,154.94 166.78,154.51 165.91,153.64 165.38,153.64 165.25,153.52 165.25,151.92 164.8,151.46 164.41,151.46 163.98,151.89 163.55,151.89 163.37,151.71 163.37,150.23 163.15,150.01 162.72,150.01 162.51,150.23 162.51,151.74 162.33,151.92 161.82,151.92 161.64,151.74 161.64,150.23 161.43,150.01 160.99,150.01 160.78,150.23 160.78,151.76 160.6,151.94 160.15,151.94 159.97,151.76 159.97,150.27 159.79,150.09 156.67,150.09 155.68,151.08 155.68,151.78 155.51,151.94 154.82,151.94 153.47,153.29 147.74,153.29 147.32,153.71
M_CHA_BA1: length 57.9
  TOP w0.102: 147.17,154.56 144.76,156.97 143.4,156.97 143.18,157.19 142.6,157.19 142.26,157.53 XU1.AV15
  TOP w0.159: 174.94,158.27 175.61,158.27 175.71,158.17 176.27,158.17 176.51,158.4 177.02,158.4 177.29,158.68 178.52,158.68 179.2,158 CON_XMM3.224 181.55,158.17 184.04,158.17 184.61,158.73 186.06,158.73 186.79,158 CON_XMM1.224
  TOP w0.203: 147.17,154.56 147.36,154.56 147.87,154.05 154.69,154.05 155.02,153.72 155.02,153 155.19,152.82 155.55,152.82 155.73,153 155.73,153.59 155.91,153.77 156.34,153.77 156.51,153.59 156.51,151.59 156.69,151.41 157.12,151.41 157.3,151.59 157.3,152.69 157.47,152.86 164.08,152.86 164.52,153.3 164.52,153.91 164.99,154.38 165.6,154.38 166.04,154.82 166.04,155.43 166.55,155.94 171.15,155.94 173.24,158.02 173.53,158.02 173.78,158.27 174.94,158.27
M_CHA_BG0: length 55.6
  TOP w0.102: XU1.AW23 143.21,164.84 143.73,164.32 145.27,164.32 145.8,164.85 146.94,164.85 147.18,165.09 147.32,165.09
  TOP w0.159: CON_XMM3.63 176.15,177.71 177.86,177.71 178.06,177.91 179.18,177.91 179.49,178.22 180.06,178.22 180.31,177.98 180.83,177.98 181.09,177.72 181.91,177.72 182.21,178.02 183.27,178.02 CON_XMM1.63
  TOP w0.203: 147.32,165.09 149.21,165.09 149.43,164.86 149.85,164.86 150.08,165.09 150.7,165.09 150.92,164.87 151.23,164.87 151.45,165.09 151.88,165.09 152.11,164.86 152.48,164.86 152.7,165.09 153.06,165.09 153.29,164.86 153.63,164.86 153.86,165.09 154.17,165.09 154.41,164.85 154.74,164.85 159.58,169.68 159.88,169.68 160.65,168.92 160.95,168.92 161.2,169.17 161.2,169.48 160.47,170.22 160.47,170.52 160.69,170.75 161,170.75 161.79,169.96 162,169.96 162.3,170.26 162.3,170.54 161.63,171.21 161.63,171.51 161.87,171.75 162.21,171.75 162.47,171.49 162.65,171.49 163.51,172.35 163.51,172.83 163.78,173.1 164.26,173.1 164.87,173.71 164.87,174.29 165.05,174.47 165.63,174.47 166.29,175.13 166.29,175.72 166.43,175.86 167.02,175.86 168.73,177.57 168.73,178.33 168.89,178.49 172.41,178.49 172.92,177.97 174.93,177.97 175.36,177.55 CON_XMM3.63
M_CHA_BG1: length 56.5
  TOP w0.102: XU1.AV23 142.29,164.84 142.63,164.5 143.16,164.5 143.54,164.12 145.58,164.12 146,164.54 146.8,164.54 146.88,164.62 147.04,164.62 147.12,164.7 147.32,164.7
  TOP w0.159: CON_XMM1.207 184.74,177.55 184.06,176.86 183.42,176.86 183.06,177.22 181.92,177.22 181.76,177.37 179.95,177.37 CON_XMM3.207 179.5,177.27 178.02,177.27 177.92,177.37 177.27,177.37 176.98,177.09 176.5,177.09 176.27,176.86 175.68,176.86 175.49,177.05 175.12,177.05
  TOP w0.203: 147.32,164.7 149.05,164.7 149.28,164.48 154.95,164.48 155.27,164.8 155.6,164.8 155.92,164.48 156.23,164.48 156.45,164.69 156.45,164.94 156.06,165.32 156.06,165.63 158.87,168.44 159.23,168.44 159.35,168.57 159.35,168.92 159.57,169.13 159.87,169.13 160.06,168.95 160.06,168.59 160.21,168.44 160.46,168.44 160.54,168.36 160.95,168.36 161.6,169.01 161.6,169.39 161.79,169.59 162.18,169.59 162.67,170.08 162.67,170.93 169.87,178.12 171.92,178.12 172.52,177.52 174.65,177.52 175.12,177.05
M_CHA_CKE0: length 44.3
  TOP w0.102: 147.32,166.29 146.62,165.59 144.14,165.59 143.97,165.76 XU1.AY24
  TOP w0.159: 147.32,166.29 147.35,166.32 154.49,166.32 168.52,180.35 174.52,180.35 174.65,180.22 174.65,180 174.52,179.88 174.49,179.88 174.37,179.75 174.37,179.53 174.49,179.41 175.14,179.41 175.66,179.92 176.72,179.92 177.23,179.41 177.89,179.41 178.14,179.66 178.57,179.66 178.69,179.79 178.69,179.97 178.57,180.09 177.58,180.09 CON_XMM3.60
M_CHA_CKE1: length 45.1
  TOP w0.102: 147.32,166.7 146.41,165.8 144.23,165.8 143.93,166.09 143.16,166.09 XU1.AW24
  TOP w0.159: CON_XMM3.203 179.15,180.31 178.97,180.31 178.7,180.58 178.7,180.8 178.57,180.92 178.23,180.92 178.08,180.77 177.29,180.77 177.05,180.54 176.54,180.54 176.27,180.26 175.59,180.26 175.03,180.82 168.42,180.82 156.41,168.81 155.95,168.81 155.65,168.51 155.65,168.1 155.42,167.87 155.01,167.87 154.64,167.5 154.64,167.03 154.36,166.75 147.37,166.75 147.32,166.7
M_CHA_CKE2: length 56.4
  TOP w0.102: 147.32,165.89 146.82,165.39 142.28,165.39 XU1.AV24
  TOP w0.159: CON_XMM1.60 185.95,180.1 186.82,179.22 186.82,178.39 186.62,178.18 186.29,178.18 186.15,178.32 186.15,179.03 185.86,179.32 185.04,179.32 184.68,179.67 184.3,179.67 184.05,179.92 183.46,179.92 183.19,179.66 182.35,179.66 182.11,179.41 181.1,179.41 180.83,179.68 180.3,179.68 180.06,179.92 179.42,179.92 178.57,179.07 177.2,179.07 176.31,178.56 175.7,178.56 175.32,178.94 174.18,178.94 174,179.12 173.15,179.12 172.38,179.88 168.62,179.88 154.65,165.91 147.35,165.91 147.32,165.89
M_CHA_CKE3: length 57.5
  TOP w0.102: XU1.AV25 142.3,166.29 144.01,166.29 144.31,166 146.27,166 147.32,167.04
  TOP w0.159: CON_XMM1.203 188.31,180.95 188.44,180.82 188.44,180.25 188.31,180.12 187.07,180.12 186.87,180.32 186.87,181.04 186.69,181.22 186.18,181.22 185.84,180.88 184.82,180.88 184.2,180.26 183.21,180.26 182.7,180.77 180.91,180.77 180.05,181.64 179.31,181.64 179.03,181.36 178.12,181.36 177.88,181.11 177.3,181.11 177.03,181.38 176.52,181.38 176.28,181.62 175.49,181.62 174.99,182.12 169.14,182.12 156.24,169.21 155.78,169.21 153.72,167.16 147.43,167.16 147.32,167.04
M_CHA_CLK0: length 43.9
  TOP w0.102: XU1.AW18 142.98,160.43 143.34,160.43 143.54,160.62 144.53,160.62 144.73,160.43 145.04,160.43 145.24,160.62 145.44,160.62 145.63,160.43 145.63,160.29 145.35,160.02 145.35,159.58 145.57,159.36 146.28,159.36 146.38,159.26 146.38,159.07 146.6,158.85 146.9,158.85 146.95,158.79 146.99,158.79 147.05,158.73 147.32,158.73
  TOP w0.165: CON_XMM3.74 177.01,168.2 176.8,167.98 176.8,167.8 177.04,167.56 177.04,166.95 176.47,166.38 175,166.38 174.97,166.35
  TOP w0.198: 147.32,158.73 162.05,158.73 167.24,163.92 167.96,163.92 168.58,163.3 170.71,163.3 171.76,164.35 171.76,164.97 171.17,165.56 171.17,165.79 171.72,166.35 174.97,166.35
M_CHA_CLK0#: length 43.9
  TOP w0.102: 147.32,159.05 146.69,159.05 146.58,159.15 146.58,159.34 146.36,159.56 145.66,159.56 145.55,159.66 145.55,159.93 145.83,160.21 145.83,160.52 145.52,160.83 145.15,160.83 144.96,160.63 144.81,160.63 144.62,160.83 143.45,160.83 143.26,160.64 142.64,160.64 142.27,160.27 XU1.AV18
  TOP w0.165: 174.87,166.65 174.91,166.65 174.91,166.64 176.36,166.64 176.78,167.06 176.78,167.44 176.58,167.64 176.27,167.64 CON_XMM3.75
  TOP w0.198: 174.87,166.65 171.6,166.65 170.87,165.92 170.87,165.43 171.46,164.84 171.46,164.47 170.59,163.6 168.7,163.6 168.08,164.22 167.11,164.22 161.93,159.03 147.34,159.03 147.32,159.05
M_CHA_CLK1: length 45.1
  TOP w0.102: XU1.AW17 142.87,159.36 143.07,159.55 143.07,159.67 143.29,159.89 144.05,159.89 144.2,159.74 144.86,159.74 146.59,158.01 147.32,158.01
  TOP w0.165: 180.39,168.35 180.55,168.2 CON_XMM3.218
  TOP w0.198: 147.32,158.01 147.34,157.99 162.64,157.99 167.09,162.45 171.32,162.45 172.22,163.34 174.78,163.34 177.1,165.65 178.06,165.65 178.3,165.89 178.3,167.87 178.78,168.35 180.39,168.35
M_CHA_CLK1#: length 45.1
  TOP w0.102: XU1.AY17 143.46,159.36 143.32,159.5 143.32,159.62 143.39,159.69 143.97,159.69 144.12,159.54 144.78,159.54 146.51,157.81 147.15,157.81 147.27,157.69 147.32,157.69
  TOP w0.165: 180.26,168.03 180.39,167.9 180.39,167.51 180.22,167.35 CON_XMM3.219
  TOP w0.198: 180.26,168.03 178.89,168.03 178.6,167.75 178.6,165.77 178.19,165.35 177.22,165.35 174.91,163.04 172.34,163.04 171.44,162.15 167.22,162.15 162.76,157.69 147.32,157.69
M_CHA_CLK2: length 54.9
  TOP w0.102: XU1.AW16 142.51,158.44 142.44,158.52 142.44,158.68 142.56,158.8 143.64,158.8 144.07,158.8 144.2,158.93 144.75,158.93 147.04,156.64 147.18,156.64
  TOP w0.165: 184.17,166.36 184.87,167.06 184.87,167.93 185.14,168.2 CON_XMM1.74
  TOP w0.198: 147.18,156.64 147.2,156.66 163.35,156.66 165.31,158.61 169.89,158.61 173.26,161.98 175.41,161.98 177.36,163.93 180.3,163.93 180.81,164.43 180.81,165.14 181.03,165.36 181.45,165.36 181.64,165.18 181.64,163.92 182,163.56 183.38,163.56 183.69,163.87 183.69,164.43 182.92,165.21 182.92,166.04 183.24,166.36 184.17,166.36
M_CHA_CLK2#: length 54.8
  TOP w0.102: XU1.AV16 142.06,158.44 142.21,158.6 142.21,158.74 142.47,159 143.73,159 143.98,159 144.11,159.13 144.83,159.13 147.01,156.95 147.32,156.95
  TOP w0.165: CON_XMM1.75 184.26,167.85 184.43,167.85 184.58,167.7 184.58,167.15 184.09,166.66 184.07,166.66
  TOP w0.198: 184.07,166.66 183.12,166.66 182.62,166.17 182.62,165.08 183.39,164.31 183.39,164 183.26,163.86 182.13,163.86 181.94,164.05 181.94,165.3 181.58,165.66 180.9,165.66 180.51,165.27 180.51,164.56 180.18,164.23 177.23,164.23 175.28,162.28 173.13,162.28 169.76,158.91 165.18,158.91 163.23,156.95 147.32,156.95
M_CHA_CLK3: length 56.9
  TOP w0.102: XU1.AT16 140.41,158.44 140.92,157.94 141.48,157.94 141.56,157.86 145.09,157.86 147.32,155.63
  TOP w0.165: 186.66,166.32 186.69,166.34 187.95,166.34 188.67,167.07 188.67,167.72 CON_XMM1.218
  TOP w0.198: 186.66,166.32 186.46,166.12 186.46,164.39 184.54,162.47 177.59,162.47 176.04,160.92 173.68,160.92 170.14,157.39 165.94,157.39 164.14,155.59 147.36,155.59 147.32,155.63
M_CHA_CLK3#: length 56.9
  TOP w0.102: XU1.AU16 141,158.24 141.07,158.17 141.58,158.17 141.68,158.06 145.17,158.06 147.24,156 147.27,156 147.29,156.02
  TOP w0.165: CON_XMM1.219 187.55,167.99 187.84,168.28 188.23,168.28 188.41,168.1 188.41,167.18 187.85,166.63 186.58,166.63
  TOP w0.198: 186.58,166.63 186.54,166.63 186.16,166.25 186.16,164.52 184.42,162.77 177.47,162.77 175.92,161.22 173.55,161.22 170.02,157.69 165.82,157.69 164.02,155.89 147.49,155.89 147.36,156.02 147.29,156.02
M_CHA_CS#0: length 45.7
  TOP w0.102: XU1.AW12 143.18,154.43 144.07,154.43 144.28,154.23 145.48,154.23 147.31,152.39
  TOP w0.159: 147.31,152.39 147.61,152.09 148.24,152.09 148.44,151.89 149.02,151.89 149.22,152.09 152.98,152.09 156.61,148.46 165.71,148.46 166.38,149.13 166.6,149.13 167.25,148.48 167.55,148.48 167.96,148.89 167.96,149.07 167.25,149.78 167.25,150.01 167.61,150.36 167.83,150.36 168.55,149.65 168.9,149.65 169.2,149.95 169.2,150.3 168.48,151.01 168.48,151.24 171.09,153.85 171.35,153.85 171.48,153.72 171.48,153.34 171.63,153.19 172.61,153.19 173.32,153.9 174.18,153.9 175.18,154.89 175.19,154.89 175.2,154.9 175.46,154.9 175.61,154.74 176.61,154.74 176.75,154.6 CON_XMM3.84
M_CHA_CS#1: length 47
  TOP w0.102: XU1.AU11 141,153.19 142.43,151.76 143.64,151.76
  TOP w0.159: CON_XMM3.89 174.75,150.35 169.44,145.03 162.15,145.03 161.95,144.83 161.95,144.49 161.76,144.3 161.49,144.3 161.32,144.48 161.32,144.83 161.11,145.03 160.66,145.03 160.56,144.93 160.56,144.23 160.4,144.07 160.06,144.07 159.9,144.23 159.9,144.91 159.77,145.03 159.37,145.03 159.24,144.91 159.24,144.23 159.07,144.07 158.74,144.07 158.58,144.23 158.58,144.91 158.45,145.03 158.05,145.03 157.92,144.91 157.92,144.23 157.75,144.07 157.42,144.07 157.26,144.23 157.26,144.91 157.13,145.03 156.44,145.03 152.46,149.02 148.05,149.02 145.3,151.76 143.64,151.76
M_CHA_CS#2: length 56.3
  TOP w0.102: XU1.AV13 142.37,155.25 142.37,154.73 142.79,154.31 142.95,154.31 143.03,154.23 143.98,154.23 144.19,154.02 145.3,154.02 147.31,152.01
  TOP w0.159: CON_XMM1.84 184.89,154.14 184.54,154.14 184.26,154.43 183.18,154.43 182.94,154.19 181.94,154.19 181.67,153.92 181.07,153.92 180.56,154.43 179.04,154.43 178.48,153.86 176.89,153.86 176.31,154.44 175.66,154.44 174.69,153.47 173.46,153.47 172.53,152.54 171.71,152.54 171.32,152.93 170.75,152.93 170.27,152.46 170.27,152.24 170.9,151.61 170.9,151.29 170.57,150.96 170.24,150.96 169.62,151.58 169.4,151.58 169.11,151.3 169.11,150.95 169.87,150.19 169.87,149.89 167.97,147.98 161.69,147.98 161.41,147.7 161.06,147.7 160.78,147.98 159.79,147.98 159.57,147.75 159.33,147.75 159.11,147.98 158.14,147.98 157.86,147.7 157.61,147.7 157.33,147.98 156.51,147.98 152.81,151.69 152.35,151.69 152.15,151.49 151.59,151.49 151.38,151.69 150.72,151.69 150.52,151.49 150.06,151.49 149.86,151.69 149.39,151.69 149.19,151.49 147.84,151.49 147.31,152.01
M_CHA_CS#3: length 53.9
  TOP w0.102: 145.04,151.13 141.37,151.13 XU1.AV10
  TOP w0.159: CON_XMM1.89 184.27,149.82 184.27,149.63 184.05,149.41 183.33,149.41 182.57,150.18 180.96,150.18 180.33,149.55 179.51,149.55 178.65,148.69 177,148.69 176.28,147.97 173.78,147.97 170.05,144.23 167.77,144.23 167.54,144.01 167.54,143.36 167.39,143.21 167.08,143.21 166.9,143.39 166.9,144.07 166.74,144.23 166.29,144.23 166.17,144.11 166.17,143.36 166.03,143.22 165.53,143.22 165.35,143.4 165.35,143.69 165.2,143.85 164.74,143.85 164.62,143.72 164.62,143.38 164.45,143.22 157.11,143.22 152.13,148.2 147.97,148.2 145.04,151.13
M_CHA_DQ0: length 100.6
  TOP w0.102: 177.09,227.2 177.24,227.05 178.02,227.05 178.3,227.33 ; 185.06,227.04 184.51,227.59 184.51,227.69 184.29,227.9 183.17,227.9 182.93,227.66 182.63,227.66 182.4,227.9 182.05,227.9 181.85,227.69 CON_XMM3.148 ; 185.06,227.04 184.9,226.88 184.64,226.88 184.02,227.49 183.42,227.49 183.31,227.39 ; 185.06,227.04 186.17,227.04 186.83,227.69 CON_XMM1.148 ; XU1.AE38 130.03,178.83 129.67,179.19 129.67,180.75 129.34,181.09 129.34,181.23 128.96,181.61
  TOP w0.159: 128.96,181.61 128.39,181.61 125.8,184.2 125.8,194.38 148.31,216.89 149.68,216.89 150.49,217.7 152.88,220.09 152.88,220.09 155.25,222.45 167.62,222.45 169.92,224.75 172.79,224.75 175.56,227.52 176.39,227.52 176.95,227.34 177.09,227.2 ; 183.31,227.39 183.1,227.17 182.03,227.17 181.65,227.01 180.87,227.01 180.62,227.1 180.5,227.23 180.05,227.52 178.91,227.52 178.3,227.33
M_CHA_DQ1: length 101.7
  TOP w0.102: CON_XMM3.3 176.44,228.08 176.87,228.08 177.32,228.52 178.51,228.52 179.17,229.18 179.54,229.18 179.67,229.32 180.28,229.32 181.06,228.55 CON_XMM1.3 ; 128.97,181.1 129.46,180.62 129.46,178.95 129.65,178.76 129.65,178.03 XU1.AE37
  TOP w0.159: 179.67,229.32 178.66,230.34 177.2,230.34 176.35,229.49 175.18,229.49 174.77,229.09 174.57,229.09 174.39,228.9 174.39,228.55 174.57,228.37 174.75,228.37 174.93,228.19 174.93,227.79 173.85,226.71 172.83,226.71 172.67,226.54 172.67,225.52 172.53,225.38 171.52,225.38 171.37,225.53 171.37,226.11 171.2,226.29 170.57,226.29 170.43,226.15 170.43,225.55 170.26,225.38 169.66,225.38 167.37,223.09 154.38,223.09 153.52,222.22 153.52,221.62 149.41,217.52 148.04,217.52 125.16,194.64 125.16,184.46 128.52,181.1 128.97,181.1
M_CHA_DQ2: length 99.9
  TOP w0.102: XU1.AG38 132.19,178.89 132.19,180.61 132.03,180.77 132.03,181.5 130.48,183.04 130.48,183.08 ; CON_XMM1.12 184.06,221.09 183.42,221.09 181.6,221.54 181.12,221.54 181.04,221.48 ; CON_XMM3.12 177.89,221.06 178.64,221.06 178.74,221.16 178.74,221.51 178.84,221.61 178.99,221.61 179.11,221.5 179.11,221.36 179.37,221.1 180.08,221.1 180.42,221.44 181,221.44 181.04,221.48 ; 178.96,220.76 179.1,220.9 180.58,220.9 180.7,220.98 180.81,221.26 180.95,221.4 181.04,221.48
  TOP w0.159: 130.48,183.08 129.93,183.63 129.93,192.58 149.82,212.47 151.65,212.47 155.24,216.05 158.04,216.05 158.2,215.89 158.2,213.86 158.37,213.7 158.67,213.7 158.86,213.89 158.86,215.89 159.03,216.05 159.76,216.05 159.86,215.95 159.86,214.11 160.06,213.91 160.33,213.91 160.49,214.07 160.49,215.84 160.66,216 161.02,216 161.2,215.82 161.2,213.88 161.36,213.72 163.92,213.72 164.46,214.26 164.46,214.9 164.74,215.19 166.1,215.19 166.31,215.4 166.31,216.1 166.8,216.59 167.51,216.59 170.25,219.32 171.49,219.32 171.65,219.15 171.65,218.92 171.83,218.74 172.34,218.74 172.91,219.32 174.79,219.32 175.08,219.62 175.42,219.62 175.67,219.37 176.28,219.37 177.12,220.21 177.86,220.21 178.03,220.38 178.58,220.38 178.96,220.76
M_CHA_DQ3: length 100.7
  TOP w0.102: 130.72,183.21 132.31,181.63 132.31,180.81 132.39,180.73 132.39,178.71 132.33,178.65 132.33,178.12 XU1.AG37 ; 183.31,220.69 183.31,220.52 182.66,219.87 182.66,219.76 182.51,219.61 182.14,219.61 181.86,219.89 180.81,219.89 180.65,220.05 CON_XMM3.157 ; 183.31,220.69 182.42,220.69 181.97,220.24 181.1,220.24 180.91,220.43 180.3,220.43 180.07,220.66 180.05,220.66 180.01,220.69 179.48,220.69 179.45,220.66 179.44,220.66 179.28,220.51 ; 183.31,220.69 183.89,220.69 184.97,220.31 185.93,220.11 186.56,220.05 CON_XMM1.157
  TOP w0.159: 130.72,183.21 130.56,183.37 130.56,192.32 150.08,211.84 151.92,211.84 153.16,213.08 153.87,213.08 154.03,213.24 154.03,213.95 154.29,214.21 154.52,214.21 154.69,214.04 154.69,213.26 154.88,213.06 155.26,213.06 155.42,213.23 155.42,215.25 155.59,215.42 155.92,215.42 156.08,215.25 156.08,213.23 156.25,213.06 156.58,213.06 156.74,213.23 156.74,215.2 156.91,215.37 157.24,215.37 157.4,215.2 157.4,213.23 157.57,213.06 164.87,213.06 165.18,213.37 165.18,213.92 165.5,214.24 166.06,214.24 170.41,218.59 170.87,218.59 171.42,218.03 172.59,218.03 173.24,218.68 175.12,218.68 175.46,219.02 176.45,219.02 177.3,219.87 177.86,219.87 178.05,219.68 178.8,219.68 179.04,219.93 179.04,220.27 179.28,220.51
M_CHA_DQ4: length 99.1
  TOP w0.102: 128.39,182.37 128.52,182.25 129.16,182.25 130.07,181.33 130.07,180.96 130.36,180.68 130.36,180.17 130.03,179.84 XU1.AE39 ; CON_XMM3.150 181.57,226.19 182.14,226.19 182.4,225.93 182.78,225.93 183.03,226.19 184.23,226.19 184.49,225.94 184.49,225.91 185.07,225.32 ; 185.07,225.32 184.94,225.19 184.64,225.19 184.03,225.79 183.43,225.79 183.3,225.67 ; 185.07,225.32 185.09,225.34 186.25,225.34 186.9,226 CON_XMM1.150
  TOP w0.159: 183.3,225.67 183.14,225.5 181.9,225.5 181.72,225.32 181.03,225.32 180.86,225.49 180.41,225.49 180.07,225.82 179.48,225.82 179.16,225.51 178.07,225.51 177.87,225.31 177.29,225.31 177.05,225.54 176.55,225.54 176.27,225.82 175.7,225.82 173.37,223.49 170.44,223.49 168.14,221.2 166.9,221.2 165.52,219.81 163.93,219.81 163.56,220.18 163.29,220.45 158.14,220.45 157.89,220.7 157.4,220.7 157.13,220.43 156.73,220.43 156.57,220.6 156.57,220.99 156.4,221.16 156.01,221.16 155.83,220.98 155.83,220.66 155.66,220.5 155.09,220.5 154.15,219.56 151.02,216.43 151.02,216.43 150.21,215.62 149.68,215.62 149.16,215.62 148.89,215.62 127.07,193.8 127.07,183.7 128.39,182.37
M_CHA_DQ5: length 98.1
  TOP w0.102: 177.09,226.47 177.27,226.64 177.85,226.64 178.45,226.04 179.2,226.04 179.41,226.25 ; 129.03,181.99 129.66,181.36 129.66,181.07 130.03,180.7 XU1.AE40 ; 179.41,226.25 179.47,226.19 179.92,226.19 181.13,226.64 183.16,226.64 CON_XMM1.5 ; 179.41,226.25 179.12,226.54 179.12,226.77 179.04,226.85 178.93,226.85 178.85,226.77 178.85,226.58 178.75,226.49 178.62,226.49 178.53,226.58 178.53,226.86 178.44,226.95 178.33,226.95 178.22,226.85 CON_XMM3.5
  TOP w0.159: 129.03,181.99 128.4,181.99 126.43,183.95 126.43,194.11 148.58,216.26 149.42,216.26 149.95,216.26 150.76,217.06 155.51,221.82 156.72,221.82 157.2,221.34 157.56,221.34 158.04,221.82 158.56,221.82 158.72,221.66 158.72,221.25 158.88,221.09 159.48,221.09 159.64,221.25 159.64,221.66 159.8,221.82 160.43,221.82 160.55,221.69 160.55,221.27 160.72,221.11 161.1,221.11 161.26,221.27 161.26,221.62 161.47,221.82 161.9,221.82 162.07,221.65 162.07,221.25 162.23,221.09 162.73,221.09 162.9,221.25 162.9,221.65 163.06,221.82 163.7,221.82 163.88,221.64 163.88,221.02 164.14,220.75 164.38,220.75 164.59,220.97 164.59,221.65 164.76,221.82 165.09,221.82 165.28,221.64 165.28,221.03 165.4,220.9 165.66,220.9 165.84,221.08 165.84,221.62 166.05,221.82 167.88,221.82 170.18,224.12 173.11,224.12 175.26,226.27 175.59,226.27 175.69,226.17 176.27,226.17 176.41,226.31 176.94,226.31 177.09,226.47
M_CHA_DQ6: length 98.6
  TOP w0.102: CON_XMM1.10 184.74,222.6 184.44,222.79 183.61,222.79 182.64,222.92 181.97,223.02 181.56,223.24 180.97,223.24 ; 180.97,223.24 180.5,223.24 180.06,222.8 179.5,222.8 179.12,223.18 179.12,223.37 179.03,223.46 178.89,223.46 178.8,223.36 178.8,223.07 178.64,222.92 178.34,222.92 178.22,222.79 178.22,222.74 178.07,222.6 CON_XMM3.10 ; 180.97,223.24 180.97,223.16 180.8,222.99 180.8,222.92 180.48,222.6 178.64,222.6 178.53,222.49 ; XU1.AG39 131.51,179.82 131.51,181.35 130.87,181.99
  TOP w0.159: 130.87,181.99 130.6,181.99 128.66,183.93 128.66,193.11 149.37,213.83 151.21,213.83 154.71,217.32 160.74,217.32 160.91,217.49 160.91,218.53 161.1,218.72 161.4,218.72 161.54,218.58 161.54,217.49 161.71,217.32 162.07,217.32 162.23,217.49 162.23,218.53 162.41,218.71 162.69,218.71 162.87,218.53 162.87,216.56 163,216.43 163.34,216.43 163.5,216.6 163.5,217.77 163.67,217.93 163.97,217.93 164.14,217.77 164.14,217.06 164.3,216.9 164.58,216.9 164.77,217.09 164.77,217.8 165.15,218.18 167.02,218.18 167.23,218.39 167.23,218.67 167.13,218.77 167.13,219.07 167.54,219.48 168.62,219.48 171.01,221.86 174.9,221.86 175.64,222.61 176.47,222.61 177.15,221.93 177.98,221.93 178.53,222.49
