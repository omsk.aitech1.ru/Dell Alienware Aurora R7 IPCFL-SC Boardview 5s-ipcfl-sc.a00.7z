# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE12_TXN_C: length 8.8
  TOP w0.102: SLOT3.B28 74.45,38.75 74.65,38.96 74.65,43.01 75.45,43.82 75.45,44.59 74.88,45.16 74.88,45.35 SC163.2
PE12_TXP: length 175.6
  TOP w0.102: PCH.B33 176.04,61.64 176.04,62.68 178.28,64.92 178.28,69.39 183.44,74.55 186.27,74.55 188.56,76.84 188.56,82.24 187.43,83.38 187.43,84.62 178.48,93.57 177.6,93.57 175.59,95.57 158.1,95.57 155.78,93.25 146.19,93.25 137.59,84.65 137.59,77.82 121.83,62.06 110.97,62.06 110.61,61.7 110.61,61.55 v1(111.05,61.11) ; v1(89.67,60.4) 89.9,60.17 89.9,58.74 81.28,50.11 77.46,50.11 74.75,47.4 74.75,46.98 SC159.1
  BOTTOM w0.102: v1(89.67,60.4) 90.02,60.75 90.02,60.96 90.26,61.2 94.83,61.2 95.46,61.83 110.34,61.83 v1(111.05,61.11)
PE12_TXP_C: length 8.8
  TOP w0.102: SC159.2 74.67,45.3 74.67,45.08 75.25,44.5 75.25,43.9 74.45,43.1 74.45,39.04 74.32,38.91 74.12,38.91 74.02,39.01 74.02,39.12 SLOT3.B27
PE16_A6_SLOT1: length 1.9
  TOP w0.102: XR8.2 50.45,85.44 SLOT1.A6
PE16_A6_SLOT4: length 1.8
  TOP w0.102: SLOT4.A6 50.45,24.54 50.8,24.89 XR16.2
PE16_A8_SLOT1: length 1.8
  TOP w0.102: XR9.2 52.45,85.76 SLOT1.A8
PE16_A8_SLOT4: length 1.7
  TOP w0.102: SLOT4.A8 52.45,24.77 52.2,25.02 XR12.2
PE16_TCK_SLOT1: length 7.4
  TOP w0.102: SLOT1.A5 49.45,82.06 48.36,80.98 48.36,79.53 49.2,78.69 49.2,77.94 48.35,77.09 XR10.1
PE16_TCK_SLOT4: length 4
  TOP w0.102: XR14.1 50.09,25.26 50.09,24.54 49.72,24.17 49.72,23.38 49.45,23.11 SLOT4.A5
PE16_TRST#_SLOT1: length 4
  TOP w0.102: SLOT1.B9 53.45,79.76 53.45,78 54.32,77.13 XR5.2
PE16_TRST#_SLOT4: length 5
  TOP w0.102: SLOT4.B9 53.45,16.4 53.7,16.15 XR13.2
PE17_RXN: length 118.7
  TOP w0.102: v1(216.99,12.96) 217.2,12.76 217.2,12.05 217.11,11.96 SS4.43 ; v1(179.27,57.3) 179.27,57.54 PCH.J41
  BOTTOM w0.102: 217.05,11.54 217.05,12.91 v1(216.99,12.96) ; 217.05,11.54 v2(216.75,11.54) ; 217.05,11.54 217.05,10.56 217.65,9.96 225.33,9.96 227.76,12.39 227.76,14.91 227.38,15.29 227.38,16.18 228.78,17.58 228.78,18.97 229.63,19.82 229.63,22.38 230.99,23.74 230.99,28.84 229.64,30.18 229.64,31.65 229.16,32.13 229.16,35.03 228.04,36.14 228.04,47.45 226.36,49.13 226.36,53.85 223.29,56.93 223.29,57.41 219.28,61.42 213.1,61.42 210.77,63.75 207.99,63.75 205.93,65.81 196.87,65.81 193,61.95 190.19,61.95 189.65,61.41 186.83,61.41 184.82,59.39 184.36,59.39 183.36,58.39 182.81,58.39 181.44,57.02 179.35,57.02 179.27,57.1 v1(179.27,57.3)
PE17_RXP: length 118.7
  TOP w0.102: v1(178.49,57.2) 178.49,57.41 PCH.K39 ; v1(217.65,12.96) 217.51,12.96 217.4,12.85 217.4,12.17 217.61,11.96 SS4.41
  BOTTOM w0.102: 218.57,10.16 v2(218.57,10.45) ; 218.57,10.16 217.74,10.16 217.25,10.65 217.25,12.56 v1(217.65,12.96) ; 218.57,10.16 225.25,10.16 227.56,12.47 227.56,14.83 227.18,15.21 227.18,16.26 228.57,17.66 228.57,19.05 229.43,19.9 229.43,22.47 230.78,23.83 230.78,28.75 229.44,30.1 229.44,31.56 228.96,32.05 228.96,34.94 227.84,36.06 227.84,47.37 226.16,49.05 226.16,53.77 223.09,56.84 223.09,57.32 219.19,61.21 213.02,61.21 210.68,63.55 207.9,63.55 205.84,65.61 196.95,65.61 193.09,61.75 190.27,61.75 189.73,61.21 186.92,61.21 184.9,59.19 184.45,59.19 183.45,58.19 182.9,58.19 181.53,56.82 178.87,56.82 v1(178.49,57.2)
PE17_TXN: length 127.7
  TOP w0.102: v1(188.23,63.25) 187.68,62.69 186.48,62.69 185.78,61.99 184,61.99 181.99,59.98 181.78,59.98 PCH.E45 ; M2C22.2 215.97,7.84 215.97,7.54 v1(216.21,7.31)
  BOTTOM w0.102: v1(188.23,63.25) 188.47,63.48 188.47,64.15 193.03,68.71 206.91,68.71 209.12,66.5 211.9,66.5 214.19,64.21 220.37,64.21 226.03,58.54 226.03,58.06 229.11,54.99 229.11,52.41 230.89,50.64 230.89,37.34 231.95,36.27 231.95,33.32 232.38,32.89 232.38,31.43 233.94,29.87 233.94,18.49 231.65,16.2 231.65,14.45 231.24,14.05 231.24,10.62 229.88,9.25 229.88,7.57 228.58,6.27 224.84,6.27 224.03,5.46 218.36,5.46 217.42,6.39 217.42,8 217.3,8.13 216.92,8.13 ; v1(216.21,7.31) 215.94,7.58 215.94,7.87 216.19,8.13 216.92,8.13 ; 216.92,8.13 v2(216.92,7.84)
PE17_TXN1_C: length 2.2
  TOP w0.102: M2C22.1 215.97,9.41 215.97,10.01 216.11,10.14 SS4.47
PE17_TXP: length 127.7
  TOP w0.102: v1(188.87,63.25) 188.4,62.78 188.05,62.78 187.76,62.48 186.56,62.48 185.87,61.79 184.08,61.79 182.07,59.78 181.78,59.78 PCH.F45 ; M2C23.2 215.77,7.86 215.77,7.49 v1(215.56,7.29)
  BOTTOM w0.102: v1(188.87,63.25) 188.67,63.45 188.67,64.06 193.11,68.5 206.83,68.5 209.04,66.29 211.82,66.29 214.11,64.01 220.28,64.01 225.83,58.46 225.83,57.98 228.9,54.91 228.9,52.33 230.68,50.55 230.68,37.25 231.75,36.19 231.75,33.24 232.18,32.81 232.18,31.34 233.74,29.79 233.74,18.57 231.44,16.28 231.44,14.54 231.04,14.13 231.04,10.7 229.67,9.34 229.67,7.66 228.5,6.48 224.76,6.48 223.94,5.66 218.89,5.66 ; 218.89,5.66 v2(218.89,5.96) ; 218.89,5.66 218.44,5.66 217.63,6.48 217.63,8.09 217.38,8.33 216.11,8.33 215.73,7.96 215.73,7.45 v1(215.56,7.29)
PE17_TXP1_C: length 2.2
  TOP w0.102: SS4.49 215.61,10.14 215.77,9.98 215.77,9.39 M2C23.1
PE18_RXN: length 112.2
  TOP w0.102: v1(178.52,56.24) 178.52,56.6 178.67,56.75 PCH.M39 ; SS4.29 220.61,11.96 220.46,12.11 220.46,12.68 v1(220.72,12.94)
  BOTTOM w0.102: v1(220.72,12.94) 220.53,12.94 220.4,12.8 220.4,11.57 ; 220.4,11.57 220.4,11.23 220.78,10.85 224.89,10.85 226.87,12.83 226.87,14.44 226.47,14.85 226.47,16.62 227.86,18.02 227.86,19.31 228.74,20.19 228.74,22.85 229.57,23.67 229.57,29 228.75,29.81 228.75,31.26 228.27,31.74 228.27,34.62 227.15,35.73 227.15,45.03 227.15,45.04 227.15,47.04 225.48,48.72 225.48,53.48 222.4,56.56 222.4,57.04 218.91,60.53 212.7,60.53 210.36,62.87 207.62,62.87 205.56,64.92 197.23,64.92 193.37,61.06 190.56,61.06 190.02,60.52 187.2,60.52 185.05,58.37 184.67,58.37 182.65,56.35 179.91,56.35 179.38,55.82 178.94,55.82 v1(178.52,56.24) ; 220.4,11.57 v2(220.69,11.57)
PE18_RXP: length 112.2
  TOP w0.102: PCH.M41 179.2,56.43 v1(179.2,56.24) ; SS4.31 220.11,11.96 220.26,12.11 220.26,12.68 v1(220,12.94)
  BOTTOM w0.102: v1(179.2,56.24) 179.51,56.24 179.83,56.55 182.57,56.55 184.59,58.57 184.97,58.57 187.12,60.72 189.93,60.72 190.47,61.26 193.29,61.26 197.15,65.13 205.64,65.13 207.7,63.07 210.45,63.07 212.78,60.73 218.99,60.73 222.61,57.12 222.61,56.64 225.68,53.57 225.68,48.8 227.36,47.12 227.36,44.95 227.35,44.95 227.35,35.82 228.47,34.7 228.47,31.83 228.96,31.34 228.96,29.9 229.77,29.08 229.77,24 ; 229.77,24 229.77,23.59 228.94,22.76 228.94,20.1 228.07,19.23 228.07,17.93 226.67,16.54 226.67,14.94 227.08,14.53 227.08,12.74 224.98,10.64 220.7,10.64 220.19,11.15 220.19,12.74 v1(220,12.94) ; 229.77,24 v2(230.06,24)
PE18_TXN: length 121.4
  TOP w0.102: M2C25.2 218.87,7.78 218.87,7.57 219.08,7.36 v1(219.3,7.36) ; PCH.G45 181.8,59.07 181.86,59.13 182.19,59.13 184.16,61.1 184.29,61.1 184.35,61.04 184.35,60.58 184.45,60.49 184.62,60.49 v1(184.78,60.66)
  BOTTOM w0.102: v1(219.3,7.36) 219.05,7.36 218.92,7.24 218.92,6.95 219.06,6.81 220.24,6.81 220.7,6.35 223.31,6.35 224.12,7.16 228.21,7.16 228.98,7.93 228.98,10.42 230.3,11.74 230.3,14.41 230.71,14.82 230.71,16.54 232.97,18.8 232.97,29.56 231.5,31.03 231.5,32.48 231.06,32.91 231.06,35.89 229.92,37.03 229.92,49.15 ; 229.92,49.15 229.92,50.34 228.22,52.04 228.22,54.62 225.15,57.7 225.15,58.17 220,63.32 213.82,63.32 211.54,65.61 208.75,65.61 206.6,67.77 193.53,67.77 190.82,65.05 190.82,63.83 188.88,61.89 186.63,61.89 185.84,61.1 185.49,61.1 185.34,60.96 185.34,60.66 185.18,60.49 184.95,60.49 v1(184.78,60.66) ; 229.92,49.15 v2(229.63,49.15)
PE18_TXN2_C: length 2.2
  TOP w0.102: M2C25.1 218.96,9.43 218.96,9.99 219.11,10.14 SS4.35
PE18_TXP: length 121.4
  TOP w0.102: v1(218.45,7.36) 218.67,7.58 218.67,7.97 M2C24.2 ; v1(184.79,61.31) 184.07,61.31 182.1,59.33 181.34,59.33 PCH.G44
  BOTTOM w0.102: v1(218.45,7.36) 218.72,7.09 218.72,6.86 218.98,6.6 220.16,6.6 220.62,6.15 223.39,6.15 224.21,6.96 228.29,6.96 229.18,7.85 229.18,10.34 230.5,11.66 230.5,14.33 230.91,14.73 230.91,16.46 233.17,18.72 233.17,29.64 231.7,31.11 231.7,32.56 231.27,32.99 231.27,35.97 230.12,37.12 230.12,50.43 228.42,52.13 228.42,54.71 225.35,57.78 225.35,58.26 220.08,63.53 213.91,63.53 211.62,65.81 208.84,65.81 206.68,67.97 193.45,67.97 190.61,65.14 190.61,63.91 188.79,62.1 187.32,62.1 ; v1(184.79,61.31) 185.76,61.31 186.55,62.1 187.32,62.1 ; 187.32,62.1 v2(187.32,62.39)
PE18_TXP2_C: length 2.2
  TOP w0.102: M2C24.1 218.76,9.41 218.76,9.99 218.61,10.14 SS4.37
PE19_RXN: length 101.9
  TOP w0.102: v1(224.36,14.76) 224.36,13.72 223.61,12.97 SS4.17 ; PCH.P39 179.3,55.28 v1(179.3,55.27)
  BOTTOM w0.102: 225.98,18.03 225.98,18.95 228.12,21.08 228.12,23.02 228.75,23.66 228.75,28.57 227.79,29.54 227.79,34.38 226.66,35.51 226.66,46.83 224.99,48.5 224.99,53.09 221.92,56.16 221.92,56.84 218.71,60.05 212.45,60.05 210.32,62.18 207.62,62.18 205.36,64.44 197.43,64.44 192.07,59.08 186.56,59.08 185.26,57.78 184.76,57.78 183.01,56.04 179.87,56.04 179.59,55.75 179.59,55.56 v1(179.3,55.27) ; 225.98,18.03 v2(226.28,18.03) ; 225.98,18.03 225.98,15.75 225.48,15.24 224.49,15.24 224.36,15.11 v1(224.36,14.76)
PE19_RXP: length 101.9
  TOP w0.102: PCH.P41 179.65,55.63 v1(180.02,55.26) ; v1(223.72,14.77) 224.16,14.33 224.16,13.8 223.4,13.05 223.4,12.15 223.34,12.09 223.19,12.09 223.11,12.01 SS4.19
  BOTTOM w0.102: 227.91,21.79 227.91,23.11 228.55,23.74 228.55,28.49 227.58,29.46 227.58,34.29 226.45,35.42 226.45,46.75 224.79,48.41 224.79,53 221.72,56.08 221.72,56.75 218.63,59.84 212.37,59.84 210.24,61.98 207.54,61.98 205.27,64.24 197.52,64.24 192.16,58.88 186.64,58.88 185.34,57.58 184.84,57.58 183.1,55.84 179.96,55.84 179.79,55.67 179.79,55.49 v1(180.02,55.26) ; 227.91,21.79 v2(227.62,21.79) ; 227.91,21.79 227.91,21.17 225.78,19.03 225.78,15.83 225.39,15.44 224.39,15.44 v1(223.72,14.77)
PE19_TXN: length 115.9
  TOP w0.102: M2C27.2 221.96,7.89 221.96,7.68 v1(222.25,7.4) ; PCH.H44 181.37,58.79 182.38,58.79 183.02,59.44 184.4,59.44 186.97,62 190.95,62 191.19,62.24 v1(191.19,62.87)
  BOTTOM w0.102: v1(222.25,7.4) 222.25,8.43 222.35,8.53 225.01,8.53 225.77,7.77 227.74,7.77 228.47,8.51 228.47,10.74 229.69,11.96 229.69,14.52 230.23,15.05 230.23,16.76 232.41,18.94 232.41,29.4 231.01,30.79 231.01,32.26 230.56,32.72 230.56,35.67 229.44,36.79 229.44,48.24 227.74,49.94 227.74,50.55 ; v1(191.19,62.87) 191.19,63.52 191.38,63.71 191.38,64.66 194,67.28 206.4,67.28 208.55,65.13 211.34,65.13 213.65,62.81 219.82,62.81 224.66,57.97 224.66,57.5 227.74,54.42 227.74,50.55 ; 227.74,50.55 v2(228.03,50.55)
PE19_TXN3_C: length 2.2
  TOP w0.102: M2C27.1 221.96,9.41 221.96,9.99 222.11,10.14 SS4.23
PE19_TXP: length 115.9
  TOP w0.102: M2C26.2 221.76,7.86 221.76,7.63 v1(221.56,7.42) ; PCH.H45 181.68,58.59 182.47,58.59 183.11,59.23 184.49,59.23 187.05,61.8 191.03,61.8 191.39,62.15 191.39,62.38 191.47,62.46 191.67,62.46 191.82,62.61 v1(191.82,62.87)
  BOTTOM w0.102: 222.88,8.74 v2(222.88,9.03) ; 222.88,8.74 222.27,8.74 222.05,8.52 222.05,7.91 v1(221.56,7.42) ; 222.88,8.74 225.09,8.74 225.86,7.98 227.65,7.98 228.27,8.59 228.27,10.83 229.49,12.05 229.49,14.61 230.02,15.14 230.02,16.84 232.21,19.02 232.21,29.31 230.81,30.71 230.81,32.17 230.35,32.63 230.35,35.59 229.24,36.7 229.24,48.16 227.53,49.86 227.53,54.34 224.46,57.41 224.46,57.89 219.74,62.61 213.56,62.61 211.25,64.92 208.47,64.92 206.31,67.08 194.08,67.08 191.58,64.58 191.58,63.62 191.44,63.48 191.44,63.35 191.5,63.29 191.88,63.29 191.97,63.2 191.97,63.02 v1(191.82,62.87)
PE19_TXP3_C: length 2.2
  TOP w0.102: SS4.25 221.61,10.14 221.76,9.99 221.76,9.44 M2C26.1
PE20_RXN: length 110.4
  TOP w0.102: v1(225.78,13.82) 225.6,13.64 225.6,13.36 226.61,12.35 SS4.5 ; PCH.P38 178.13,55.55 v1(177.8,55.22)
  BOTTOM w0.102: v1(177.8,55.22) 177.75,55.27 177.75,55.53 177.83,55.6 178.05,55.6 179.06,54.59 179.87,54.59 179.88,54.6 180.29,54.6 180.3,54.59 180.49,54.59 181.19,55.29 183.53,55.29 185.04,56.8 185.56,56.8 186.87,58.12 192.37,58.12 197.8,63.55 204.99,63.55 207.33,61.21 209.91,61.21 211.96,59.16 218.34,59.16 221.03,56.47 221.03,55.79 224.1,52.72 224.1,48.08 225.77,46.42 225.77,34.18 226.9,33.05 226.9,29.01 227.86,28.04 227.86,24.03 226.69,22.86 226.69,22.16 226.26,21.73 226.26,20.6 222.3,16.64 222.3,15.75 ; v1(225.78,13.82) 225.53,13.57 225.53,12.82 224.09,11.38 222.2,11.38 221.79,11.79 221.79,14.38 222.3,14.89 222.3,15.75 ; 222.3,15.75 v2(222.01,15.75)
PE20_RXP: length 110.4
  TOP w0.102: PCH.P36 177.36,55.88 v1(177.75,56.26) ; v1(225.14,13.82) 225.4,13.56 225.4,13.27 226.4,12.27 226.4,12.18 226.11,11.88 SS4.7
  BOTTOM w0.102: v1(177.75,56.26) 177.75,55.96 177.9,55.8 178.14,55.8 179.14,54.8 179.79,54.8 179.8,54.81 180.38,54.81 180.38,54.8 180.4,54.8 181.1,55.5 183.44,55.5 184.95,57.01 185.47,57.01 186.78,58.32 192.28,58.32 197.72,63.75 205.07,63.75 207.41,61.42 209.99,61.42 212.05,59.36 218.43,59.36 221.23,56.55 221.23,55.87 224.31,52.8 224.31,48.17 225.97,46.5 225.97,34.26 227.1,33.13 227.1,29.09 228.07,28.13 228.07,23.94 226.9,22.78 226.9,22.07 226.47,21.64 226.47,20.51 222.5,16.55 222.5,14.81 222,14.3 222,13.46 ; v1(225.14,13.82) 225.32,13.63 225.32,12.9 224,11.58 222.28,11.58 222,11.87 222,13.46 ; 222,13.46 v2(222.29,13.46)
PE20_TXN: length 111.2
  TOP w0.102: PCH.J43 180.99,58.22 182.58,58.22 183.08,58.72 184.73,58.72 187.32,61.32 191.57,61.32 193.73,63.47 193.73,63.62 193.62,63.73 v1(193.27,63.73) ; v1(226.4,8.75) 226.85,8.3 226.85,7.91 226.27,7.33 225.09,7.33 224.96,7.46 224.96,7.84 M2C29.2
  BOTTOM w0.102: v1(226.4,8.75) 226.85,9.2 226.85,10.67 228.78,12.6 228.78,14.89 229.29,15.4 229.29,17.08 230.91,18.7 230.91,19.57 231.19,19.84 231.19,21.15 ; 231.19,21.15 v2(230.9,21.15) ; 231.19,21.15 231.19,23.24 231.52,23.57 231.52,29.01 230.12,30.4 230.12,31.87 229.64,32.35 229.64,35.25 228.55,36.34 228.55,47.7 226.85,49.4 226.85,54.05 223.77,57.13 223.77,57.61 219.45,61.93 213.28,61.93 210.97,64.24 208.19,64.24 206.05,66.37 194.39,66.37 193.75,65.74 193.75,63.6 193.65,63.5 193.5,63.5 v1(193.27,63.73)
PE20_TXN4_C: length 2.2
  TOP w0.102: SS4.11 225.11,10.14 224.99,10.02 224.99,9.44 M2C29.1
PE20_TXP: length 111.2
  TOP w0.102: M2C28.2 224.76,7.91 224.76,7.37 225.01,7.13 226.35,7.13 227.05,7.82 v1(227.05,8.74) ; v1(193.27,64.36) 193.93,63.7 193.93,63.38 191.66,61.11 187.41,61.11 184.82,58.52 183.17,58.52 182.66,58.02 181.38,58.02 PCH.J44
  BOTTOM w0.102: v1(193.27,64.36) 193.55,64.64 193.55,65.82 194.3,66.57 206.14,66.57 208.27,64.44 211.05,64.44 213.36,62.13 219.54,62.13 223.98,57.69 223.98,57.21 227.05,54.14 227.05,49.49 228.75,47.79 228.75,36.42 229.84,35.33 229.84,32.44 230.33,31.95 230.33,30.49 231.72,29.09 231.72,23.49 231.39,23.15 231.39,22.71 ; 231.39,22.71 231.39,19.76 231.11,19.48 231.11,18.62 229.49,16.99 229.49,15.32 228.98,14.81 228.98,12.51 227.05,10.58 v1(227.05,8.74) ; 231.39,22.71 v2(231.68,22.71)
PE20_TXP4_C: length 2.2
  TOP w0.102: SS4.13 224.61,10.14 224.78,9.97 224.78,9.41 M2C28.1
PECI_PCH: length 261.2
  TOP w0.089: 158.59,47.91 159.66,47.91 159.8,48.05 160.13,48.15 160.24,48.26 160.47,48.26 160.62,48.2 161,48.18 PCH.AK4
  TOP w0.102: v1(141.7,45.93) 142.12,46.34 146.17,46.34 146.46,46.06 147.83,46.06 148.31,45.58 150.68,45.58 151.52,46.42 153.42,46.42 153.5,46.34 156.77,46.34 158.34,47.91 158.59,47.91 ; v1(82.36,101.99) 81.05,103.3 79.7,103.3 78.82,104.18 71.82,104.18 70.75,103.1 55.2,103.1 53.5,101.41 53.5,100.13 52.35,98.97 51.72,98.97 41.74,88.99 41.74,87.88 40.68,86.82 40.68,79.4 36.41,75.13 36.41,61.01 36.25,60.84 v1(36.25,59.39) ; HR22.1 101.91,124.11 v1(103.27,124.11)
  BOTTOM w0.102: v1(103.27,124.11) 103.27,117.77 102.7,117.21 102.7,116.74 103.09,116.35 103.93,116.35 105.68,114.61 105.68,113.1 96.83,104.25 84.65,104.25 82.39,101.99 v1(82.36,101.99) ; v1(36.25,59.39) 36.25,58.88 v2(36.96,58.17) 36.96,57.9 48.23,46.62 57.39,46.62 58.15,45.86 60.12,45.86 60.84,45.14 81.39,45.14 85.59,40.94 104.26,40.94 104.55,40.65 106.67,40.65 107.63,39.69 120.47,39.69 121.06,40.27 127.82,40.27 128.63,41.09 136.34,41.09 138.61,43.35 139.13,43.35 v1(141.7,45.93)
PECI_READY: length 5.4
  TOP w0.102: U104.31 220.94,24.05 221.53,23.46 v1(222.85,23.46) 223.44,22.86 OR3.2
  BOTTOM w0.102: v2(223.09,24.56) 223.09,23.7 v1(222.85,23.46)
PECI_SIO: length 421.2
  TOP w0.102: XU1.G7 112.65,148.39 112.73,148.46 v1(113.13,148.46) ; v1(102.02,125.45) 102.02,125.11 HR22.2 96.94,129.34 85.61,129.34 81.85,125.58 81.85,120.32 79.47,117.93 76.2,117.93 69.05,110.78 53.84,110.78 50.63,107.57 48.07,107.57 42.12,101.63 34.47,101.63 26.87,94.02 26.87,72.88 30.58,69.16 30.58,65.94 26.72,62.08 26.72,58.34 23.93,55.54 23.93,38.86 v1(26.28,36.52) ; v1(222.76,21.55) O2R1.1 ; v1(196.27,29.77) 197.02,29.02 197.02,24.28 197.6,23.7 197.6,22.88 197.86,22.62 197.86,21.05 199.34,19.57 203.58,19.57 204.17,18.98 211.63,18.98 v1(212.75,17.86)
  BOTTOM w0.102: v1(26.28,36.52) 26.28,35.75 27.18,34.85 v2(27.18,32) 27.18,29.74 30.89,26.03 30.89,25.92 42.03,14.78 60.19,14.78 60.43,14.54 61.57,14.54 61.66,14.64 88.31,14.64 88.71,14.24 90.62,14.24 91.46,15.07 106.99,15.07 107.4,14.67 121.66,14.67 122.42,15.43 129.94,15.43 130.75,16.24 132.46,16.24 132.55,16.14 133.94,16.14 136.84,19.04 142.89,19.04 144.1,20.24 152.05,20.24 152.97,21.16 154.7,21.16 156.09,22.55 156.88,23.34 160.9,23.34 161.3,23.74 166.17,23.74 166.58,24.14 171.28,24.14 172.63,25.49 173.62,25.49 176.11,27.98 178.17,27.98 180.14,29.95 184.59,29.95 185.53,30.89 193.11,30.89 193.45,31.23 195.22,31.23 196.27,30.19 v1(196.27,29.77) ; v1(212.75,17.86) 219.79,17.86 222.76,20.83 v1(222.76,21.55) ; v1(113.13,148.46) 112.64,148.96 112,148.96 111.23,149.72 107.22,149.72 106.3,148.81 106.3,146.47 106.14,146.31 106.14,141.02 105.59,140.47 105.59,138.45 105.59,137.94 105.59,136.44 102.16,133.01 102.16,125.59 v1(102.02,125.45)
PLTRST_CPU#: length 314.9
  TOP w0.089: PCH.AK3 160.69,47.92 160.4,47.62 159.9,47.62 159.8,47.53 158.5,47.53
  TOP w0.102: HC5.1 102.68,123.17 102.92,123.17 103.69,123.93 103.69,124.84 102.36,126.16 102.36,128.19 103.38,129.2 v1(103.38,129.64) 103.19,129.82 85.41,129.82 81.37,125.78 81.37,120.61 79.42,118.67 76.07,118.67 69.09,111.69 53.56,111.69 50.28,108.41 47.51,108.41 44.89,105.79 36.84,105.79 25.49,94.44 25.49,72.35 29.27,68.57 29.27,66.71 v1(28.88,66.32) ; v1(151.63,45.82) 151.94,45.5 156.48,45.5 158.5,47.53 ; v1(111.29,147.55) XU1.E7
  BOTTOM w0.102: v1(111.29,147.55) 110.88,147.14 110.13,147.14 109.91,147.37 109.91,147.7 109.65,147.96 109.19,147.96 108.99,148.16 108.99,148.67 108.75,148.91 107.55,148.91 107.24,148.6 107.24,144.94 107.59,144.59 107.59,143.78 107.11,143.31 107.11,142.29 107.49,141.91 107.49,135.45 103.81,131.76 103.81,130.07 v1(103.38,129.64) ; v1(28.88,66.32) 30.48,66.32 32.82,63.99 32.82,63.7 v2(33.78,62.74) 34.87,61.65 34.87,54.24 44.12,44.99 58.76,44.99 59.43,44.32 59.43,44.09 60.34,43.18 82.49,43.18 85.4,40.27 104.25,40.27 104.34,40.17 106.07,40.17 107.03,39.21 120.67,39.21 121.13,39.66 128.13,39.66 128.89,40.43 136.4,40.43 138.79,42.82 139.33,42.82 143.49,46.97 150.47,46.97 v1(151.63,45.82)
PLTRST_PCIE1#: length 525.9
  TOP w0.102: v1(57.45,84.23) 58.63,83.05 58.63,80.86 57.51,79.73 57.51,77.94 60.19,75.26 60.9,75.26 62.67,73.48 62.67,69.35 59.22,65.9 59.22,64.15 58.31,63.23 58.31,62.34 58.64,62.01 58.64,60.62 57.39,59.37 57.39,57.67 60.08,54.98 60.08,50.04 60.72,49.41 60.72,46.65 59.14,45.07 58.33,45.07 57.75,44.49 57.75,42.78 58.86,41.67 58.86,40.16 57.33,38.63 v1(57.33,38.15) ; M2C44.1 212.37,9.63 212.26,9.74 v1(212.26,12.98) 215.36,16.08 SS4.50 ; v1(216.08,31.98) 217.06,31.98 217.53,31.51 219.9,31.51 222.03,33.64 U104.51 223.91,33.64 224.31,34.04 224.88,34.04 R636.1 ; LR1.2 v1(38.23,222.29) 37.68,221.74 37.68,220.6 LC18.1 37.02,218.85 36.87,218.85 36.38,218.36 U10.2 ; v1(200.08,16.08) 199.86,15.86 199.86,11.81 v1(200.7,10.97) ; J60.52 40.17,116.8 40.37,117.01 41.26,117.01 41.76,117.5 44.31,117.5 46.13,119.32 47.9,119.32 v1(48.57,120) 49.08,119.48 52.27,119.48 52.61,119.14 53.18,119.14 M2C48.1 54.46,117.87 54.46,115.66 v1(53.96,115.16) ; v1(53.8,9.4) 54.18,9.78 54.18,10.71 56.88,13.41 56.88,16.42 54.73,18.57 54.73,19.77 54.89,19.94 54.89,20.96 54.5,21.35 54.5,22.28 55.64,23.42 55.64,26.65 56.29,27.3 58.58,27.3 60.07,28.8 60.07,33.61 56.26,37.42 v1(56.26,38) ; v1(23.52,150.85) 23.62,150.75 23.62,149.78 23.93,149.48 24.18,149.48 25.27,150.57 26.05,150.57 26.63,149.99 29.09,149.99 30.9,151.8 33.63,151.8 34.02,151.41 v1(34.02,150.9) 33.57,150.9 UC950.1 33.4,150.33 33.82,150.33 34.02,150.13 U4.30
  BOTTOM w0.102: v1(216.08,31.98) 216.05,31.95 216.05,28.81 212.35,25.11 208.21,25.11 204.91,21.81 204.91,20.1 201.19,16.38 200.38,16.38 v1(200.08,16.08) 199.28,16.08 199.19,16.17 189.42,16.17 188.06,14.81 183.53,14.81 182.73,14.01 181.96,14.01 180.51,14.01 176.13,14.01 176.13,14.01 174.69,14.01 174.4,13.72 172.76,13.72 172.01,12.97 172.01,12.8 171.26,12.05 171.13,12.05 170.5,11.42 170.5,11.19 167.5,8.19 162.66,8.19 155.47,15.38 151.32,15.38 150.05,14.11 148.42,14.11 147.47,13.16 141.24,13.16 137.25,9.17 121.85,9.17 121.49,9.53 120.82,10.2 116.61,10.2 115.81,11 105.99,11 105.4,10.4 104.39,10.4 103.99,10.81 103.2,10.81 102.54,10.15 98.63,10.15 97.87,10.91 92.21,10.91 92.13,10.82 83.04,10.82 82.17,9.95 74.56,9.95 74.22,9.61 58.22,9.61 58.02,9.41 53.81,9.41 v1(53.8,9.4) ; v1(57.33,38.15) 57.18,38 v1(56.26,38) ; v1(23.52,150.85) 23.18,151.19 23.18,155.19 18.53,159.83 18.53,175.17 20.33,176.97 21.71,176.97 22.98,178.25 22.98,193.85 29.73,200.6 29.73,202.31 31.15,203.74 31.15,211.18 27.97,214.37 27.97,217.3 26.45,218.81 26.45,223.99 27.31,224.84 v2(31.88,224.84) 31.95,224.84 32.86,223.93 36.59,223.93 v1(38.23,222.29) ; v1(57.45,84.23) 57.45,85.01 58.25,85.81 58.25,110.86 v1(53.96,115.16) ; v1(48.57,120) 47.06,121.51 47.06,123.1 46.46,123.7 46.46,125.25 45.48,126.23 45.48,126.97 45.08,127.37 45.08,129.61 42.85,131.84 42.85,133.13 40.41,135.57 40.41,141.39 38.98,142.82 38.85,142.82 34.99,146.69 34.99,146.82 34.02,147.78 v1(34.02,150.9) ; v1(212.26,12.98) 212.26,12.59 210.39,10.72 200.94,10.72 v1(200.7,10.97)
PM_DOWN: length 264.6
  TOP w0.089: PCH.AH2 160.15,48.62 159.73,48.76 159.22,48.76 158.78,48.31 158.65,48.18 158.35,48.18
  TOP w0.102: v1(141.88,46.89) 146.24,46.89 SR694.1 147.36,47.59 147.59,47.36 149.77,47.36 149.82,47.31 153.77,47.31 153.89,47.18 156.19,47.18 156.67,47.66 157.83,47.66 158.35,48.18 ; v1(82.89,98.11) 82.89,102.14 81.25,103.78 79.9,103.78 79.02,104.66 71.28,104.66 70.21,103.59 53.2,103.59 52.55,102.93 51.07,102.93 49.25,101.11 49.25,97.29 41.26,89.3 41.26,88.08 40.16,86.98 40.16,79.65 35.92,75.41 v1(35.92,62.19) ; v1(99.87,101.04) 99.87,105.79 102.49,108.41 102.49,113.4 103.92,114.83 103.92,120.19 HR27.1
  BOTTOM w0.102: v1(141.88,46.89) 140.8,46.89 139.63,45.72 138.74,45.72 135.42,42.41 128.12,42.41 127.16,41.44 120.57,41.44 120.07,40.94 108.85,40.94 107.97,41.82 105.03,41.82 104.75,42.11 86.32,42.11 82.07,46.36 61.36,46.36 60.44,47.28 58.38,47.28 57.87,47.79 51.72,47.79 50.3,49.22 47.29,49.22 38.67,57.84 38.67,59.69 36.17,62.19 v1(35.92,62.19) ; v1(82.89,98.11) v2(84.38,99.59) 85.75,100.97 89.15,100.97 89.78,100.34 96.33,100.34 97.03,101.04 v1(99.87,101.04)
PM_DOWN_R: length 44.7
  TOP w0.102: v1(103.84,123.29) 103.82,123.29 HR27.2 ; v1(110.39,148.45) 110.39,148.45 XU1.D8
  BOTTOM w0.102: v2(106.81,113.79) 106.81,118.35 103.84,121.32 v1(103.84,123.29) 103.84,126.64 102.93,127.55 102.93,132.3 106.73,136.1 106.73,141.91 106.54,142.1 106.54,144.47 106.71,144.64 106.71,148.64 107.38,149.32 109.42,149.32 110.29,148.45 v1(110.39,148.45)
PM_SYNC: length 281.2
  TOP w0.102: XU1.E8 110.82,148.92 v1(111.28,148.46) ; v1(141.01,45.98) 141.01,46.7 141.74,47.43 SR220.2 ; v1(28.85,67.69) 25.14,71.41 25.14,94.59 36.69,106.15 44.75,106.15 47.36,108.76 50.13,108.76 53.41,112.04 68.94,112.04 75.93,119.02 79.27,119.02 81.01,120.76 81.01,125.93 85.26,130.18 102.29,130.18 v1(103.35,131.24)
  BOTTOM w0.102: v1(111.28,148.46) 110.82,148.01 110.16,148.01 109.88,148.29 109.88,148.57 109.34,149.11 107.47,149.11 107.04,148.68 107.04,144.86 107.38,144.51 107.38,143.86 106.9,143.38 106.9,142.22 107.11,142 107.11,135.84 103.35,132.08 v1(103.35,131.24) ; v1(141.01,45.98) 138.93,43.9 138.11,43.9 135.91,41.69 128.38,41.69 127.44,40.75 120.86,40.75 120.36,40.25 108.48,40.25 107.6,41.14 104.75,41.14 104.46,41.42 85.92,41.42 81.66,45.68 61.06,45.68 60.26,46.48 58.21,46.48 57.59,47.1 50.91,47.1 49.63,48.38 47.16,48.38 37.98,57.55 37.98,58.32 35.23,61.07 35.23,62.19 v2(30.29,67.12) 29.72,67.69 v1(28.85,67.69)
PM_SYNC_R: length 19.5
  TOP w0.089: 157.76,47.87 158.28,48.39 158.43,48.39 158.6,48.39 159.15,48.93 159.79,48.93 160.13,48.82 160.35,48.76 160.74,48.76 PCH.AH3
  TOP w0.102: 157.76,47.87 156.37,47.87 155.91,47.41 153.99,47.41 153.86,47.54 153.67,47.54 153.67,47.54 149.91,47.54 149.86,47.59 147.99,47.59 147.83,47.75 147.83,48.39 147.52,48.69 v1(146.18,48.69) 145.63,48.69 144.86,47.92 SR220.1
  BOTTOM w0.102: v2(146.96,48.69) v1(146.18,48.69)
PORST#: length 49.6
  TOP w0.102: U4.9 42.62,144.63 42.9,144.91 42.9,148.98 UC969.1 41.87,150.69 v1(41.35,151.21) ; v1(35.61,182.14) 34.77,182.14 34.54,182.37 UD8869.1 35.56,183.3 UR69692.1 36.14,181.86 35.97,181.69 UC641.1
  BOTTOM w0.102: v1(35.61,182.14) 35.61,179.01 33.57,176.97 33.57,166.06 v2(35.08,164.55) 36.87,162.76 36.87,159.44 38.28,158.03 38.28,154.51 39.28,153.5 39.28,153.28 v1(41.35,151.21)
PQ37_S_A: length 6.2
  TOP w0.102: PQ37.2 239.03,210.07 238.23,210.86 PC132.2 238.23,212.07 238.39,212.23 PR198.2 238.24,212.7 AR235.1 237.53,212.01 237.35,211.84 v1(236.88,211.84)
  BOTTOM w0.102: v2(236.42,211.18) 236.42,211.38 v1(236.88,211.84)
PQ46_EN_R1: length 4
  TOP w0.102: PQ46.2 136.3,110.38 PC133.1 PR249.2 v1(134.26,109.94)
  BOTTOM w0.102: v2(134.84,109.37) v1(134.26,109.94)
PQ46_EN_R2: length 5.2
  TOP w0.102: PQ46.3 137.14,111.36 137.58,111.8 PR248.2 137.79,111.29 137.79,110.62 138.47,109.94 v1(138.71,109.94)
  BOTTOM w0.102: v2(138.28,110.79) 138.28,110.38 v1(138.71,109.94)
PQ46_EN_R3: length 19.1
  TOP w0.102: PR244.1 v1(127.56,118.31) ; v1(132.61,114.91) 136.35,114.91 136.95,114.31 PQ46.4
  BOTTOM w0.102: v1(127.56,118.31) 128.17,118.92 131.93,118.92 133.15,117.7 133.15,115.44 v1(132.61,114.91) 133.12,114.4 133.12,111.79 v2(132.74,111.4)
PQ46_EN_R4: length 14.8
  TOP w0.102: v1(121.18,117.58) 123.88,117.58 124.34,117.11 PC274.1 124.76,116.94 125.15,117.32 126.15,117.32 PR245.1 127.15,116.76 127.18,116.74 PR244.2 128.18,116.12 PQ60.1
  BOTTOM w0.102: v2(121.18,111.43) v1(121.18,117.58)
PQ54_S_A: length 7.4
  TOP w0.254: v1(215.96,129.69) 216.28,129.69 216.57,129.98 AR233.1 216.57,132 PQ54.2 215.78,132.79 215.04,132.79 PC131.2 214.1,133.74 PR137.2
  BOTTOM w0.102: v1(215.96,129.69) 215.95,129.7 v2(215.95,130.66)
PROC_AUDIO_CLK: length 182.8
  TOP w0.102: XU1.V3 122.71,143.96 122.18,143.43 122.18,142.35 121.99,142.16 121.99,140.71 121.87,140.59 121.87,139.65 121.67,139.45 121.67,137.49 v1(122.12,137.03) ; SR246.1 152.2,44.42 152.16,44.39 145.41,44.39 144.98,44.82 137.85,44.82 v1(137.46,45.21) ; v1(105.15,43.65) 105.15,44.65 105.95,45.45 105.95,62.64 114,70.69 114.68,71.37 114.68,71.37 114.76,71.45 122.6,71.45 129.17,78.02 129.17,79.54 128.72,80 128.72,82.16 128.78,82.22 128.78,83.19 131.67,86.08 131.67,86.46 v1(132.59,87.38) ; v1(122.02,120.19) 122.81,119.41 126.62,119.41 126.92,119.71 128.37,119.71 128.8,119.28 130.33,119.28 130.86,118.75 134.09,118.75 v1(134.37,119.02)
  BOTTOM w0.102: v1(105.15,43.65) 105.65,43.15 106.95,43.15 108.43,43.15 108.43,43.15 122.53,43.15 122.94,43.56 135.83,43.56 137.46,45.19 v1(137.46,45.21) ; v1(122.12,137.03) 121.29,136.2 121.29,120.92 v1(122.02,120.19) ; v1(132.59,87.38) 132.86,87.38 v2(134.19,88.7) 134.59,89.11 134.59,92.66 137.13,95.2 137.13,101.14 137.44,101.45 137.44,108.43 135.86,110.01 135.86,111.17 134.75,112.29 134.75,118.64 v1(134.37,119.02)
PROC_AUDIO_CLK_R: length 7.9
  TOP w0.089: 158.34,46.56 158.59,46.81 160.35,46.81 PCH.AM2
  TOP w0.102: 158.34,46.56 156.2,44.42 SR246.2
PROC_AUDIO_SDI: length 183.8
  TOP w0.102: HR28.1 152.27,43.9 145.2,43.9 144.77,44.34 136.81,44.34 v1(136.17,44.98) ; v1(132.49,86.44) 132.21,86.16 132.21,85.93 131.78,85.51 131.78,80.7 130.87,79.79 130.87,79.37 129.66,78.15 129.66,77.82 122.8,70.97 114.96,70.97 114.88,70.89 106.56,62.57 106.56,49.83 106.68,49.71 107.74,49.71 107.92,49.52 107.92,48.72 107.77,48.56 106.61,48.56 106.43,48.39 106.43,47.9 106.56,47.78 107.77,47.78 107.92,47.62 107.92,46.74 105.92,44.74 v1(105.92,43.64) ; v1(122.16,137.7) 122.16,139.23 122.23,139.3 122.23,141.69 122.19,141.72 122.19,142.07 122.38,142.26 122.38,142.72 122.71,143.05 XU1.V2 ; v1(133.65,119.96) 133.48,119.79 133.1,119.79 132.16,120.73 v1(123.14,120.73)
  BOTTOM w0.102: v1(123.14,120.73) 123.14,121.64 122.31,122.47 122.31,134.38 122.67,134.73 122.67,137.19 v1(122.16,137.7) ; v1(136.17,44.98) 136.15,44.96 136.15,44.57 135.63,44.04 122.74,44.04 122.33,43.64 108.63,43.64 v1(105.92,43.64) ; v1(132.49,86.44) 132.79,86.44 135.08,88.72 135.08,92.46 137.62,95 137.62,99.82 v2(138.1,100.3) 138.1,108.45 136.35,110.21 136.35,111.37 135.23,112.49 135.23,118.95 134.21,119.96 v1(133.65,119.96)
PROC_AUDIO_SDI_R: length 10.3
  TOP w0.089: PCH.AM3 160.68,46.49 160.29,46.49 160.18,46.6 158.65,46.6
  TOP w0.102: HR28.2 153.85,43.86 v1(154.63,43.86) 155.52,43.86 155.56,43.89 155.94,43.89 158.65,46.6
  BOTTOM w0.102: v2(155.61,44.92) 155.61,44.84 v1(154.63,43.86)
PROC_AUDIO_SDO: length 164.9
  TOP w0.089: PCH.AN2 160.28,46.22 160.14,46.37 159.89,46.37
  TOP w0.102: 159.89,46.37 159.07,46.37 156.11,43.41 155.76,43.41 155.44,43.1 153.81,43.1 153.74,43.03 152.43,43.03 152.04,43.42 144.92,43.42 144.5,43.84 136.09,43.84 135.46,44.47 v1(135.46,44.53) ; v1(133.43,119.23) 132.61,119.23 132.44,119.4 132.44,119.76 132.21,119.99 131.72,119.99 131.57,119.84 131.57,119.4 131.47,119.3 130.99,119.3 130.89,119.4 130.89,119.96 130.66,120.19 125.83,120.19 125.55,119.91 SR245.1 ; v1(104.45,43.65) 104.45,44.64 105.38,45.57 105.38,62.76 113.51,70.89 114.48,71.86 114.48,71.86 114.56,71.93 122.25,71.93 127.46,77.14 127.46,78.92 128.17,79.63 128.17,83.26 131.19,86.28 131.19,87.15 v1(132.89,88.85)
  BOTTOM w0.102: v1(135.46,44.53) 122.54,44.53 122.13,44.12 108.83,44.12 104.92,44.12 v1(104.45,43.65) ; v1(132.89,88.85) 133.45,88.85 134.11,89.51 134.11,92.86 136.65,95.4 136.65,101.63 136.91,101.88 v2(136.91,104.85) 136.91,108.28 135.38,109.81 135.38,110.97 134.26,112.09 134.26,118.39 v1(133.43,119.23)
PROC_AUDIO_SDO_R: length 34.7
  TOP w0.102: v1(122.48,120.68) 122.91,120.24 123.15,120.24 SR245.2 ; v1(121.8,135.76) 121.18,136.38 121.18,139.65 121.51,139.98 121.51,140.59 121.78,140.86 121.78,142.24 121.8,142.25 XU1.U1
  BOTTOM w0.102: v2(122.86,110.77) 121.67,111.96 121.67,119.23 122.48,120.04 v1(122.48,120.68) 121.8,121.35 v1(121.8,135.76)
PROC_SEL#: length 619.4
  TOP w0.102: v1(126.82,100.46) 126.95,100.33 PR312.2 ; v1(126.82,177.17) 126.84,177.17 XU1.AB36 ; v1(92.54,11.33) 92.54,13.5 95.72,16.68 95.72,17.68 96.71,18.67 96.71,22.36 97.39,23.04 97.39,38.31 104.64,45.56 104.64,62.7 114.38,72.44 119.89,72.44 125.49,78.04 125.49,78.39 126.39,79.29 126.39,83.44 127.39,84.44 127.39,85.23 128.41,86.25 129.81,86.25 v1(130.23,86.66) ; v1(211.91,56.44) 212.94,57.47 212.94,61.54 222.54,71.13 222.54,75.11 216.32,81.33 216.32,87.57 213.77,90.13 213.77,96.55 214.79,97.57 215.07,97.57 v1(215.49,97.99)
  BOTTOM w0.102: v1(126.82,177.17) 125.65,178.34 125.65,181.01 123.95,182.71 123.95,196.33 131.29,203.67 131.29,205.93 136.36,211 137.12,211 144.87,218.75 144.87,222.83 147.34,225.3 163.8,225.3 165.05,226.55 169.37,226.55 175.96,233.13 207.89,233.13 208.14,232.88 210.78,232.88 215.66,228 224.24,228 229.72,222.53 229.72,214.57 229.12,213.97 229.12,213.57 229.12,213.56 229.12,212.47 229.12,212.47 229.12,205.81 227.29,203.98 227.29,191.6 225.72,190.03 225.72,188.5 225.44,188.23 225.44,185.29 225.51,185.22 225.51,171.72 224.4,170.61 224.4,167.82 225.35,166.86 225.35,149.64 229.13,145.85 229.13,144.68 226.81,142.35 v2(226.81,141.85) 224.85,139.89 224.85,134.17 219.81,129.13 219.81,125.73 221.52,124.02 221.52,122.01 218.4,118.88 218.4,112.04 215.87,109.51 215.87,106.72 216.76,105.83 216.76,102.66 216.18,102.08 216.18,99.12 215.49,98.43 v1(215.49,97.99) ; v1(211.91,56.44) 212.38,55.97 212.38,52.5 215.24,49.64 215.24,46.48 216.14,45.58 216.14,33.89 215.66,33.41 215.66,31.43 215.79,31.3 215.79,28.94 212.17,25.32 208.12,25.32 204.7,21.9 204.7,20.24 201.06,16.59 199.48,16.59 199.27,16.39 189.33,16.39 187.97,15.02 183.44,15.02 182.64,14.22 181.87,14.22 180.6,14.22 178.84,14.22 178.84,14.22 176.22,14.22 174.6,14.22 174.31,13.93 172.67,13.93 171.8,13.06 171.8,12.89 171.18,12.27 171.05,12.27 170.28,11.51 170.28,11.28 167.41,8.41 162.75,8.41 155.56,15.6 151.24,15.6 149.97,14.33 148.33,14.33 147.41,13.41 141.18,13.41 137.16,9.39 121.94,9.39 121.7,9.62 120.91,10.42 116.7,10.42 115.9,11.21 105.87,11.21 105.27,10.62 104.48,10.62 104.08,11.02 102.98,11.02 102.32,10.36 98.72,10.36 97.95,11.14 93.9,11.14 93.7,11.33 v1(92.54,11.33) ; v1(126.82,100.46) 125.77,99.41 125.77,95.76 127.53,94 127.53,88.35 128.49,87.4 129.37,87.4 130.11,86.66 v1(130.23,86.66)
PROCHOT#: length 412.8
  TOP w0.102: C83.1 225.93,25.76 225.93,25.68 ECR104.2 227.03,25.29 v1(227.08,25.34) ; v1(211.96,55.58) 212.39,56.01 212.39,56.22 213.17,56.99 213.17,61.44 222.77,71.04 222.77,75.2 216.55,81.42 216.55,87.67 214,90.22 214,96.46 214.82,97.28 v1(215.49,97.28) ; v1(215.35,29.1) 220.36,29.1 v1(220.98,29.72) ; v1(92.43,210.41) 93.12,209.73 93.12,208.7 HR24.2 92.46,207.44 92.35,207.34 HR26.1 ; PR5822.1 87.11,221.77 v1(87.44,222.1) 87.72,222.38 PR5823.2 88.53,222.81 89.31,222.81 89.51,223.01 89.51,224.56 90.09,225.15 90.09,230.23 v1(90.27,230.4)
  BOTTOM w0.102: v1(211.96,55.58) 211.96,52.6 215.01,49.55 215.01,46.39 215.91,45.48 215.91,33.98 215.43,33.5 215.43,31.33 215.56,31.21 215.56,30.67 215.35,30.47 v1(215.35,29.1) ; v1(215.49,97.28) 216.18,97.97 216.34,97.97 216.78,98.4 216.78,99.12 216.62,99.27 216.62,101.9 217.21,102.48 217.21,106.01 216.31,106.91 216.31,109.32 218.85,111.86 218.85,118.48 221.97,121.6 221.97,124.22 220.26,125.93 220.26,128.95 225.34,134.03 225.34,139.18 228.93,142.77 v2(228.93,143.23) 229.58,143.88 229.58,146.04 225.79,149.82 225.79,166.12 227.3,167.63 227.3,175.71 227.23,175.79 227.23,184.13 225.88,185.48 225.88,188.04 226.16,188.32 226.16,189.85 227.74,191.42 227.74,202.87 229.57,204.69 229.57,212.65 229.56,212.65 229.56,213.38 229.57,213.38 229.57,213.79 230.16,214.38 230.16,222.71 224.43,228.45 215.9,228.45 210.4,233.95 208.98,233.95 208.82,233.79 175.51,233.79 169.26,227.55 158.86,227.55 157.81,228.6 150.01,228.6 149.47,229.15 146.33,229.15 146.28,229.1 136.53,229.1 135.76,229.86 117.51,229.86 117.34,230.04 100.52,230.04 100.44,229.96 98.29,229.96 98.01,230.24 94.12,230.24 93.99,230.11 90.57,230.11 v1(90.27,230.4) ; v1(92.43,210.41) 92.28,210.26 90.6,210.26 88.72,212.14 88.72,212.43 87.99,213.16 87.99,221.53 87.44,222.07 v1(87.44,222.1) ; v1(227.08,25.34) 226.62,25.34 226.36,25.59 226.36,26.34 225.88,26.82 224.18,26.82 222.43,28.57 221.68,28.57 220.98,29.28 v1(220.98,29.72)
PROCHOT#_R: length 40.6
  TOP w0.102: v1(92.43,205.23) 92.35,205.31 HR26.2 92.81,206.01 92.82,205.99 HC24.1 ; XU1.C39 109.27,180.11 109.27,181.99 109.04,182.22 108.61,182.22 v1(108.08,182.75)
  BOTTOM w0.102: v1(92.43,205.23) 92.43,206.02 92.05,206.4 v2(91.95,206.4) 91.57,206.4 90.51,205.35 90.51,203.49 93.98,200.03 93.98,194.36 105.59,182.75 v1(108.08,182.75)
PROCPWRGD: length 47
  TOP w0.102: HR86.1 101.96,116.6 v1(102.22,116.87) 101.93,117.16 HC23.1 ; v1(112.19,148.48) XU1.F8
  BOTTOM w0.102: v2(105.18,114.4) 104.36,114.4 102.22,116.54 v1(102.22,116.87) 102.22,117.87 102.63,118.28 102.63,124.12 103.2,124.69 103.2,126.96 102.7,127.45 102.7,132.39 106.34,136.03 106.34,144.56 106.5,144.72 106.5,148.72 107.3,149.52 109.51,149.52 110.14,148.88 111.79,148.88 v1(112.19,148.48)
PRSENT_SOLT1: length 101.9
  TOP w0.102: M2R40.2 60.18,75.58 57.73,78.03 57.73,79.64 59.67,81.58 v1(60.48,81.58) ; SLOT1.B81 126.6,81.17 126.6,83.35 127.6,84.35 127.6,85.14 128.5,86.03 130.26,86.03 130.71,86.48 130.71,87.48 130.28,87.91 129.89,87.91 129.03,87.05 96.27,87.05 95.66,86.44 95.66,84.2 94.45,82.99 v1(94.45,81.23) SLOT1.B48
  BOTTOM w0.102: v1(60.48,81.58) 62.19,81.58 SLOT1.B17 64.32,81.2 76.58,81.2 SLOT1.B31 78.32,81.2 94.42,81.2 v1(94.45,81.23)
PRSENT_SOLT4: length 76.9
  TOP w0.102: M2R44.2 63.45,16.65 SLOT4.B17 ; v1(129.57,17.74) 128.87,18.44 128.38,18.44 SLOT4.B81 ; SLOT4.B48 93.56,16.48 78.26,16.48 77.45,17.29 SLOT4.B31
  BOTTOM w0.102: SLOT4.B48 95.26,18.18 120.75,18.18 120.8,18.13 121.97,18.13 122.02,18.18 122.79,18.18 122.84,18.13 124.05,18.13 124.11,18.18 124.79,18.18 124.84,18.13 126.05,18.13 126.11,18.18 126.79,18.18 126.84,18.13 128.06,18.13 128.11,18.18 128.79,18.18 129.23,17.74 v1(129.57,17.74) ; SLOT4.B17 64.26,20.18 76.64,20.18 SLOT4.B31
PS_ON#: length 154.5
  TOP w0.102: v1(228.5,145.52) 229.16,146.18 P1R2.2 ; v1(214.68,33.97) 216.14,33.97 216.76,34.59 218.47,34.59 218.67,34.8 220.11,34.8 220.87,35.55 220.87,36.69 222.05,37.87 222.05,38.97 222.28,39.2 223.81,39.2 223.95,39.34 225.09,39.34 v1(225.17,39.27) ; v1(212.52,49.63) 210.66,49.63 210.16,50.13 MQ35.3 ; ECR98.1 225.53,35.64 224.71,35.64 224.51,35.43 224.51,34.96 v1(224.27,34.72) ; v1(212.7,92.05) 212.7,91.36 212.85,91.21 212.85,89.61 214.13,88.32 214.13,76.42 210.67,72.96 210.67,59 v1(210.34,58.67)
  BOTTOM w0.102: v1(210.34,58.67) 210.34,57.43 210.67,57.1 210.67,53.26 212.52,51.41 v1(212.52,49.63) 212.52,47.68 213.66,46.53 213.66,39.09 213.86,38.9 213.86,38.09 213.23,37.47 213.23,35.96 214.68,34.51 v1(214.68,33.97) ; v1(228.5,145.52) v2(227.59,144.6) 223.18,140.2 223.18,133.11 219.38,129.31 219.38,124.31 219.52,124.16 219.52,122.29 217.97,120.74 217.97,112.22 215.43,109.69 215.43,106.54 216.33,105.65 216.33,102.84 215.75,102.26 215.75,99.3 213.28,96.83 213.28,94.26 212.34,93.32 212.34,92.63 212.7,92.28 v1(212.7,92.05) ; v1(225.17,39.27) 225.29,39.15 225.29,35.74 v1(224.27,34.72)
PS_ON#_C: length 38.3
  TOP w0.102: v1(214.91,30.94) 214.91,31.4 215.9,32.4 219.52,32.4 221.56,34.44 U104.53 223.68,34.44 223.87,34.25 224.57,34.25 224.74,34.42 224.74,34.82 ECR98.2 ; MQ35.2 209.48,50.78 209.19,50.5 v1(209.19,49.4) 209.6,49 OR69.2
  BOTTOM w0.102: v1(209.19,49.4) 209.51,49.09 209.51,47.04 212.97,43.59 212.97,38.85 212.8,38.69 212.8,35.78 213.61,34.97 213.61,34.28 v2(213.26,33.93) 213.26,32.97 213.54,32.69 213.54,32.48 214.91,31.11 v1(214.91,30.94)
PSW_EN#: length 77.6
  TOP w0.089: PCH.BG11 164.95,39.26 164.95,38.7 164.93,38.68 164.93,38.66 164.88,38.61 164.88,37.97
  TOP w0.102: P215.1 122.3,8.81 123.97,10.49 v1(127.96,10.49) ; 164.88,37.97 164.88,36.84 163.33,35.29 163.33,34.71 161.34,32.72 161.34,30.73 160.46,29.86 160.46,29.27 160.29,29.09 160.29,28.5 160.07,28.28 160.07,27.67 SR375.2 159.26,27.7 158.54,27.7 158.14,27.29 v1(158.14,27.05) ; v1(140.13,22.73) 140.46,22.4 140.46,21.55 140.61,21.4 140.61,21.4 142.17,19.84 142.17,18.48 145.41,15.24 145.67,15.24 v1(146.2,14.71)
  BOTTOM w0.102: v1(140.13,22.73) 140.12,22.74 140.12,22.78 140.97,23.62 v2(145.03,23.62) 145.32,23.62 145.5,23.44 149.02,23.44 149.79,24.21 153.55,24.21 155.9,26.56 156.26,26.56 157.65,26.56 v1(158.14,27.05) ; v1(127.96,10.49) 128.22,10.23 136.52,10.23 140.62,14.33 145.82,14.33 v1(146.2,14.71)
PWRBTN#: length 503
  TOP w0.102: SW1.2 SW1.1 125.14,25.34 128.55,25.34 129.13,24.76 129.85,24.04 130.36,24.04 132.49,21.91 132.49,21.66 135.78,18.37 135.78,12.71 136.56,11.92 136.56,11.76 138.64,9.68 v1(139.36,9.68) 139.56,9.47 144.04,9.47 145.02,10.45 149.22,10.45 150.58,9.09 150.58,8.28 150.98,7.89 168.46,7.89 171.63,11.06 171.63,13 v1(171.15,13.49) ; SW1.2 117.18,27.42 UCR47.2 ; SW1.2 119.25,27.77 119.25,28.27 118.75,28.77 118.62,28.77 118.22,29.17 118.22,31.69 119.68,33.15 v1(119.68,34.14) ; v1(140.23,35.31) 141.99,35.31 145.36,38.68 146.49,38.68 SR7630.2 SC105.1 148.34,39.62 152.27,39.62 152.44,39.79 157.07,39.79 v1(157.91,38.96) ; PCH.BC5 161.82,41.67 v1(162.05,41.91) ; v1(60.64,8.42) 60.64,9.6 60.06,10.19 59.9,10.19 O3R5.1 AC197.1 ; v1(221.77,26.87) 221.8,26.84 U104.34 223.78,26.84 224.28,26.34 224.28,25.16 225.07,24.37 O2CB15.1 ; v1(194.25,16.82) 194.25,14.45 v1(192.69,12.89) ; v1(29.59,60.33) 29.59,60.95 32.56,63.92 32.56,71 28.87,74.69 28.87,93.21 35.25,99.59 43.03,99.59 49.02,105.59 51.45,105.59 54.66,108.8 72.42,108.8 75.16,111.54 77.6,111.54 78.31,110.83 83.09,110.83 83.55,111.29 85.18,111.29 XDP2.41
  BOTTOM w0.089: v1(157.91,38.96) 157.91,39.52 160.42,42.03 161.93,42.03 v1(162.05,41.91)
  BOTTOM w0.102: v1(139.36,9.68) 137.94,8.26 121.47,8.26 120.57,9.16 120.44,9.29 119.71,9.29 119.71,9.29 116.23,9.29 115.43,10.08 106.37,10.08 106.33,10.05 105.65,9.36 105.18,9.36 103.8,9.36 103.57,9.13 95.37,9.13 94.5,9.99 92.59,9.99 92.51,9.91 83.42,9.91 82.55,9.04 74.94,9.04 74.6,8.7 60.92,8.7 v1(60.64,8.42) ; v1(194.25,16.82) 189.44,16.82 187.85,15.24 183.35,15.24 182.55,14.44 181.78,14.44 180.69,14.44 178.75,14.44 178.75,14.44 176.31,14.44 174.51,14.44 174.22,14.15 172.49,14.15 171.83,13.49 v1(171.15,13.49) ; v1(192.69,12.89) 196.26,12.89 196.66,12.48 198.68,12.48 199.77,11.39 201.73,11.39 201.98,11.64 209.59,11.64 212.15,14.2 212.15,17.96 212.58,18.38 219.6,18.38 221.51,20.29 221.51,25.63 221.87,25.98 221.87,26.77 v1(221.77,26.87) ; v1(29.59,60.33) 29.59,59.18 29.21,58.8 29.21,57.15 v2(29.46,56.9) 29.57,56.79 29.57,54.52 28.96,53.91 28.96,50.23 45,34.19 81.89,34.19 82.79,35.09 107.43,35.09 108.07,34.44 113.2,34.44 113.49,34.72 119.09,34.72 v1(119.68,34.14) 119.97,34.43 121.12,34.43 121.67,33.88 130.17,33.88 130.49,34.2 139.13,34.2 v1(140.23,35.31)
RBIAS: length 3.2
  TOP w0.203: U10.10 33.18,218.18 33.05,218.31 32.31,218.31 31.55,219.07 LR24.1
REGREF: length 3.7
  TOP w0.254: AU1.3 21.62,13.82
  TOP w0.508: AC188.1 v1(22.17,13.71) 21.73,13.71 21.62,13.82
  BOTTOM w0.102: v2(22.96,13.71) v1(22.17,13.71)
REMOTE1+: length 62.2
  TOP w0.127: U104.41 223.76,29.64 224.9,28.5 225.06,28.5 O2C5.1 v1(225.23,27.64) ; AMB_Q1.1 227.5,77.84 228.45,76.89 AMB_Q1.3 228.73,75.83 228.16,75.26 O2C4.1 228.16,72.27 223.93,68.05 223.93,53.37 223.01,52.45 v1(222.25,52.45)
  BOTTOM w0.127: v1(222.25,52.45) 222.25,52.13 221.69,51.57 221.69,47.67 223.63,45.73 223.63,43.04 221.85,41.25 221.85,36.25 221.56,35.97 221.56,33.4 222.07,32.89 222.07,29.95 v2(223.6,28.42) 224.38,27.64 v1(225.23,27.64)
REMOTE1-: length 59.3
  TOP w0.127: U104.42 223.72,30.04 225.01,28.75 225.64,28.75 O2C5.2 v1(226.07,27.64) ; AMB_Q1.2 226.91,75.94 227.32,75.53 O2C4.2 227.32,71.79 223.68,68.16 223.68,53.88 v1(222.88,53.09)
  BOTTOM w0.127: v1(222.88,53.09) 222.88,52.4 221.95,51.46 221.95,47.78 223.89,45.84 223.89,42.93 222.1,41.14 222.1,36.14 221.82,35.86 221.82,33.55 222.61,32.77 v2(222.61,30.35) 222.99,30.35 225.09,28.24 225.46,28.24 v1(226.07,27.64)
REMOTE2+: length 298.8
  TOP w0.127: v1(143.74,97.66) 144.25,97.16 153.26,97.16 154.28,98.17 v1(154.28,98.58) ; v1(129.77,61.6) 129.77,63.78 140.89,74.91 140.89,83.46 147.7,90.27 147.83,90.27 v1(148.06,90.04) ; v1(211.71,76.71) 211.71,76.86 211.79,76.94 211.79,87.83 210.64,88.97 210.64,94.29 210.95,94.59 v1(211.81,94.59) ; v1(226.07,69.15) 226.07,68.72 224.95,67.6 224.95,53.02 223.82,51.89 223.22,51.89 222.91,51.58 v1(222.91,50.88) ; U104.43 223.74,30.44 223.95,30.23 223.95,30.17 225.11,29.01 226.43,29.01 O2C1.1 226.33,29.97 225.91,29.97 v1(225.75,30.12) ; GFX_Q1.3 66.22,74.88 65.9,74.56 GFX_Q1.1 65.9,71.83 O2C2.1 66.83,70.9 66.83,70.43 66.62,70.23 65.15,70.23 64.49,69.57 64.49,69.22 v1(64.3,69.03)
  BOTTOM w0.127: v1(64.3,69.03) 64.52,68.81 64.52,67.17 65.22,66.47 68.12,66.47 69.39,65.2 69.39,63.92 70.25,63.07 70.25,61.73 70.97,61.01 71.58,61.01 72.25,60.34 72.25,59.34 73.25,58.34 73.25,57.28 74.69,55.84 115.46,55.84 116.08,56.46 124.31,56.46 128.96,61.11 129.28,61.11 v1(129.77,61.6) ; v1(154.28,98.58) 154.79,99.09 154.79,99.82 161.17,106.21 170.41,106.21 171.17,105.45 171.17,104.85 174.88,101.13 196.51,101.13 198.3,99.34 199.87,99.34 201.09,100.56 203.98,100.56 204.72,99.82 206.04,99.82 211.28,94.59 v1(211.81,94.59) ; v1(211.71,76.71) 211.96,76.71 212.35,76.32 220.15,76.32 225.25,71.22 v2(225.25,70.87) 226.07,70.04 v1(226.07,69.15) ; v1(222.91,50.88) 222.91,48.17 224.6,46.48 224.6,42.63 222.9,40.93 222.9,35.47 222.77,35.34 222.77,34.1 223.32,33.55 223.32,31.55 224.21,30.66 225.22,30.66 v1(225.75,30.12) ; v1(148.06,90.04) 148.06,90.5 143.26,95.3 143.26,97.18 v1(143.74,97.66)
REMOTE2-: length 292.7
  TOP w0.127: v1(225.02,30.18) 225.55,29.64 225.82,29.64 O2C1.2 225.92,29.34 225.14,29.34 224.18,30.3 224.18,30.4 223.74,30.84 U104.44 ; v1(223.42,51.41) 223.74,51.41 225.2,52.88 225.2,67.47 226.72,68.98 v1(226.72,69.65) ; v1(212.37,77.04) 212.04,77.37 212.04,87.93 210.9,89.08 210.9,93.78 v1(211.23,94.11) ; v1(148.87,90.07) 148.41,90.53 147.57,90.53 140.64,83.59 140.64,75.01 129.51,63.88 129.51,62.02 v1(129.09,61.6) ; GFX_Q1.2 67.8,71.57 O2C2.2 67.08,70.85 67.08,70.33 66.73,69.98 65.25,69.98 64.74,69.47 64.74,69.33 v1(65.07,69) ; v1(143.76,96.9) 153.37,96.9 v1(155.04,98.58)
  BOTTOM w0.127: v1(211.23,94.11) 206.02,99.31 v2(205.56,99.31) 204.87,99.31 203.88,100.31 201.2,100.31 199.97,99.08 198.2,99.08 196.4,100.88 174.78,100.88 170.92,104.74 170.92,105.34 170.3,105.96 161.28,105.96 155.04,99.72 v1(155.04,98.58) ; v1(225.02,30.18) 224.33,30.18 223.06,31.44 223.06,33.45 222.52,34 222.52,35.45 222.64,35.58 222.64,41.03 224.35,42.74 224.35,46.37 222.4,48.31 222.4,51.13 222.68,51.41 v1(223.42,51.41) ; v1(148.87,90.07) 143.51,95.43 143.51,96.65 v1(143.76,96.9) ; v1(65.07,69) 64.8,68.73 64.8,67.25 65.33,66.73 68.23,66.73 69.65,65.31 69.65,64.03 70.5,63.17 70.5,61.86 71.09,61.27 71.68,61.27 72.5,60.45 72.5,59.45 73.5,58.45 73.5,57.39 74.8,56.09 115.35,56.09 115.98,56.72 124.21,56.72 v1(129.09,61.6) ; v1(212.37,77.04) 212.82,76.59 220.26,76.59 226.72,70.13 v1(226.72,69.65)
REXT: length 3.3
  TOP w0.254: U4.59 38.02,139.7 38.42,139.29 38.87,139.29 v1(38.89,139.28) 39.55,138.62 UR69686.2
  BOTTOM w0.254: v1(38.89,139.28) 38.85,139.32 38.7,139.32 v2(38.16,139.85)
REXT_CC: length 5.5
  TOP w0.178: AR247.2 22.05,151.35 v1(22.05,151.1) 21.48,150.53 20.54,150.53 20.2,150.19 U5.9
  BOTTOM w0.178: v2(20.92,152.23) v1(22.05,151.1)
ROLE_SEL: length 5.6
  TOP w0.102: U5.15 17.8,150.22 15.78,152.23 AR241.1 15.37,151.51 v1(15.65,151.23)
  BOTTOM w0.102: v2(15.65,152.02) v1(15.65,151.23)
RTCRST#: length 69.7
  TOP w0.102: v1(161.93,37.57) 161.93,37.49 159.13,34.7 159.13,34.15 154.64,29.65 154.64,29.65 153.63,28.64 SR101.2 153.63,27.67 SC103.1 153.26,26.29 153.26,25.32 v1(153.43,25.16) ; v1(129.39,10.65) 128.6,9.85 P216.1 ; v1(144.88,15.04) 141.1,18.82 141.1,20.42 139.45,22.07 v1(139.45,23.11) ; v1(163.27,40.77) 163.42,40.61 PCH.BE8
  BOTTOM w0.102: v1(144.88,15.04) 140.69,15.04 136.3,10.65 v1(129.39,10.65) ; v1(139.45,23.11) 140.46,24.13 v2(140.72,24.13) 145.31,24.13 145.64,23.8 148.85,23.8 150.21,25.16 v1(153.43,25.16) ; v1(161.93,37.57) 161.93,37.72 163.27,39.06 v1(163.27,40.77)
RTCX1_NO_IO_HS_S20MIL: length 18.4
  TOP w0.089: PCH.BF7 162.77,39.58 162.67,39.49 162.67,39.23 160.78,37.34 160.39,37.34
  TOP w0.102: SR44.2 152.62,32.11 SC6.1 152.97,31.27 SR45.1 153.5,31.08 v1(153.87,31.45) 154.81,32.38 154.81,34.55 155.45,35.18 156.87,35.18 157.03,35.34 158.04,35.34 160.04,37.34 160.39,37.34
  BOTTOM w0.102: v1(153.87,31.45) 153.44,31.88 v2(153.44,32.77)
RTCX2_NO_IO_HS_S20MIL: length 19.1
  TOP w0.089: 161.44,37.72 162.92,39.2 PCH.BG7
  TOP w0.102: 161.44,37.72 160.81,37.08 160.66,37.08 158.3,34.73 157.28,34.73 157.12,34.57 155.7,34.57 155.44,34.31 v1(155.44,34.14) 155.44,32.15 153.75,30.45 153.38,30.45 SR45.2 152.96,30.04 SC7.1 151.66,29.55 Y5.4
  BOTTOM w0.102: v2(156.26,33.4) 155.85,33.82 155.76,33.82 v1(155.44,34.14)
S/PDIF_OUT: length 246.3
  TOP w0.254: AU1.48 18.75,10.58 19.3,10.03 v1(20.12,10.03) ; v1(23.62,225.07) 21.62,225.07 20.98,225.7 17.28,225.7 AC186.1 16,227.46 15.52,227.94 AR20.1
  BOTTOM w0.254: v1(23.62,225.07) v2(24.18,224.51) 24.18,219.94 26.95,217.17 26.95,214.33 30.51,210.78 30.51,207.11 28.46,205.07 28.46,200.27 22.33,194.13 22.33,178.54 21.41,177.62 20.07,177.62 16.32,173.87 16.32,170.21 17.36,169.16 17.36,163.31 16.44,162.39 16.44,160.2 20.47,156.17 20.47,155.47 21.86,154.08 21.86,153.13 21.54,152.81 20.68,152.81 20.35,152.47 20.35,149.43 20.37,149.4 20.37,146.18 19.81,145.62 19.81,140.83 23.18,137.46 23.18,136.17 23.84,135.52 23.84,128.15 22.73,127.04 22.73,124.76 22.45,124.49 22.45,121.68 20.64,119.86 20.64,112.94 20.95,112.62 20.95,56.54 21.54,55.96 21.54,39.66 22.02,39.18 22.02,31.75 22.54,31.23 22.54,28.74 22.2,28.4 22.2,26.21 21.06,25.07 21.06,19.86 19.73,18.54 19.73,10.42 v1(20.12,10.03)
S/PDIF_OUT_B: length 6.8
  TOP w0.254: AR20.2 13.23,227.94 11.72,226.43 S/PDIF.1
S/PDIF_OUT_R: length 6.1
  TOP w0.254: AR228.2 AR227.2 14.19,222.38 AC185.2 14.19,221.37 S/PDIF.5
S_PECI_REQ#: length 71.4
  TOP w0.102: U104.20 216.54,26.11 215.95,26.7 214.88,26.7 v1(213.42,28.16) ; v1(214.25,31.01) 213.66,31.6 212.27,31.6 211.34,32.52 209.11,32.52 v1(208.81,32.22) ; v1(167.31,22.72) 166.93,23.1 166.93,26.5 166.47,26.96 166.47,31.01 166.08,31.41 SR7656.1
  BOTTOM w0.102: v1(213.42,28.16) 213.96,28.16 214.25,28.45 v2(214.25,28.51) v1(214.25,31.01) ; v1(208.81,32.22) 208.3,32.22 205.56,29.49 201.92,29.49 200.38,27.95 199.52,27.95 196.58,25.01 182.14,25.01 180.07,22.94 177.38,22.94 176.04,21.6 169.75,21.6 169.04,22.3 167.73,22.3 v1(167.31,22.72)
SA_DAC: length 307.6
  TOP w0.102: v1(145.44,19.48) 145.44,20.55 132.03,33.96 132.03,40.61 126.81,45.82 122.67,45.82 121.91,46.59 121.91,58.06 120.57,59.4 119.18,59.4 117.98,58.2 117.98,57.66 117.67,57.34 117.67,56.07 117.47,55.88 PC570.1 117.25,55.3 117.58,54.96 PU12.7 ; PR70188.2 61.56,119.01 61.04,118.49 61.04,115.52 60.93,115.42 60.93,115.05 60.56,114.68 60.19,114.68 58.17,112.66 53.4,112.66 49.95,109.21 47.18,109.21 44.6,106.63 44.42,106.63 44.42,106.63 36.01,106.63 24.31,94.93 24.31,62.99 24.73,62.58 24.73,59.14 22.19,56.6 22.19,39.05 v1(26.14,35.1)
  BOTTOM w0.102: v1(145.44,19.48) 144.51,18.55 137.04,18.55 134.14,15.66 132.26,15.66 132.17,15.75 130.95,15.75 130.14,14.94 122.62,14.94 121.86,14.19 105.96,14.19 105.56,14.59 91.86,14.59 91.03,13.75 88.51,13.75 88.11,14.16 61.86,14.16 61.77,14.06 60.23,14.06 59.99,14.3 40.84,14.3 29.06,26.08 29.06,27.16 26.67,29.55 v2(26.67,30.28) 26.67,34.57 v1(26.14,35.1)
SA_SET: length 8.7
  TOP w0.102: v1(120.75,55.11) 119.58,53.94 119.58,53.06 PR6605.2 120.77,51.87 120.77,50.98 120.47,50.68 PR6603.1 119.08,50.68 118.88,50.88 PU12.4
  BOTTOM w0.102: v1(120.75,55.11) 121.03,55.4 v2(121.79,55.4)
