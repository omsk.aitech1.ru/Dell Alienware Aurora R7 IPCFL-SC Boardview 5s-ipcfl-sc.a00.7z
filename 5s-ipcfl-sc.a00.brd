# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
A_USB_CON_2X12P_8HOLD_ACON
  round 0.762 hole 0.762 unplated: (-3.6,0) (3.6,0)
  oval 1.6x0.813 hole 1.245x0.457: 1(-3.47,1.55) 2(3.47,1.55)
  oval 1.346x1.905 hole 0.991x1.549: 3(-4.43,-1.25) 4(4.43,-1.25)
  oval 1.092x2.489 hole 0.61x1.194: 5(-4.575,-4.45) 6(4.575,-4.45)
  rect 0.305x0.787 smd: A1(-2.75,0.6) A2(-2.25,0.6) A3(-1.75,0.6) A4(-1.25,0.6) A5(-0.75,0.6) A6(-0.25,0.6) A7(0.25,0.6) A8(0.75,0.6) A9(1.25,0.6) A10(1.75,0.6) A11(2.25,0.6) A12(2.75,0.6) B1(2.75,-0.5) B2(2.25,-0.5) B3(1.75,-0.5) B4(1.25,-0.5) B5(0.75,-0.5) B6(0.25,-0.5) B7(-0.25,-0.5) B8(-0.75,-0.5) B9(-1.25,-0.5) B10(-1.75,-0.5) B11(-2.25,-0.5) B12(-2.75,-0.5)
BGA_885P_909X949_N
  round 0.305 smd: A2(10.46,-11.314) A3(9.959,-11.314) A4(9.459,-11.314) A42(-9.459,-11.314) A43(-9.959,-11.314) A44(-10.46,-11.314) AA17(3.099,-1.549) AA18(2.324,-1.549) AA20(1.549,-1.549) AA21(0.775,-1.549) AA23(0,-1.549) AA25(-0.775,-1.549) AA26(-1.549,-1.549) AA28(-2.324,-1.549) AA29(-3.099,-1.549) AB17(3.099,-0.775) AB18(2.324,-0.775) AB20(1.549,-0.775) AB21(0.775,-0.775) AB23(0,-0.775) AB25(-0.775,-0.775) AB26(-1.549,-0.775) AB28(-2.324,-0.775) AB29(-3.099,-0.775) AC7(8.175,-0.705) AC8(7.413,-0.705) AC10(6.651,-0.705) AC11(5.889,-0.705) AC13(5.127,-0.705) AC14(4.365,-0.705) AC16(3.705,-0.705) AC30(-3.705,-0.705) AC32(-4.365,-0.705) AC33(-5.127,-0.705) AC35(-5.889,-0.705) AC36(-6.651,-0.705) AC38(-7.413,-0.705) AC39(-8.175,-0.705) AD17(3.099,0) AD18(2.324,0) AD20(1.549,0) AD21(0.775,0) AD23(0,0) AD25(-0.775,0) AD26(-1.549,0) AD28(-2.324,0) AD29(-3.099,0) AE7(8.175,0.705) AE8(7.413,0.705) AE10(6.651,0.705) AE11(5.889,0.705) AE13(5.127,0.705) AE14(4.365,0.705) AE16(3.705,0.705) AE30(-3.705,0.705) AE32(-4.365,0.705) AE33(-5.127,0.705) AE35(-5.889,0.705) AE36(-6.651,0.705) AE38(-7.413,0.705) AE39(-8.175,0.705) AF17(3.099,0.775) AF18(2.324,0.775) AF20(1.549,0.775) AF21(0.775,0.775) AF23(0,0.775) AF25(-0.775,0.775) AF26(-1.549,0.775) AF28(-2.324,0.775) AF29(-3.099,0.775) AG17(3.099,1.549) AG18(2.324,1.549) AG20(1.549,1.549) AG21(0.775,1.549) AG23(0,1.549) AG25(-0.775,1.549) AG26(-1.549,1.549) AG28(-2.324,1.549) AG29(-3.099,1.549) AH7(8.175,1.772) AH8(7.413,1.772) AH10(6.651,1.772) AH11(5.889,1.772) AH13(5.127,1.772) AH14(4.365,1.772) AH16(3.705,1.772) AH30(-3.705,1.772) AH32(-4.365,1.772) AH33(-5.127,1.772) AH35(-5.889,1.772) AH36(-6.651,1.772) AH38(-7.413,1.772) AH39(-8.175,1.772) AJ17(3.099,2.324) AJ18(2.324,2.324) AJ20(1.549,2.324) AJ21(0.775,2.324) AJ23(0,2.324) AJ25(-0.775,2.324) AJ26(-1.549,2.324) AJ28(-2.324,2.324) AJ29(-3.099,2.324) AK7(8.074,3.093) AK8(7.312,3.093) AK10(6.55,3.093) AK11(5.788,3.093) AK13(5.026,3.093) AK14(4.264,3.093) AK16(3.705,3.093) AK17(3.099,3.099) AK18(2.324,3.099) AK20(1.549,3.099) AK21(0.775,3.099) AK23(0,3.099) AK25(-0.775,3.099) AK26(-1.549,3.099) AK28(-2.324,3.099) AK29(-3.099,3.099) AK30(-3.705,3.093) AK32(-4.365,3.093) AK33(-5.127,3.093) AK35(-5.889,3.093) AK36(-6.651,3.093) AK38(-7.413,3.093) AK39(-8.175,3.093) AM7(8.074,4.071) AM8(7.312,4.071) AM10(6.55,4.071) AM11(5.788,4.071) AM13(5.026,4.071) AM14(4.264,4.071) AM17(3.093,4.205) AM19(1.772,4.205) AM22(0.705,4.205) AM24(-0.705,4.205) AM27(-1.772,4.205) AM29(-3.093,4.205) AM32(-4.34,4.096) AM33(-5.102,4.096) AM35(-5.864,4.096) AM36(-6.626,4.096) AM38(-7.388,4.096) AM39(-8.15,4.096) AN14(4.658,4.545) AP7(8.048,5.036) AP8(7.312,4.985) AP10(6.55,4.985) AP11(5.788,4.985) AP13(5.026,4.985) AP15(4.096,4.84) AP17(3.093,4.866) AP19(1.772,4.866) AP22(0.705,4.866) AP24(-0.705,4.866) AP27(-1.772,4.866) AP29(-3.093,4.764) AP31(-4.21,4.816) AP33(-5.106,4.913) AP34(-5.708,5.087) AP36(-6.47,5.087) AP38(-7.232,5.087) AP39(-7.994,5.087) AR13(4.94,5.591) AR15(4.096,5.602) AR17(3.093,5.628) AR19(1.772,5.628) AR22(0.705,5.628) AR24(-0.705,5.628) AR27(-1.772,5.628) AR29(-3.093,5.526) AR31(-4.071,5.526) AR33(-4.799,5.408) AT7(8.048,6.077) AT8(7.312,6.027) AT10(6.55,6.027) AT13(5.087,6.208) AT35(-5.955,6.192) AT37(-6.779,6.134) AT38(-7.37,6.068) AT39(-8.132,6.068) AU11(6.068,6.372) AU15(4.096,6.364) AU17(3.093,6.39) AU19(1.772,6.39) AU22(0.705,6.39) AU24(-0.705,6.39) AU27(-1.772,6.39) AU29(-3.093,6.288) AU31(-4.071,6.288) AU33(-4.985,6.237) AV7(8.048,7.119) AV8(7.286,7.119) AV10(6.664,7.08) AV11(6.068,7.134) AV13(5.087,6.97) AV15(4.096,7.126) AV17(3.093,7.152) AV19(1.772,7.152) AV22(0.705,7.152) AV24(-0.705,7.152) AV27(-1.772,7.152) AV29(-3.093,7.05) AV31(-4.071,7.05) AV33(-4.985,6.999) AV35(-6.027,6.999) AV38(-7.444,7.149) AV39(-8.158,7.09) AY8(7.217,7.967) AY11(6.068,7.896) AY13(5.087,7.732) AY15(4.096,7.888) AY17(3.093,7.914) AY19(1.772,7.914) AY22(0.705,7.914) AY24(-0.705,7.914) AY27(-1.772,7.914) AY29(-3.093,7.812) AY31(-4.071,7.812) AY33(-4.985,7.761) AY35(-6.027,7.761) AY37(-7.103,7.863) AY39(-8.182,8.08) B1(10.814,-10.96) B2(10.33,-10.83) B3(9.824,-10.826) B4(9.318,-10.82) B43(-9.8,-10.804) B44(-10.33,-10.83) B45(-10.814,-10.96) BA6(8.392,8.369) BA9(7.11,8.658) BA11(6.068,8.658) BA13(5.087,8.494) BA15(4.096,8.65) BA17(3.093,8.676) BA19(1.772,8.676) BA22(0.705,8.676) BA24(-0.705,8.676) BA27(-1.772,8.676) BA29(-3.093,8.574) BA31(-4.071,8.574) BA33(-5.036,8.523) BA35(-6.077,8.523) BA37(-7.141,8.537) BA39(-7.76,8.469) BB7(8.072,8.843) BB40(-8.494,9.022) BC3(9.886,9.463) BC5(9,9.472) BC42(-9.285,9.604) BC43(-9.79,9.538) BD1(10.814,9.959) BD2(10.288,9.781) BD4(9.448,9.722) BD45(-10.814,9.959) BE1(10.814,10.459) BE2(10.326,10.324) BE4(9.272,10.255) BE41(-9.073,10.241) BE44(-10.304,10.3) BE45(-10.814,10.459) BF1(10.814,10.96) BF2(10.33,10.83) BF3(9.8,10.804) BF42(-9.318,10.82) BF43(-9.824,10.826) BF44(-10.33,10.83) BF45(-10.814,10.96) BG2(10.46,11.314) BG3(9.959,11.314) BG4(9.459,11.314) BG42(-9.459,11.314) BG43(-9.959,11.314) BG44(-10.46,11.314) C1(10.814,-10.459) C2(10.304,-10.3) C5(9.073,-10.241) C42(-9.272,-10.255) C44(-10.326,-10.324) C45(-10.814,-10.459) D1(10.814,-9.959) D42(-9.448,-9.722) D44(-10.288,-9.781) D45(-10.814,-9.959) E3(9.79,-9.538) E4(9.285,-9.604) E41(-9,-9.472) E43(-9.886,-9.463) F6(8.494,-9.022) F39(-8.072,-8.843) G7(7.76,-8.469) G9(7.141,-8.537) G11(6.077,-8.523) G13(5.036,-8.523) G15(4.071,-8.574) G17(3.093,-8.574) G19(1.772,-8.676) G22(0.705,-8.676) G24(-0.705,-8.676) G27(-1.772,-8.676) G29(-3.093,-8.676) G31(-4.096,-8.65) G33(-5.087,-8.494) G35(-6.068,-8.658) G37(-7.11,-8.658) G40(-8.392,-8.369) H7(8.182,-8.08) H9(7.103,-7.863) H11(6.027,-7.761) H13(4.985,-7.761) H15(4.071,-7.812) H17(3.093,-7.812) H19(1.772,-7.914) H22(0.705,-7.914) H24(-0.705,-7.914) H27(-1.772,-7.914) H29(-3.093,-7.914) H31(-4.096,-7.888) H33(-5.087,-7.732) H35(-6.068,-7.896) H38(-7.217,-7.967) K7(8.158,-7.09) K8(7.444,-7.149) K11(6.027,-6.999) K13(4.985,-6.999) K15(4.071,-7.05) K17(3.093,-7.05) K19(1.772,-7.152) K22(0.705,-7.152) K24(-0.705,-7.152) K27(-1.772,-7.152) K29(-3.093,-7.152) K31(-4.096,-7.126) K33(-5.087,-6.97) K35(-6.068,-7.134) K36(-6.664,-7.08) K38(-7.286,-7.119) K39(-8.048,-7.119) L13(4.985,-6.237) L15(4.071,-6.288) L17(3.093,-6.288) L19(1.772,-6.39) L22(0.705,-6.39) L24(-0.705,-6.39) L27(-1.772,-6.39) L29(-3.093,-6.39) L31(-4.096,-6.364) L35(-6.068,-6.372) M7(8.132,-6.068) M8(7.37,-6.068) M9(6.779,-6.134) M11(5.955,-6.192) M33(-5.087,-6.208) M36(-6.55,-6.027) M38(-7.312,-6.027) M39(-8.048,-6.077) N13(4.799,-5.408) N15(4.071,-5.526) N17(3.093,-5.526) N19(1.772,-5.628) N22(0.705,-5.628) N24(-0.705,-5.628) N27(-1.772,-5.628) N29(-3.093,-5.628) N31(-4.096,-5.602) N33(-4.94,-5.591) P7(7.994,-5.087) P8(7.232,-5.087) P10(6.47,-5.087) P12(5.708,-5.087) P13(5.106,-4.913) P15(4.21,-4.816) P17(3.093,-4.764) P19(1.772,-4.866) P22(0.705,-4.866) P24(-0.705,-4.866) P27(-1.772,-4.866) P29(-3.093,-4.866) P31(-4.096,-4.84) P33(-5.026,-4.985) P35(-5.788,-4.985) P36(-6.55,-4.985) P38(-7.312,-4.985) P39(-8.048,-5.036) R32(-4.658,-4.545) T7(8.15,-4.096) T8(7.388,-4.096) T10(6.626,-4.096) T11(5.864,-4.096) T13(5.102,-4.096) T14(4.34,-4.096) T17(3.093,-4.205) T19(1.772,-4.205) T22(0.705,-4.205) T24(-0.705,-4.205) T27(-1.772,-4.205) T29(-3.093,-4.205) T32(-4.264,-4.071) T33(-5.026,-4.071) T35(-5.788,-4.071) T36(-6.55,-4.071) T38(-7.312,-4.071) T39(-8.074,-4.071) V7(8.175,-3.093) V8(7.413,-3.093) V10(6.651,-3.093) V11(5.889,-3.093) V13(5.127,-3.093) V14(4.365,-3.093) V16(3.705,-3.093) V17(3.099,-3.099) V18(2.324,-3.099) V20(1.549,-3.099) V21(0.775,-3.099) V23(0,-3.099) V25(-0.775,-3.099) V26(-1.549,-3.099) V28(-2.324,-3.099) V29(-3.099,-3.099) V30(-3.705,-3.093) V32(-4.264,-3.093) V33(-5.026,-3.093) V35(-5.788,-3.093) V36(-6.55,-3.093) V38(-7.312,-3.093) V39(-8.074,-3.093) W17(3.099,-2.324) W18(2.324,-2.324) W20(1.549,-2.324) W21(0.775,-2.324) W23(0,-2.324) W25(-0.775,-2.324) W26(-1.549,-2.324) W28(-2.324,-2.324) W29(-3.099,-2.324) Y7(8.175,-1.772) Y8(7.413,-1.772) Y10(6.651,-1.772) Y11(5.889,-1.772) Y13(5.127,-1.772) Y14(4.365,-1.772) Y16(3.705,-1.772) Y30(-3.705,-1.772) Y32(-4.365,-1.772) Y33(-5.127,-1.772) Y35(-5.889,-1.772) Y36(-6.651,-1.772) Y38(-7.413,-1.772) Y39(-8.175,-1.772)
  round 0.279 smd: A5(8.959,-11.314) A41(-8.959,-11.314) BC1(10.814,9.459) BC45(-10.814,9.459) BG5(8.959,11.314) BG41(-8.959,11.314) E1(10.814,-9.459) E45(-10.814,-9.459)
  round 0.254 smd: A6(8.458,-11.314) A40(-8.458,-11.314) AA5(8.887,-1.721) AC5(8.887,-0.705) AC41(-8.887,-0.705) AE5(8.887,0.705) AE41(-8.887,0.705) AG41(-8.887,1.721) AH5(8.887,1.772) AK5(8.836,3.093) AK41(-8.937,3.093) AM5(8.836,4.071) AM41(-8.887,4.096) AP5(8.836,5.163) AP41(-8.756,5.087) AT5(8.836,6.204) AT41(-8.894,6.068) AV41(-8.92,7.09) AW5(8.836,7.246) B41(-8.701,-10.855) BA4(9.434,8.408) BA42(-9.482,8.547) BB1(10.814,8.958) BB3(9.86,8.702) BB44(-10.333,9.125) BB45(-10.814,8.958) BC9(7.11,9.394) BC11(6.068,9.394) BC13(5.087,9.256) BC15(4.096,9.387) BC17(3.093,9.438) BC20(1.721,9.387) BC22(0.705,9.387) BC24(-0.705,9.387) BC27(-1.772,9.387) BC29(-3.093,9.336) BC31(-4.071,9.336) BC33(-5.163,9.285) BC35(-6.182,9.387) BC38(-7.321,9.229) BC40(-8.274,9.478) BE40(-8.53,10.345) BF5(8.701,10.855) BG6(8.458,11.314) BG40(-8.458,11.314) C6(8.53,-10.345) E6(8.274,-9.478) E8(7.321,-9.229) E11(6.182,-9.387) E13(5.163,-9.285) E15(4.071,-9.336) E17(3.093,-9.336) E19(1.772,-9.387) E22(0.705,-9.387) E24(-0.705,-9.387) E26(-1.721,-9.387) E29(-3.093,-9.438) E31(-4.096,-9.387) E33(-5.087,-9.256) E35(-6.068,-9.394) E37(-7.11,-9.394) F1(10.814,-8.958) F2(10.333,-9.125) F43(-9.86,-8.702) F45(-10.814,-8.958) G4(9.482,-8.547) G42(-9.434,-8.408) J41(-8.836,-7.246) K5(8.92,-7.09) M5(8.894,-6.068) M41(-8.836,-6.204) P5(8.756,-5.087) P41(-8.836,-5.163) T5(8.887,-4.096) T41(-8.836,-4.071) V5(8.937,-3.093) V41(-8.836,-3.093) Y41(-8.887,-1.772)
  custom 0.051x0.051 smd: A7(7.868,-11.314) A9(6.852,-11.314) A12(5.595,-11.314) A14(4.553,-11.314) A16(3.321,-11.314) A18(2.28,-11.314) A21(1.048,-11.314) A23(0.007,-11.314) A25(-1.225,-11.314) A28(-2.267,-11.314) A30(-3.499,-11.314) A32(-4.54,-11.314) A35(-5.772,-11.314) A37(-6.839,-11.314) A39(-7.893,-11.314) AA43(-9.888,-1.664) AA44(-10.396,-1.664) AB1(10.814,-1.225) AB2(10.306,-1.225) AB4(9.301,-1.225) AB42(-9.301,-1.048) AB44(-10.306,-1.048) AB45(-10.814,-1.048) AC2(10.396,-0.609) AC3(9.888,-0.609) AC4(9.403,-0.482) AC42(-9.421,-0.509) AC43(-9.929,-0.484) AC44(-10.428,-0.388) AD1(10.814,0.007) AD2(10.235,-0.096) AD3(9.727,-0.096) AD43(-9.727,0.096) AD44(-10.235,0.096) AD45(-10.814,-0.007) AE2(10.428,0.388) AE3(9.929,0.484) AE4(9.421,0.509) AE42(-9.403,0.482) AE43(-9.888,0.609) AE44(-10.396,0.609) AF1(10.814,1.048) AF2(10.306,1.048) AF4(9.301,1.048) AF42(-9.301,1.225) AF44(-10.306,1.225) AF45(-10.814,1.225) AG2(10.396,1.664) AG3(9.888,1.664) AH2(10.235,2.178) AH3(9.727,2.178) AH4(9.403,1.791) AH42(-9.421,1.764) AH43(-9.929,1.789) AH44(-10.428,1.886) AJ1(10.814,2.28) AJ2(10.428,2.661) AJ43(-9.727,2.369) AJ44(-10.235,2.369) AJ45(-10.814,2.267) AK3(9.929,2.757) AK4(9.421,2.783) AK42(-9.403,2.756) AK43(-9.888,2.883) AK44(-10.396,2.883) AL1(10.814,3.321) AL2(10.306,3.321) AL4(9.301,3.321) AL42(-9.301,3.499) AL44(-10.306,3.499) AL45(-10.814,3.499) AM2(10.396,3.937) AM3(9.888,3.937) AM4(9.403,4.064) AM42(-9.421,4.037) AM43(-9.929,4.063) AM44(-10.428,4.159) AN1(10.814,4.553) AN2(10.235,4.451) AN3(9.727,4.451) AN43(-9.727,4.642) AN44(-10.235,4.642) AN45(-10.814,4.54) AP2(10.428,4.934) AP3(9.929,5.03) AP4(9.421,5.056) AP42(-9.403,5.029) AP43(-9.888,5.156) AP44(-10.396,5.156) AR1(10.814,5.595) AR2(10.306,5.595) AR4(9.301,5.595) AT42(-9.301,5.772) AT44(-10.306,5.772) AT45(-10.814,5.772) AU2(10.396,6.211) AU3(9.888,6.211) AU4(9.403,6.338) AU42(-9.421,6.311) AU43(-9.929,6.336) AU44(-10.428,6.432) AV1(10.814,6.827) AV2(10.235,6.724) AV3(9.727,6.724) AV43(-9.727,6.915) AV44(-10.235,6.915) AV45(-10.814,6.813) AW2(10.428,7.208) AW3(9.929,7.304) AW42(-9.403,7.302) AW43(-9.888,7.429) AW44(-10.396,7.429) AY1(10.814,7.868) AY2(10.306,7.868) AY4(9.301,7.868) AY42(-9.301,8.045) AY44(-10.306,8.045) AY45(-10.814,7.88) B7(7.868,-10.806) B8(7.258,-10.928) B9(6.724,-10.735) B10(6.211,-10.896) B12(5.595,-10.806) B13(4.934,-10.928) B14(4.451,-10.735) B15(3.937,-10.896) B16(3.321,-10.806) B18(2.661,-10.928) B19(2.178,-10.735) B20(1.664,-10.896) B21(1.048,-10.806) B22(0.388,-10.928) B23(-0.096,-10.735) B24(-0.609,-10.896) B25(-1.225,-10.806) B27(-1.886,-10.928) B28(-2.369,-10.735) B29(-2.883,-10.896) B30(-3.499,-10.806) B31(-4.159,-10.928) B32(-4.642,-10.735) B33(-5.156,-10.896) B35(-5.772,-10.806) B36(-6.432,-10.928) B37(-6.915,-10.735) B38(-7.391,-10.896) B39(-8.045,-10.808) BA1(10.814,8.393) BA2(10.306,8.444) BA44(-10.333,8.546) BA45(-10.814,8.401) BD7(8.045,9.801) BD10(6.311,9.921) BD11(5.772,9.801) BD13(5.029,9.903) BD15(4.037,9.921) BD16(3.499,9.801) BD17(2.756,9.903) BD19(1.764,9.921) BD21(1.225,9.801) BD22(0.482,9.903) BD24(-0.509,9.921) BD25(-1.048,9.801) BD27(-1.791,9.903) BD29(-2.783,9.921) BD30(-3.321,9.801) BD31(-4.064,9.903) BD33(-5.056,9.921) BD34(-5.595,9.801) BD36(-6.338,9.903) BD39(-7.868,9.801) BE8(7.391,10.388) BE9(6.915,10.227) BE10(6.336,10.429) BE13(5.156,10.388) BE14(4.642,10.227) BE15(4.063,10.429) BE17(2.883,10.388) BE18(2.369,10.227) BE19(1.789,10.429) BE22(0.609,10.388) BE23(0.096,10.227) BE24(-0.484,10.429) BE26(-1.664,10.388) BE27(-2.178,10.227) BE29(-2.757,10.429) BE31(-3.937,10.388) BE32(-4.451,10.227) BE33(-5.03,10.429) BE36(-6.211,10.388) BE37(-6.724,10.227) BE38(-7.355,10.429) BF7(8.045,10.808) BF8(7.391,10.896) BF9(6.915,10.735) BF10(6.432,10.928) BF11(5.772,10.806) BF13(5.156,10.896) BF14(4.642,10.735) BF15(4.159,10.928) BF16(3.499,10.806) BF17(2.883,10.896) BF18(2.369,10.735) BF19(1.886,10.928) BF21(1.225,10.806) BF22(0.609,10.896) BF23(0.096,10.735) BF24(-0.388,10.928) BF25(-1.048,10.806) BF26(-1.664,10.896) BF27(-2.178,10.735) BF28(-2.661,10.928) BF30(-3.321,10.806) BF31(-3.937,10.896) BF32(-4.451,10.735) BF33(-4.934,10.928) BF34(-5.595,10.806) BF36(-6.211,10.896) BF37(-6.724,10.735) BF38(-7.258,10.928) BF39(-7.868,10.806) BG7(7.893,11.314) BG9(6.839,11.314) BG11(5.772,11.314) BG14(4.54,11.314) BG16(3.499,11.314) BG18(2.267,11.314) BG21(1.225,11.314) BG23(-0.007,11.314) BG25(-1.048,11.314) BG28(-2.28,11.314) BG30(-3.321,11.314) BG32(-4.553,11.314) BG34(-5.595,11.314) BG37(-6.852,11.314) BG39(-7.868,11.314) C8(7.355,-10.429) C9(6.724,-10.227) C10(6.211,-10.388) C13(5.03,-10.429) C14(4.451,-10.227) C15(3.937,-10.388) C17(2.757,-10.429) C19(2.178,-10.227) C20(1.664,-10.388) C22(0.484,-10.429) C23(-0.096,-10.227) C24(-0.609,-10.388) C27(-1.789,-10.429) C28(-2.369,-10.227) C29(-2.883,-10.388) C31(-4.063,-10.429) C32(-4.642,-10.227) C33(-5.156,-10.388) C36(-6.336,-10.429) C37(-6.915,-10.227) C38(-7.391,-10.388) D7(7.868,-9.801) D10(6.338,-9.903) D12(5.595,-9.801) D13(5.056,-9.921) D15(4.064,-9.903) D16(3.321,-9.801) D17(2.783,-9.921) D19(1.791,-9.903) D21(1.048,-9.801) D22(0.509,-9.921) D24(-0.482,-9.903) D25(-1.225,-9.801) D27(-1.764,-9.921) D29(-2.756,-9.903) D30(-3.499,-9.801) D31(-4.037,-9.921) D33(-5.029,-9.903) D35(-5.772,-9.801) D36(-6.311,-9.921) D39(-8.045,-9.801) G1(10.814,-8.401) G2(10.333,-8.546) G44(-10.306,-8.444) G45(-10.814,-8.393) H1(10.814,-7.88) H2(10.306,-8.045) H4(9.301,-8.045) H42(-9.301,-7.868) H44(-10.306,-7.868) H45(-10.814,-7.868) J2(10.396,-7.429) J3(9.888,-7.429) J4(9.403,-7.302) J43(-9.929,-7.304) J44(-10.428,-7.208) K1(10.814,-6.813) K2(10.235,-6.915) K3(9.727,-6.915) K43(-9.727,-6.724) K44(-10.235,-6.724) K45(-10.814,-6.827) L2(10.428,-6.432) L3(9.929,-6.336) L4(9.421,-6.311) L42(-9.403,-6.338) L43(-9.888,-6.211) L44(-10.396,-6.211) M1(10.814,-5.772) M2(10.306,-5.772) M4(9.301,-5.772) N42(-9.301,-5.595) N44(-10.306,-5.595) N45(-10.814,-5.595) P2(10.396,-5.156) P3(9.888,-5.156) P4(9.403,-5.029) P42(-9.421,-5.056) P43(-9.929,-5.03) P44(-10.428,-4.934) R1(10.814,-4.54) R2(10.235,-4.642) R3(9.727,-4.642) R43(-9.727,-4.451) R44(-10.235,-4.451) R45(-10.814,-4.553) T2(10.428,-4.159) T3(9.929,-4.063) T4(9.421,-4.037) T42(-9.403,-4.064) T43(-9.888,-3.937) T44(-10.396,-3.937) U1(10.814,-3.499) U2(10.306,-3.499) U4(9.301,-3.499) U42(-9.301,-3.321) U44(-10.306,-3.321) U45(-10.814,-3.321) V2(10.396,-2.883) V3(9.888,-2.883) V4(9.403,-2.756) V42(-9.421,-2.783) V43(-9.929,-2.757) W1(10.814,-2.267) W2(10.235,-2.369) W3(9.727,-2.369) W44(-10.428,-2.661) W45(-10.814,-2.28) Y2(10.428,-1.886) Y3(9.929,-1.789) Y4(9.421,-1.764) Y42(-9.403,-1.791) Y43(-9.727,-2.178) Y44(-10.235,-2.178)
C1206_H75
  rect 0.864x1.803 smd: 1(1.27,0) 2(-1.27,0)
CE_59_BD177_H236_HD28_LF5
  rect 1.118x1.118 hole 0.711: 1(0.75,0)
  round 1.118 hole 0.711: 2(-0.75,0)
HD_1X4P_79_LF3
  rect 1.372x1.372 hole 0.965: 1(-3,0)
  round 1.372 hole 0.965: 2(-1,0) 3(1,0) 4(3,0)
HD_1X5P_100_JVE_LF3
  rect 1.575x1.575 hole 1.168: 1(-5.08,0)
  round 1.575 hole 1.168: 2(-2.54,0) 3(0,0) 4(2.54,0) 5(5.08,0)
MX_2R4P0402
  rect 0.254x0.66 smd: 1(-0.325,-0.575) 2(-0.325,0.575) 3(0.325,-0.575) 4(0.325,0.575)
MX_4R8P0402
  rect 0.498x0.61 smd: 1(-0.852,-0.495) 2(-0.852,0.495) 7(0.852,-0.495) 8(0.852,0.495)
  rect 0.295x0.61 smd: 3(-0.25,-0.495) 4(-0.25,0.495) 5(0.25,-0.495) 6(0.25,0.495)
MX_ANCHOR_2P_100_AMCO_LF3
  rect 1.575x1.575 hole 1.168: 1(-2.54,0)
  round 1.575 hole 1.168: 2(2.54,0)
MX_BACKPLANE_7P_S3465_AMCO
  round 4.039 hole 4.039 unplated: (-37.5,-37.5) (-37.5,37.5) (37.5,-37.5) (37.5,37.5)
  round 3.81 hole 3.81 unplated: (-34.59,0) (26.415,-18) (26.415,18)
MX_BATHOLDER_2P_787_LF3
  rect 1.499x1.499 hole 1.092: 1(12.29,0)
  round 1.397 hole 0.991: 2(-7.71,0)
MX_BOX_HD_2X10P_79_K20_LF3
  rect 1.219x1.219 hole 0.813: 1(-9,-1)
  round 1.219 hole 0.813: 2(-9,1) 3(-7,-1) 4(-7,1) 5(-5,-1) 6(-5,1) 7(-3,-1) 8(-3,1) 9(-1,-1) 10(-1,1) 11(1,-1) 12(1,1) 13(3,-1) 14(3,1) 15(5,-1) 16(5,1) 17(7,-1) 18(7,1) 19(9,-1)
MX_BOX_HD_2X10P_79_K20_LF5
  rect 1.219x1.219 hole 0.813: 1(-9,-1)
  round 1.219 hole 0.813: 2(-9,1) 3(-7,-1) 4(-7,1) 5(-5,-1) 6(-5,1) 7(-3,-1) 8(-3,1) 9(-1,-1) 10(-1,1) 11(1,-1) 12(1,1) 13(3,-1) 14(3,1) 15(5,-1) 16(5,1) 17(7,-1) 18(7,1) 19(9,-1)
MX_BTOB_60P_20_F_SAMT_NS_NP
  round 1.041 hole 1.041 unplated: (-10.06,0) (10.066,0)
  rect 0.279x2.261 smd: 1(-7.25,-5.53) 2(-7.25,0.198) 3(-6.75,-5.53) 4(-6.75,0.198) 5(-6.25,-5.53) 6(-6.25,0.198) 7(-5.75,-5.53) 8(-5.75,0.198) 9(-5.25,-5.53) 10(-5.25,0.198) 11(-4.75,-5.53) 12(-4.75,0.198) 13(-4.25,-5.53) 14(-4.25,0.198) 15(-3.75,-5.53) 16(-3.75,0.198) 17(-3.25,-5.53) 18(-3.25,0.198) 19(-2.75,-5.53) 20(-2.75,0.198) 21(-2.25,-5.53) 22(-2.25,0.198) 23(-1.75,-5.53) 24(-1.75,0.198) 25(-1.25,-5.53) 26(-1.25,0.198) 27(-0.75,-5.53) 28(-0.75,0.198) 29(-0.25,-5.53) 30(-0.25,0.198) 31(0.25,-5.53) 32(0.25,0.198) 33(0.75,-5.53) 34(0.75,0.198) 35(1.25,-5.53) 36(1.25,0.198) 37(1.75,-5.53) 38(1.75,0.198) 39(2.25,-5.53) 40(2.25,0.198) 41(2.75,-5.53) 42(2.75,0.198) 43(3.25,-5.53) 44(3.25,0.198) 45(3.75,-5.53) 46(3.75,0.198) 47(4.25,-5.53) 48(4.25,0.198) 49(4.75,-5.53) 50(4.75,0.198) 51(5.25,-5.53) 52(5.25,0.198) 53(5.75,-5.53) 54(5.75,0.198) 55(6.25,-5.53) 56(6.25,0.198) 57(6.75,-5.53) 58(6.75,0.198) 59(7.25,-5.53) 60(7.25,0.198)
MX_BUZZ_256_BD472_H394_LF3
  rect 1.27x1.27 hole 0.864: 1(3.25,0)
  round 1.27 hole 0.864: 2(-3.25,0)
MX_C0201
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
MX_C0402_SMALL_T01
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
MX_C0603
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
MX_C0603_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
MX_C0603_SMALL_T01
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
MX_C0603_SMALL_T02
  rect 0.559x0.991 smd: 1(-0.67,0) 2(0.67,0)
MX_C0805_SMALL_T02
  rect 0.711x1.397 smd: 1(-0.864,0) 2(0.864,0)
MX_C1206
  rect 0.864x1.803 smd: 1(1.27,0) 2(-1.27,0)
MX_C1206_H75
  rect 0.864x1.803 smd: 1(1.27,0) 2(-1.27,0)
MX_CE_98_BD268_H374_37_LFH
  rect 1.321x1.321 hole 0.94: 1(1.25,0)
  round 1.321 hole 0.94: 2(-1.25,0)
MX_CE_100U_16V_5X11_LFH
  rect 1.219x1.219 hole 0.838: 1(1,0)
  round 1.219 hole 0.838: 2(-1,0)
MX_CE_100U_16V_6D3X7_LFH
  rect 1.168x1.168 hole 0.787: 1(1.25,0)
  round 1.168 hole 0.787: 2(-1.25,0)
MX_CE_138_BD335_H492_37_LFH
  rect 1.321x1.321 hole 0.94: 1(1.75,0)
  round 1.321 hole 0.94: 2(-1.75,0)
MX_CE_138_BD335_H512_37_LFH
  rect 1.321x1.321 hole 0.94: 1(1.75,0)
  round 1.321 hole 0.94: 2(-1.75,0)
MX_CE_330U_6D3V_6D3X11_LFH
  rect 1.219x1.219 hole 0.838: 1(1.25,0)
  round 1.219 hole 0.838: 2(-1.25,0)
MX_CE_470U_6D3V_6D3X11_LFH
  rect 1.219x1.219 hole 0.838: 1(1.25,0)
  round 1.219 hole 0.838: 2(-1.25,0)
MX_CHOKE_4P_49X39_TAI
  rect 0.508x0.305 smd: 1(-0.625,-0.275) 2(0.625,-0.275) 3(0.625,0.275) 4(-0.625,0.275)
MX_DDR4_DIMM_288P_3H_CO
  round 2.438 hole 2.438 unplated: (-74.55,0) (63.4,0)
  oval 1.194x2.438 hole 1.194x2.438 unplated: (0,0)
  round 0.965 hole 0.66: 1(-68.9,-2.7) 2(-68.05,-1.1) 3(-67.2,-2.7) 4(-66.35,-1.1) 5(-65.5,-2.7) 6(-64.65,-1.1) 7(-63.8,-2.7) 8(-62.95,-1.1) 9(-62.1,-2.7) 10(-61.25,-1.1) 11(-60.4,-2.7) 12(-59.55,-1.1) 13(-58.7,-2.7) 14(-57.85,-1.1) 15(-57,-2.7) 16(-56.15,-1.1) 17(-55.3,-2.7) 18(-54.45,-1.1) 19(-53.6,-2.7) 20(-52.75,-1.1) 21(-51.9,-2.7) 22(-51.05,-1.1) 23(-50.2,-2.7) 24(-49.35,-1.1) 25(-48.5,-2.7) 26(-47.65,-1.1) 27(-46.8,-2.7) 28(-45.95,-1.1) 29(-45.1,-2.7) 30(-44.25,-1.1) 31(-43.4,-2.7) 32(-42.55,-1.1) 33(-41.7,-2.7) 34(-40.85,-1.1) 35(-40,-2.7) 36(-39.15,-1.1) 37(-38.3,-2.7) 38(-37.45,-1.1) 39(-36.6,-2.7) 40(-35.75,-1.1) 41(-34.9,-2.7) 42(-34.05,-1.1) 43(-33.2,-2.7) 44(-32.35,-1.1) 45(-31.5,-2.7) 46(-30.65,-1.1) 47(-29.8,-2.7) 48(-28.95,-1.1) 49(-28.1,-2.7) 50(-27.25,-1.1) 51(-26.4,-2.7) 52(-25.55,-1.1) 53(-24.7,-2.7) 54(-23.85,-1.1) 55(-23,-2.7) 56(-22.15,-1.1) 57(-21.3,-2.7) 58(-20.45,-1.1) 59(-19.6,-2.7) 60(-18.75,-1.1) 61(-17.9,-2.7) 62(-17.05,-1.1) 63(-16.2,-2.7) 64(-15.35,-1.1) 65(-14.5,-2.7) 66(-13.65,-1.1) 67(-12.8,-2.7) 68(-11.95,-1.1) 69(-11.1,-2.7) 70(-10.25,-1.1) 71(-9.4,-2.7) 72(-8.55,-1.1) 73(-7.7,-2.7) 74(-6.85,-1.1) 75(-6,-2.7) 76(-5.15,-1.1) 77(-4.3,-2.7) 78(1.65,-1.1) 79(2.5,-2.7) 80(3.35,-1.1) 81(4.2,-2.7) 82(5.05,-1.1) 83(5.9,-2.7) 84(6.75,-1.1) 85(7.6,-2.7) 86(8.45,-1.1) 87(9.3,-2.7) 88(10.15,-1.1) 89(11,-2.7) 90(11.85,-1.1) 91(12.7,-2.7) 92(13.55,-1.1) 93(14.4,-2.7) 94(15.25,-1.1) 95(16.1,-2.7) 96(16.95,-1.1) 97(17.8,-2.7) 98(18.65,-1.1) 99(19.5,-2.7) 100(20.35,-1.1) 101(21.2,-2.7) 102(22.05,-1.1) 103(22.9,-2.7) 104(23.75,-1.1) 105(24.6,-2.7) 106(25.45,-1.1) 107(26.3,-2.7) 108(27.15,-1.1) 109(28,-2.7) 110(28.85,-1.1) 111(29.7,-2.7) 112(30.55,-1.1) 113(31.4,-2.7) 114(32.25,-1.1) 115(33.1,-2.7) 116(33.95,-1.1) 117(34.8,-2.7) 118(35.65,-1.1) 119(36.5,-2.7) 120(37.35,-1.1) 121(38.2,-2.7) 122(39.05,-1.1) 123(39.9,-2.7) 124(40.75,-1.1) 125(41.6,-2.7) 126(42.45,-1.1) 127(43.3,-2.7) 128(44.15,-1.1) 129(45,-2.7) 130(45.85,-1.1) 131(46.7,-2.7) 132(47.55,-1.1) 133(48.4,-2.7) 134(49.25,-1.1) 135(50.1,-2.7) 136(50.95,-1.1) 137(51.8,-2.7) 138(52.65,-1.1) 139(53.5,-2.7) 140(54.35,-1.1) 141(55.2,-2.7) 142(56.05,-1.1) 143(56.9,-2.7) 144(57.75,-1.1) 145(-68.9,1.1) 146(-68.05,2.7) 147(-67.2,1.1) 148(-66.35,2.7) 149(-65.5,1.1) 150(-64.65,2.7) 151(-63.8,1.1) 152(-62.95,2.7) 153(-62.1,1.1) 154(-61.25,2.7) 155(-60.4,1.1) 156(-59.55,2.7) 157(-58.7,1.1) 158(-57.85,2.7) 159(-57,1.1) 160(-56.15,2.7) 161(-55.3,1.1) 162(-54.45,2.7) 163(-53.6,1.1) 164(-52.75,2.7) 165(-51.9,1.1) 166(-51.05,2.7) 167(-50.2,1.1) 168(-49.35,2.7) 169(-48.5,1.1) 170(-47.65,2.7) 171(-46.8,1.1) 172(-45.95,2.7) 173(-45.1,1.1) 174(-44.25,2.7) 175(-43.4,1.1) 176(-42.55,2.7) 177(-41.7,1.1) 178(-40.85,2.7) 179(-40,1.1) 180(-39.15,2.7) 181(-38.3,1.1) 182(-37.45,2.7) 183(-36.6,1.1) 184(-35.75,2.7) 185(-34.9,1.1) 186(-34.05,2.7) 187(-33.2,1.1) 188(-32.35,2.7) 189(-31.5,1.1) 190(-30.65,2.7) 191(-29.8,1.1) 192(-28.95,2.7) 193(-28.1,1.1) 194(-27.25,2.7) 195(-26.4,1.1) 196(-25.55,2.7) 197(-24.7,1.1) 198(-23.85,2.7) 199(-23,1.1) 200(-22.15,2.7) 201(-21.3,1.1) 202(-20.45,2.7) 203(-19.6,1.1) 204(-18.75,2.7) 205(-17.9,1.1) 206(-17.05,2.7) 207(-16.2,1.1) 208(-15.35,2.7) 209(-14.5,1.1) 210(-13.65,2.7) 211(-12.8,1.1) 212(-11.95,2.7) 213(-11.1,1.1) 214(-10.25,2.7) 215(-9.4,1.1) 216(-8.55,2.7) 217(-7.7,1.1) 218(-6.85,2.7) 219(-6,1.1) 220(-5.15,2.7) 221(-4.3,1.1) 222(1.65,2.7) 223(2.5,1.1) 224(3.35,2.7) 225(4.2,1.1) 226(5.05,2.7) 227(5.9,1.1) 228(6.75,2.7) 229(7.6,1.1) 230(8.45,2.7) 231(9.3,1.1) 232(10.15,2.7) 233(11,1.1) 234(11.85,2.7) 235(12.7,1.1) 236(13.55,2.7) 237(14.4,1.1) 238(15.25,2.7) 239(16.1,1.1) 240(16.95,2.7) 241(17.8,1.1) 242(18.65,2.7) 243(19.5,1.1) 244(20.35,2.7) 245(21.2,1.1) 246(22.05,2.7) 247(22.9,1.1) 248(23.75,2.7) 249(24.6,1.1) 250(25.45,2.7) 251(26.3,1.1) 252(27.15,2.7) 253(28,1.1) 254(28.85,2.7) 255(29.7,1.1) 256(30.55,2.7) 257(31.4,1.1) 258(32.25,2.7) 259(33.1,1.1) 260(33.95,2.7) 261(34.8,1.1) 262(35.65,2.7) 263(36.5,1.1) 264(37.35,2.7) 265(38.2,1.1) 266(39.05,2.7) 267(39.9,1.1) 268(40.75,2.7) 269(41.6,1.1) 270(42.45,2.7) 271(43.3,1.1) 272(44.15,2.7) 273(45,1.1) 274(45.85,2.7) 275(46.7,1.1) 276(47.55,2.7) 277(48.4,1.1) 278(49.25,2.7) 279(50.1,1.1) 280(50.95,2.7) 281(51.8,1.1) 282(52.65,2.7) 283(53.5,1.1) 284(54.35,2.7) 285(55.2,1.1) 286(56.05,2.7) 287(56.9,1.1) 288(57.75,2.7)
MX_DFN_8P_20_79X79_PAD_RIC
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.245x0.838 smd: 9(0,0)
MX_DFN_10P_20_S118_PAD_R_4V
  rect 0.279x0.61 smd: 1(-1,-1.35) 2(-0.5,-1.35) 3(0,-1.35) 4(0.5,-1.35) 5(1,-1.35) 6(1,1.35) 7(0.5,1.35) 8(0,1.35) 9(-0.5,1.35) 10(-1,1.35)
  rect 2.642x1.676 smd: 11(0,0)
  round 0.61 hole 0.305: 12(-1.016,0.533) 13(1.016,0.533) 14(-1.016,-0.533) 15(1.016,-0.533)
MX_DISPLY20P_39_4HLD_LF3
  rect 0.914x0.914 hole 0.508: 1(6.2,0.72)
  round 0.914 hole 0.508: 2(5.7,-0.68) 3(4.8,0.72) 4(4.4,-0.68) 5(3.5,0.72) 6(3,-0.68) 7(2.2,0.72) 8(1.7,-0.68) 9(0.8,0.72) 10(0.4,-0.68) 11(-0.5,0.72) 12(-1,-0.68) 13(-1.8,0.72) 14(-2.3,-0.68) 15(-3.1,0.72) 16(-3.6,-0.68) 17(-4.5,0.72) 18(-4.9,-0.68) 19(-5.8,0.72) 20(-6.2,-0.68)
  oval 1.626x3.226 hole 0.61x2.21: 21(8.25,0) 22(-8.25,0)
  oval 1.626x2.718 hole 0.61x1.702: 23(8.25,-6.48) 24(-8.25,-6.48)
MX_ESD_10P_20_98X39_NXP
  rect 0.295x0.483 smd: 1(-1,-0.363) 2(-0.5,-0.363) 3(0,-0.363) 4(0.5,-0.363) 5(1,-0.363) 6(1,0.363) 7(0.5,0.363) 8(0,0.363) 9(-0.5,0.363) 10(-1,0.363)
MX_FPC_12P_20_2HD_ACES_B
  rect 0.305x0.889 smd: 1(-2.75,3.05) 2(-2.25,3.05) 3(-1.75,3.05) 4(-1.25,3.05) 5(-0.75,3.05) 6(-0.25,3.05) 7(0.25,3.05) 8(0.75,3.05) 9(1.25,3.05) 10(1.75,3.05) 11(2.25,3.05) 12(2.75,3.05)
  rect 0.991x2.007 smd: 13(-4.85,0) 14(4.85,0)
MX_H_C315D189N_M2_P2_V8
  round 4.801 hole 4.801 unplated: (0,0)
  round 0.61 hole 0.305: 2(0,3.34) 3(2.362,2.362) 4(3.34,0) 5(2.362,-2.362) 6(0,-3.34) 7(-2.362,-2.362) 8(-3.34,0) 9(-2.362,2.362)
MX_HD_1X2P_100_LF3
  rect 1.575x1.575 hole 1.168: 1(-1.27,0)
  round 1.575 hole 1.168: 2(1.27,0)
MX_HD_1X3P_100_LF3
  rect 1.575x1.575 hole 1.168: 1(-2.54,0)
  round 1.575 hole 1.168: 2(0,0) 3(2.54,0)
MX_HD_2X5P_100_K8_LF3
  rect 1.575x1.575 hole 1.168: 1(-5.08,-1.27)
  round 1.575 hole 1.168: 2(-5.08,1.27) 3(-2.54,-1.27) 4(-2.54,1.27) 5(0,-1.27) 6(0,1.27) 7(2.54,-1.27) 9(5.08,-1.27) 10(5.08,1.27)
MX_HD_2X6P_79_K6_PINRE_LF5
  rect 1.372x1.372 hole 0.965: 1(-5,-1)
  round 1.372 hole 0.965: 2(-5,1) 3(-3,-1) 4(-3,1) 5(-1,-1) 7(1,-1) 8(1,1) 9(3,-1) 10(3,1) 11(5,-1) 12(5,1)
MX_HOLE_160_T_HP
  round 4.064 hole 4.064 unplated: (0,0)
  round 0.762 hole 0.406: 1(-2.921,0) 2(-2.057,2.057) 3(0,2.921) 4(2.057,2.057) 5(2.921,0) 6(2.057,-2.057) 7(0,-2.921) 8(-2.057,-2.083)
MX_HOLE_160_T_R_HP
  round 4.064 hole 4.064 unplated: (0,0)
  round 0.762 hole 0.406: 1(-2.921,0) 2(-2.057,2.057) 3(0,2.921) 4(2.057,2.057) 5(2.921,0) 6(2.057,-2.057) 7(0,-2.921) 8(-2.057,-2.083)
MX_HOLE_160_T_U_HP
  round 4.064 hole 4.064 unplated: (0,0)
  round 0.762 hole 0.406: 1(-2.921,0) 2(-2.057,2.057) 3(0,2.921) 4(2.057,2.057) 5(2.921,0) 6(2.057,-2.057) 7(0,-2.921) 8(-2.057,-2.083)
MX_HOLE_C315D189N_M2_P2_V8
  round 4.801 hole 4.801 unplated: (0,0)
  round 0.61 hole 0.305: 2(0,3.34) 3(2.362,2.362) 4(3.34,0) 5(2.362,-2.362) 6(0,-3.34) 7(-2.362,-2.362) 8(-3.34,0) 9(-2.362,2.362)
MX_HSK_S1299_2ANCHOR_LF3
  round 1.422 hole 0.965: 1(18.29,27.43) 2(18.29,22.35) 3(-18.29,-22.35) 4(-18.29,-27.43)
MX_INDU_D_2P_S309_MAGI_LF3
  rect 1.372x1.372 hole 0.965: 1(-2.2,2.25)
  oval 2.642x1.981 hole 1.626x0.965 rot 134.4: 2(2.2,-2.25)
MX_INDU_D_2P_S445_LF3
  rect 2.311x2.311 hole 1.549: 1(-3.15,3.2)
  oval 3.226x2.565 hole 2.21x1.549 rot 134.5: 2(3.15,-3.2)
MX_INDUCT_D_2P_433X315_LF3
  rect 2.108x2.108 hole 1.346: 1(3.4,1)
  oval 2.362x3.023 hole 1.346x2.007 rot 106.4: 2(-3.4,-1)
MX_INDUCTOR_2P_287X260
  rect 2.845x2.997 smd: 1(-3.025,0) 2(3.025,0)
MX_JACK_USB_22P_8H_UD_LF5
  round 3.073 hole 2.311: 1(-6.57,0) 2(6.57,0) 3(-6.57,-5.68) 4(6.57,-5.68) 5(-9.275,4.37) 6(9.275,4.37) 7(-9.275,-8.31) 8(9.275,-8.31)
  round 1.27 hole 0.864: L1(7.2,9.84) L2(4.66,9.84) L3(-4.66,9.84) L4(-7.2,9.84) R1(5.715,4.47) R2(4.445,7.01) R3(3.175,4.47) R4(1.905,7.01) R5(0.635,4.47) R6(-0.635,7.01) R7(-1.905,4.47) R8(-3.175,7.01) R9(-4.445,4.47) R10(-5.715,7.01)
  rect 1.321x1.321 hole 0.914: U1(-3.5,-2.97)
  round 1.321 hole 0.914: U2(-1,-2.97) U3(1,-2.97) U4(3.5,-2.97) U5(-3.5,-0.35) U6(-1,-0.35) U7(1,-0.35) U8(3.5,-0.35)
MX_L0603_SMALL_T02
  rect 0.559x0.991 smd: 1(-0.67,0) 2(0.67,0)
MX_LED_2P_63X31_EVER
  rect 0.787x0.787 smd: 1(0.75,0) 2(-0.75,0)
MX_LED_2P_63X31_H16
  rect 0.787x0.787 smd: 1(0.75,0) 2(-0.75,0)
MX_LED_D_2P_157X327_LF3
  rect 1.27x1.27 hole 0.864: 1(-1.27,0)
  round 1.27 hole 0.864: 2(1.27,0)
MX_MINI_PCI_67P_4HD_COLAY
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
MX_MINI_PCI_67P_20_4H_COLAY
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 8(-7.5,-1.725) 9(-7.25,4.725) 10(-7,-1.725) 11(-6.75,4.725) 12(-6.5,-1.725) 13(-6.25,4.725) 14(-6,-1.725) 15(-5.75,4.725) 16(-5.5,-1.725) 17(-5.25,4.725) 18(-5,-1.725) 19(-4.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 24(-3.5,-1.725) 25(-3.25,4.725) 26(-3,-1.725) 27(-2.75,4.725) 28(-2.5,-1.725) 29(-2.25,4.725) 30(-2,-1.725) 31(-1.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
MX_NUT_CT256BD146_H71
  round 6.502 hole 3.708: 1(0,0)
MX_OPTCL_JACK_5P_2H_JY_LF5
  oval 1.803x4.191 hole 1.803x4.191 unplated: (-6.2,0) (6.2,0)
  rect 1.295x1.295 hole 0.889: 1(-2.54,-0.1)
  round 1.295 hole 0.889: 2(0,-0.1) 3(2.54,-0.1)
  oval 1.067x2.921 hole 0.66x2.515: 4(-10.2,3.25)
  round 1.702 hole 1.295: 5(4.6,3.95)
MX_PHONE_JACK_26P_4H_LO_LF5
  rect 1.397x1.397 hole 0.991: 1(6,3.8)
  round 1.397 hole 0.991: 2(11,3.8) 3(8.5,3.8) 4(3.5,3.8) 5(1,3.8) 41(-6,3.8) 62(-1,3.8) 63(-3.5,3.8) 64(-8.5,3.8) 65(-11,3.8)
  round 1.346 hole 0.94: 22(9.75,8.8) 23(7.25,8.8) 24(4.75,8.8) 25(2.25,8.8) 32(9.75,13.8) 33(7.25,13.8) 34(4.75,13.8) 35(2.25,13.8) 42(-2.25,13.8) 43(-4.75,13.8) 44(-7.25,13.8) 45(-9.75,13.8) 52(-2.25,8.8) 53(-4.75,8.8) 54(-7.25,8.8) 55(-9.75,8.8)
  round 3.073 hole 2.311: 66(-12.04,11.3) 67(12.04,11.3) 68(-12.04,0) 69(12.04,0)
MX_POLYSWITCH_2P_0805_H30
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
MX_POWERPAIR_8P_2PAD_VISHAY
  rect 0.457x0.457 smd: 1(-0.975,-1.386) 2(-0.325,-1.386) 3(0.325,-1.386) 4(0.975,-1.386) 5(0.975,1.386) 6(0.325,1.386) 7(-0.325,1.386) 8(-0.975,1.386)
  rect 2.438x1.041 smd: 9(0,0.434)
  rect 2.438x0.559 smd: 10(0,-0.671)
MX_PWR_2X2P_165_HD_LF3
  round 2.997 hole 2.997 unplated: (-6.8,2.29)
  rect 2.311x2.311 hole 1.549: 1(2.1,-2.75)
  round 2.311 hole 1.549: 2(-2.1,-2.75) 3(2.1,2.75) 4(-2.1,2.75)
MX_PWR_2X12P_165_2HD_LF3
  round 2.997 hole 2.997 unplated: (-27.8,-2.29) (27.8,-2.29)
  rect 2.159x2.159 hole 1.397: 1(-23.1,2.75)
  round 2.159 hole 1.397: 2(-18.9,2.75) 3(-14.7,2.75) 4(-10.5,2.75) 5(-6.3,2.75) 6(-2.1,2.75) 7(2.1,2.75) 8(6.3,2.75) 9(10.5,2.75) 10(14.7,2.75) 11(18.9,2.75) 12(23.1,2.75) 13(-23.1,-2.75) 14(-18.9,-2.75) 15(-14.7,-2.75) 16(-10.5,-2.75) 17(-6.3,-2.75) 18(-2.1,-2.75) 19(2.1,-2.75) 20(6.3,-2.75) 21(10.5,-2.75) 22(14.7,-2.75) 23(18.9,-2.75) 24(23.1,-2.75)
MX_PWR_8P_165_2HOLD_VIT_LF3
  round 2.997 hole 2.997 unplated: (-11,2.27) (11,2.27)
  rect 2.159x2.159 hole 1.397: 1(6.3,-2.75)
  round 2.159 hole 1.397: 2(2.1,-2.75) 3(-2.1,-2.75) 4(-6.3,-2.75) 5(6.3,2.75) 6(2.1,2.75) 7(-2.1,2.75) 8(-6.3,2.75)
MX_QFN_16P_20_S118_PAD_RIC
  rect 0.279x0.61 smd: 1(-0.75,-1.35) 2(-0.25,-1.35) 3(0.25,-1.35) 4(0.75,-1.35) 9(0.75,1.35) 10(0.25,1.35) 11(-0.25,1.35) 12(-0.75,1.35)
  rect 0.61x0.279 smd: 5(1.35,-0.75) 6(1.35,-0.25) 7(1.35,0.25) 8(1.35,0.75) 13(-1.35,0.75) 14(-1.35,0.25) 15(-1.35,-0.25) 16(-1.35,-0.75)
  rect 1.676x1.676 smd: 17(0,0)
MX_QFN_32P_16_S161_PD_8V
  rect 0.229x0.508 smd: 1(-1.4,-1.896) 8(1.4,-1.896) 17(1.4,1.896) 24(-1.4,1.896)
  rect 0.229x0.61 smd: 2(-1,-1.845) 3(-0.6,-1.845) 4(-0.2,-1.845) 5(0.2,-1.845) 6(0.6,-1.845) 7(1,-1.845) 18(1,1.845) 19(0.6,1.845) 20(0.2,1.845) 21(-0.2,1.845) 22(-0.6,1.845) 23(-1,1.845)
  rect 0.508x0.229 smd: 9(1.896,-1.4) 16(1.896,1.4) 25(-1.896,1.4) 32(-1.896,-1.4)
  rect 0.61x0.229 smd: 10(1.845,-1) 11(1.845,-0.6) 12(1.845,-0.2) 13(1.845,0.2) 14(1.845,0.6) 15(1.845,1) 26(-1.845,1) 27(-1.845,0.6) 28(-1.845,0.2) 29(-1.845,-0.2) 30(-1.845,-0.6) 31(-1.845,-1)
  rect 2.667x2.667 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.029,1.029) 35(0,1.029) 36(1.029,1.029) 37(-1.029,0) 38(1.029,0) 39(-1.029,-1.029) 40(0,-1.029) 41(1.029,-1.029)
MX_QFN_40P_16_S197_PD_QU_9V
  rect 0.229x0.559 smd: 1(-1.8,-2.37) 2(-1.4,-2.37) 3(-1,-2.37) 4(-0.6,-2.37) 5(-0.2,-2.37) 6(0.2,-2.37) 7(0.6,-2.37) 8(1,-2.37) 9(1.4,-2.37) 10(1.8,-2.37) 21(1.8,2.37) 22(1.4,2.37) 23(1,2.37) 24(0.6,2.37) 25(0.2,2.37) 26(-0.2,2.37) 27(-0.6,2.37) 28(-1,2.37) 29(-1.4,2.37) 30(-1.8,2.37)
  rect 0.559x0.229 smd: 11(2.37,-1.8) 12(2.37,-1.4) 13(2.37,-1) 14(2.37,-0.6) 15(2.37,-0.2) 16(2.37,0.2) 17(2.37,0.6) 18(2.37,1) 19(2.37,1.4) 20(2.37,1.8) 31(-2.37,1.8) 32(-2.37,1.4) 33(-2.37,1) 34(-2.37,0.6) 35(-2.37,0.2) 36(-2.37,-0.2) 37(-2.37,-0.6) 38(-2.37,-1) 39(-2.37,-1.4) 40(-2.37,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.49,1.49) 43(0,1.49) 44(1.49,1.49) 45(-1.49,0) 46(0,0) 47(1.49,0) 48(-1.49,-1.49) 49(0,-1.49) 50(1.49,-1.49)
MX_QFN_56P_16_S236_PAD_4V
  rect 0.222x0.457 smd: 1(-2.8,-2.922) 2(-2.4,-2.922) 14(2.4,-2.922) 15(2.8,-2.922) 29(2.8,2.922) 30(2.4,2.922) 42(-2.4,2.922) 43(-2.8,2.922)
  rect 0.222x0.61 smd: 3(-2,-2.845) 4(-1.6,-2.845) 5(-1.2,-2.845) 6(-0.8,-2.845) 7(-0.4,-2.845) 8(0,-2.845) 9(0.4,-2.845) 10(0.8,-2.845) 11(1.2,-2.845) 12(1.6,-2.845) 13(2,-2.845) 31(2,2.845) 32(1.6,2.845) 33(1.2,2.845) 34(0.8,2.845) 35(0.4,2.845) 36(0,2.845) 37(-0.4,2.845) 38(-0.8,2.845) 39(-1.2,2.845) 40(-1.6,2.845) 41(-2,2.845)
  rect 0.61x0.222 smd: 16(2.845,-2.4) 17(2.845,-2) 18(2.845,-1.6) 19(2.845,-1.2) 20(2.845,-0.8) 21(2.845,-0.4) 22(2.845,0) 23(2.845,0.4) 24(2.845,0.8) 25(2.845,1.2) 26(2.845,1.6) 27(2.845,2) 28(2.845,2.4) 44(-2.845,2.4) 45(-2.845,2) 46(-2.845,1.6) 47(-2.845,1.2) 48(-2.845,0.8) 49(-2.845,0.4) 50(-2.845,0) 51(-2.845,-0.4) 52(-2.845,-0.8) 53(-2.845,-1.2) 54(-2.845,-1.6) 55(-2.845,-2) 56(-2.845,-2.4)
  rect 4.674x4.674 smd: 57(0,0)
  round 0.61 hole 0.305: 58(-2.032,2.032) 59(2.032,2.032) 60(-2.032,-2.032) 61(2.032,-2.032)
MX_QFN_64P_20_S354_P_MA_12V
  rect 0.279x0.61 smd: 1(-3.75,-4.35) 2(-3.25,-4.35) 3(-2.75,-4.35) 4(-2.25,-4.35) 5(-1.75,-4.35) 6(-1.25,-4.35) 7(-0.75,-4.35) 8(-0.25,-4.35) 9(0.25,-4.35) 10(0.75,-4.35) 11(1.25,-4.35) 12(1.75,-4.35) 13(2.25,-4.35) 14(2.75,-4.35) 15(3.25,-4.35) 16(3.75,-4.35) 33(3.75,4.35) 34(3.25,4.35) 35(2.75,4.35) 36(2.25,4.35) 37(1.75,4.35) 38(1.25,4.35) 39(0.75,4.35) 40(0.25,4.35) 41(-0.25,4.35) 42(-0.75,4.35) 43(-1.25,4.35) 44(-1.75,4.35) 45(-2.25,4.35) 46(-2.75,4.35) 47(-3.25,4.35) 48(-3.75,4.35)
  rect 0.61x0.279 smd: 17(4.35,-3.75) 18(4.35,-3.25) 19(4.35,-2.75) 20(4.35,-2.25) 21(4.35,-1.75) 22(4.35,-1.25) 23(4.35,-0.75) 24(4.35,-0.25) 25(4.35,0.25) 26(4.35,0.75) 27(4.35,1.25) 28(4.35,1.75) 29(4.35,2.25) 30(4.35,2.75) 31(4.35,3.25) 32(4.35,3.75) 49(-4.35,3.75) 50(-4.35,3.25) 51(-4.35,2.75) 52(-4.35,2.25) 53(-4.35,1.75) 54(-4.35,1.25) 55(-4.35,0.75) 56(-4.35,0.25) 57(-4.35,-0.25) 58(-4.35,-0.75) 59(-4.35,-1.25) 60(-4.35,-1.75) 61(-4.35,-2.25) 62(-4.35,-2.75) 63(-4.35,-3.25) 64(-4.35,-3.75)
  rect 5.41x5.41 smd: 65(0,0)
  round 0.61 hole 0.305: 66(-2.25,2.25) 67(-0.75,2.25) 68(0.75,2.25) 69(2.25,2.25) 70(-2.25,0.75) 71(2.25,0.75) 72(-2.25,-0.75) 73(2.25,-0.75) 74(-2.25,-2.25) 75(-0.75,-2.25) 76(0.75,-2.25) 77(2.25,-2.25)
MX_QFP_48P_20_354X354_H63
  rect 0.279x1.499 smd: 1(-2.75,-4.36) 2(-2.25,-4.36) 3(-1.75,-4.36) 4(-1.25,-4.36) 5(-0.75,-4.36) 6(-0.25,-4.36) 7(0.25,-4.36) 8(0.75,-4.36) 9(1.25,-4.36) 10(1.75,-4.36) 11(2.25,-4.36) 12(2.75,-4.36) 25(2.75,4.36) 26(2.25,4.36) 27(1.75,4.36) 28(1.25,4.36) 29(0.75,4.36) 30(0.25,4.36) 31(-0.25,4.36) 32(-0.75,4.36) 33(-1.25,4.36) 34(-1.75,4.36) 35(-2.25,4.36) 36(-2.75,4.36)
  rect 1.499x0.279 smd: 13(4.36,-2.75) 14(4.36,-2.25) 15(4.36,-1.75) 16(4.36,-1.25) 17(4.36,-0.75) 18(4.36,-0.25) 19(4.36,0.25) 20(4.36,0.75) 21(4.36,1.25) 22(4.36,1.75) 23(4.36,2.25) 24(4.36,2.75) 37(-4.36,2.75) 38(-4.36,2.25) 39(-4.36,1.75) 40(-4.36,1.25) 41(-4.36,0.75) 42(-4.36,0.25) 43(-4.36,-0.25) 44(-4.36,-0.75) 45(-4.36,-1.25) 46(-4.36,-1.75) 47(-4.36,-2.25) 48(-4.36,-2.75)
MX_QFP_128P_16_S630_H47
  rect 0.191x1.499 smd: 1(-6.2,-7.86) 2(-5.8,-7.86) 3(-5.4,-7.86) 4(-5,-7.86) 5(-4.6,-7.86) 6(-4.2,-7.86) 7(-3.8,-7.86) 8(-3.4,-7.86) 9(-3,-7.86) 10(-2.6,-7.86) 11(-2.2,-7.86) 12(-1.8,-7.86) 13(-1.4,-7.86) 14(-1,-7.86) 15(-0.6,-7.86) 16(-0.2,-7.86) 17(0.2,-7.86) 18(0.6,-7.86) 19(1,-7.86) 20(1.4,-7.86) 21(1.8,-7.86) 22(2.2,-7.86) 23(2.6,-7.86) 24(3,-7.86) 25(3.4,-7.86) 26(3.8,-7.86) 27(4.2,-7.86) 28(4.6,-7.86) 29(5,-7.86) 30(5.4,-7.86) 31(5.8,-7.86) 32(6.2,-7.86) 65(6.2,7.86) 66(5.8,7.86) 67(5.4,7.86) 68(5,7.86) 69(4.6,7.86) 70(4.2,7.86) 71(3.8,7.86) 72(3.4,7.86) 73(3,7.86) 74(2.6,7.86) 75(2.2,7.86) 76(1.8,7.86) 77(1.4,7.86) 78(1,7.86) 79(0.6,7.86) 80(0.2,7.86) 81(-0.2,7.86) 82(-0.6,7.86) 83(-1,7.86) 84(-1.4,7.86) 85(-1.8,7.86) 86(-2.2,7.86) 87(-2.6,7.86) 88(-3,7.86) 89(-3.4,7.86) 90(-3.8,7.86) 91(-4.2,7.86) 92(-4.6,7.86) 93(-5,7.86) 94(-5.4,7.86) 95(-5.8,7.86) 96(-6.2,7.86)
  rect 1.499x0.191 smd: 33(7.86,-6.2) 34(7.86,-5.8) 35(7.86,-5.4) 36(7.86,-5) 37(7.86,-4.6) 38(7.86,-4.2) 39(7.86,-3.8) 40(7.86,-3.4) 41(7.86,-3) 42(7.86,-2.6) 43(7.86,-2.2) 44(7.86,-1.8) 45(7.86,-1.4) 46(7.86,-1) 47(7.86,-0.6) 48(7.86,-0.2) 49(7.86,0.2) 50(7.86,0.6) 51(7.86,1) 52(7.86,1.4) 53(7.86,1.8) 54(7.86,2.2) 55(7.86,2.6) 56(7.86,3) 57(7.86,3.4) 58(7.86,3.8) 59(7.86,4.2) 60(7.86,4.6) 61(7.86,5) 62(7.86,5.4) 63(7.86,5.8) 64(7.86,6.2) 97(-7.86,6.2) 98(-7.86,5.8) 99(-7.86,5.4) 100(-7.86,5) 101(-7.86,4.6) 102(-7.86,4.2) 103(-7.86,3.8) 104(-7.86,3.4) 105(-7.86,3) 106(-7.86,2.6) 107(-7.86,2.2) 108(-7.86,1.8) 109(-7.86,1.4) 110(-7.86,1) 111(-7.86,0.6) 112(-7.86,0.2) 113(-7.86,-0.2) 114(-7.86,-0.6) 115(-7.86,-1) 116(-7.86,-1.4) 117(-7.86,-1.8) 118(-7.86,-2.2) 119(-7.86,-2.6) 120(-7.86,-3) 121(-7.86,-3.4) 122(-7.86,-3.8) 123(-7.86,-4.2) 124(-7.86,-4.6) 125(-7.86,-5) 126(-7.86,-5.4) 127(-7.86,-5.8) 128(-7.86,-6.2)
MX_R0402_SHORT_SMALL_T01
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
MX_R0402_SMALL_T01
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
MX_R0402_T01
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
MX_R0603_SHORT_SMALL_T01
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
MX_R0603_SMALL_T01
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
MX_R0805_SMALL_T02
  rect 0.711x1.397 smd: 1(-0.864,0) 2(0.864,0)
MX_R0805_SMALL_T02_H26
  rect 0.711x1.397 smd: 1(-0.864,0) 2(0.864,0)
MX_R1206
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
MX_R1206_H26
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
MX_RUBBER_FOOT_C394_NOPAD
  round 0 smd: 1(0,0)
MX_S0402_AMAZ_COLAY
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
MX_SATA_CON_7P_50_2HD_LF3
  rect 1.143x1.143 hole 0.737: 1(3.955,-1.5)
  round 1.067 hole 0.737: 2(2.685,0) 3(1.415,0) 5(-1.125,0) 6(-2.395,0)
  round 1.143 hole 0.737: 4(0.145,-1.5) 7(-3.665,-1.5)
  round 2.108 hole 1.346: 8(6.415,0) 9(-6.415,1)
MX_SLOT_PCI64P_79_2HOLD_LF3
  round 2.362 hole 2.362 unplated: (0,0) (23.15,0)
  rect 1.067x1.067 hole 0.711: A1(-11.65,1.25)
  round 1.067 hole 0.711: A2(-10.65,3.25) A3(-9.65,1.25) A4(-8.65,3.25) A5(-7.65,1.25) A6(-6.65,3.25) A7(-5.65,1.25) A8(-4.65,3.25) A9(-3.65,1.25) A10(-2.65,3.25) A11(-1.65,1.25) A12(1.35,3.25) A13(2.35,1.25) A14(3.35,3.25) A15(4.35,1.25) A16(5.35,3.25) A17(6.35,1.25) A18(7.35,3.25) A19(8.35,1.25) A20(9.35,3.25) A21(10.35,1.25) A22(11.35,3.25) A23(12.35,1.25) A24(13.35,3.25) A25(14.35,1.25) A26(15.35,3.25) A27(16.35,1.25) A28(17.35,3.25) A29(18.35,1.25) A30(19.35,3.25) A31(20.35,1.25) A32(21.35,3.25) B1(-11.65,-1.25) B2(-10.65,-3.25) B3(-9.65,-1.25) B4(-8.65,-3.25) B5(-7.65,-1.25) B6(-6.65,-3.25) B7(-5.65,-1.25) B8(-4.65,-3.25) B9(-3.65,-1.25) B10(-2.65,-3.25) B11(-1.65,-1.25) B12(1.35,-3.25) B13(2.35,-1.25) B14(3.35,-3.25) B15(4.35,-1.25) B16(5.35,-3.25) B17(6.35,-1.25) B18(7.35,-3.25) B19(8.35,-1.25) B20(9.35,-3.25) B21(10.35,-1.25) B22(11.35,-3.25) B23(12.35,-1.25) B24(13.35,-3.25) B25(14.35,-1.25) B26(15.35,-3.25) B27(16.35,-1.25) B28(17.35,-3.25) B29(18.35,-1.25) B30(19.35,-3.25) B31(20.35,-1.25) B32(21.35,-3.25)
MX_SLOT_PCI_E_164P_2H_L_LF3
  round 2.362 hole 2.362 unplated: (0,0) (73.15,0)
  rect 1.118x1.118 hole 0.711: A1(-11.65,1.25)
  round 1.118 hole 0.711: A2(-10.65,3.25) A3(-9.65,1.25) A4(-8.65,3.25) A5(-7.65,1.25) A6(-6.65,3.25) A7(-5.65,1.25) A8(-4.65,3.25) A9(-3.65,1.25) A10(-2.65,3.25) A11(-1.65,1.25) A12(1.35,3.25) A13(2.35,1.25) A14(3.35,3.25) A15(4.35,1.25) A16(5.35,3.25) A17(6.35,1.25) A18(7.35,3.25) A19(8.35,1.25) A20(9.35,3.25) A21(10.35,1.25) A22(11.35,3.25) A23(12.35,1.25) A24(13.35,3.25) A25(14.35,1.25) A26(15.35,3.25) A27(16.35,1.25) A28(17.35,3.25) A29(18.35,1.25) A30(19.35,3.25) A31(20.35,1.25) A32(21.35,3.25) A33(22.35,1.25) A34(23.35,3.25) A35(24.35,1.25) A36(25.35,3.25) A37(26.35,1.25) A38(27.35,3.25) A39(28.35,1.25) A40(29.35,3.25) A41(30.35,1.25) A42(31.35,3.25) A43(32.35,1.25) A44(33.35,3.25) A45(34.35,1.25) A46(35.35,3.25) A47(36.35,1.25) A48(37.35,3.25) A49(38.35,1.25) A50(39.35,3.25) A51(40.35,1.25) A52(41.35,3.25) A53(42.35,1.25) A54(43.35,3.25) A55(44.35,1.25) A56(45.35,3.25) A57(46.35,1.25) A58(47.35,3.25) A59(48.35,1.25) A60(49.35,3.25) A61(50.35,1.25) A62(51.35,3.25) A63(52.35,1.25) A64(53.35,3.25) A65(54.35,1.25) A66(55.35,3.25) A67(56.35,1.25) A68(57.35,3.25) A69(58.35,1.25) A70(59.35,3.25) A71(60.35,1.25) A72(61.35,3.25) A73(62.35,1.25) A74(63.35,3.25) A75(64.35,1.25) A76(65.35,3.25) A77(66.35,1.25) A78(67.35,3.25) A79(68.35,1.25) A80(69.35,3.25) A81(70.35,1.25) A82(71.35,3.25) B1(-11.65,-1.25) B2(-10.65,-3.25) B3(-9.65,-1.25) B4(-8.65,-3.25) B5(-7.65,-1.25) B6(-6.65,-3.25) B7(-5.65,-1.25) B8(-4.65,-3.25) B9(-3.65,-1.25) B10(-2.65,-3.25) B11(-1.65,-1.25) B12(1.35,-3.25) B13(2.35,-1.25) B14(3.35,-3.25) B15(4.35,-1.25) B16(5.35,-3.25) B17(6.35,-1.25) B18(7.35,-3.25) B19(8.35,-1.25) B20(9.35,-3.25) B21(10.35,-1.25) B22(11.35,-3.25) B23(12.35,-1.25) B24(13.35,-3.25) B25(14.35,-1.25) B26(15.35,-3.25) B27(16.35,-1.25) B28(17.35,-3.25) B29(18.35,-1.25) B30(19.35,-3.25) B31(20.35,-1.25) B32(21.35,-3.25) B33(22.35,-1.25) B34(23.35,-3.25) B35(24.35,-1.25) B36(25.35,-3.25) B37(26.35,-1.25) B38(27.35,-3.25) B39(28.35,-1.25) B40(29.35,-3.25) B41(30.35,-1.25) B42(31.35,-3.25) B43(32.35,-1.25) B44(33.35,-3.25) B45(34.35,-1.25) B46(35.35,-3.25) B47(36.35,-1.25) B48(37.35,-3.25) B49(38.35,-1.25) B50(39.35,-3.25) B51(40.35,-1.25) B52(41.35,-3.25) B53(42.35,-1.25) B54(43.35,-3.25) B55(44.35,-1.25) B56(45.35,-3.25) B57(46.35,-1.25) B58(47.35,-3.25) B59(48.35,-1.25) B60(49.35,-3.25) B61(50.35,-1.25) B62(51.35,-3.25) B63(52.35,-1.25) B64(53.35,-3.25) B65(54.35,-1.25) B66(55.35,-3.25) B67(56.35,-1.25) B68(57.35,-3.25) B69(58.35,-1.25) B70(59.35,-3.25) B71(60.35,-1.25) B72(61.35,-3.25) B73(62.35,-1.25) B74(63.35,-3.25) B75(64.35,-1.25) B76(65.35,-3.25) B77(66.35,-1.25) B78(67.35,-3.25) B79(68.35,-1.25) B80(69.35,-3.25) B81(70.35,-1.25) B82(71.35,-3.25)
MX_SMA
  rect 1.956x1.499 smd: 1(2.25,0) 2(-2.25,0)
MX_SMT_N_CT299B196D166_H100
  round 7.595 hole 4.216: 1(0,0)
MX_SMT_NUT_CT276B195D165
  round 7.01 hole 4.191: 1(0,0)
MX_SO_8FL_COLAY
  rect 0.762x1.524 smd: 1(-1.905,-2.848) 2(-0.635,-2.848) 3(0.635,-2.848) 4(1.905,-2.848)
  rect 4.547x4.826 smd: 5(0,1.083)
MX_SO_8FL_COLAY_9VI
  rect 0.762x1.524 smd: 1(-1.905,-2.848) 2(-0.635,-2.848) 3(0.635,-2.848) 4(1.905,-2.848)
  rect 4.547x4.826 smd: 5(0,1.083)
  round 0.559 hole 0.254: 6(-1.97,3.183) 7(0,3.183) 8(1.97,3.183) 9(-1.97,1.083) 10(0,1.083) 11(1.97,1.083) 12(-1.97,-1.017) 13(0,-1.017) 14(1.97,-1.017)
MX_SOCKET1151_FOXN_7HD
  round 4.039 hole 4.039 unplated: (-38.12,37.5) (-38.12,-37.5) (36.89,37.5) (36.89,-37.5)
  round 3.81 hole 3.81 unplated: (-35.21,0) (25.81,18) (25.81,-18)
  round 0.508 smd: A4(-16.187,18.288) A5(-15.273,18.288) AT40(18.931,-14.63) AU1(-18.931,-14.63) AU39(18.016,-15.545) AU40(18.931,-15.545) AV1(-18.931,-15.545) AV2(-18.016,-15.545) AV38(17.102,-16.459) AV39(18.016,-16.459) AW2(-18.016,-16.459) AW3(-17.102,-16.459) AW37(16.187,-17.374) AW38(17.102,-17.374) AY3(-17.102,-17.374) AY4(-16.187,-17.374) B3(-17.102,17.374) B4(-16.187,17.374) B37(16.187,16.459) B38(17.102,16.459) B39(18.016,16.459) C2(-18.016,16.459) C3(-17.102,16.459) C39(18.016,15.545) C40(18.931,15.545) D1(-18.931,15.545) D2(-18.016,15.545) D40(18.931,14.63) E40(18.931,13.716)
  round 0.432 smd: A6(-14.359,18.288) A7(-13.444,18.288) A25(3.015,18.288) A26(3.929,18.288) A27(4.844,18.288) A28(5.758,18.288) A29(6.673,18.288) A30(7.587,18.288) AA5(-15.273,0) AA6(-14.359,0) AA7(-13.444,0) AA8(-12.53,0) AA33(12.53,-0.914) AA34(13.444,-0.914) AA35(14.359,-0.914) AA36(15.273,-0.914) AA37(16.187,-0.914) AA38(17.102,-0.914) AB5(-15.273,-0.914) AB6(-14.359,-0.914) AB7(-13.444,-0.914) AB8(-12.53,-0.914) AB33(12.53,-1.829) AB34(13.444,-1.829) AB35(14.359,-1.829) AB36(15.273,-1.829) AB37(16.187,-1.829) AC5(-15.273,-1.829) AC6(-14.359,-1.829) AC7(-13.444,-1.829) AC8(-12.53,-1.829) AC33(12.53,-2.743) AC34(13.444,-2.743) AC35(14.359,-2.743) AC36(15.273,-2.743) AC37(16.187,-2.743) AD3(-17.102,-2.743) AD4(-16.187,-2.743) AD5(-15.273,-2.743) AD6(-14.359,-2.743) AD7(-13.444,-2.743) AD8(-12.53,-2.743) AD33(12.53,-3.658) AD34(13.444,-3.658) AD35(14.359,-3.658) AD36(15.273,-3.658) AD37(16.187,-3.658) AE3(-17.102,-3.658) AE4(-16.187,-3.658) AE5(-15.273,-3.658) AE6(-14.359,-3.658) AE7(-13.444,-3.658) AE8(-12.53,-3.658) AE33(12.53,-4.572) AE34(13.444,-4.572) AE35(14.359,-4.572) AE36(15.273,-4.572) AE37(16.187,-4.572) AE38(17.102,-4.572) AF4(-16.187,-4.572) AF5(-15.273,-4.572) AF6(-14.359,-4.572) AF7(-13.444,-4.572) AF8(-12.53,-4.572) AF33(12.53,-5.486) AF34(13.444,-5.486) AF35(14.359,-5.486) AF36(15.273,-5.486) AF37(16.187,-5.486) AF38(17.102,-5.486) AG4(-16.187,-5.486) AG5(-15.273,-5.486) AG6(-14.359,-5.486) AG7(-13.444,-5.486) AG8(-12.53,-5.486) AG33(12.53,-6.401) AG34(13.444,-6.401) AG35(14.359,-6.401) AG36(15.273,-6.401) AG37(16.187,-6.401) AG38(17.102,-6.401) AH3(-17.102,-6.401) AH4(-16.187,-6.401) AH5(-15.273,-6.401) AH6(-14.359,-6.401) AH7(-13.444,-6.401) AH8(-12.53,-6.401) AH33(12.53,-7.315) AH34(13.444,-7.315) AH35(14.359,-7.315) AH36(15.273,-7.315) AH37(16.187,-7.315) AH38(17.102,-7.315) AJ3(-17.102,-7.315) AJ4(-16.187,-7.315) AJ5(-15.273,-7.315) AJ6(-14.359,-7.315) AJ7(-13.444,-7.315) AJ8(-12.53,-7.315) AJ9(-11.615,-7.315) AJ11(-7.587,-8.23) AJ12(-6.673,-8.23) AJ13(-5.758,-8.23) AJ14(-4.844,-8.23) AJ15(-3.929,-8.23) AJ16(-3.015,-8.23) AJ17(-2.101,-8.23) AJ18(-1.186,-8.23) AJ19(-0.272,-8.23) AJ20(0.643,-8.23) AJ21(1.557,-8.23) AJ22(2.471,-8.23) AJ23(3.386,-8.23) AJ24(4.3,-8.23) AJ25(5.215,-8.23) AJ26(6.129,-8.23) AJ27(7.043,-8.23) AJ28(7.958,-8.23) AJ29(8.872,-8.23) AJ30(9.787,-8.23) AJ31(10.701,-8.23) AJ32(11.615,-8.23) AJ33(12.53,-8.23) AJ34(13.444,-8.23) AJ35(14.359,-8.23) AJ36(15.273,-8.23) AJ37(16.187,-8.23) AJ38(17.102,-8.23) AK3(-17.102,-8.23) AK4(-16.187,-8.23) AK5(-15.273,-8.23) AK6(-14.359,-8.23) AK7(-13.444,-8.23) AK8(-12.53,-8.23) AK9(-11.615,-8.23) AK10(-10.701,-8.23) AK11(-7.587,-9.144) AK12(-6.673,-9.144) AK13(-5.758,-9.144) AK14(-4.844,-9.144) AK15(-3.929,-9.144) AK16(-3.015,-9.144) AK17(-2.101,-9.144) AK18(-1.186,-9.144) AK19(-0.272,-9.144) AK20(0.643,-9.144) AK21(1.557,-9.144) AK22(2.471,-9.144) AK23(3.386,-9.144) AK24(4.3,-9.144) AK25(5.215,-9.144) AK26(6.129,-9.144) AK27(7.043,-9.144) AK28(7.958,-9.144) AK29(8.872,-9.144) AK30(9.787,-9.144) AK31(10.701,-9.144) AK32(11.615,-9.144) AK33(12.53,-9.144) AK34(13.444,-9.144) AK35(14.359,-9.144) AK36(15.273,-9.144) AK37(16.187,-9.144) AK38(17.102,-9.144) AL3(-17.102,-9.144) AL4(-16.187,-9.144) AL5(-15.273,-9.144) AL6(-14.359,-9.144) AL7(-13.444,-9.144) AL8(-12.53,-9.144) AL9(-11.615,-9.144) AL10(-10.701,-9.144) AL11(-7.587,-10.058) AL12(-6.673,-10.058) AL13(-5.758,-10.058) AL14(-4.844,-10.058) AL15(-3.929,-10.058) AL16(-3.015,-10.058) AL17(-2.101,-10.058) AL18(-1.186,-10.058) AL19(-0.272,-10.058) AL20(0.643,-10.058) AL21(1.557,-10.058) AL22(2.471,-10.058) AL23(3.386,-10.058) AL24(4.3,-10.058) AL25(5.215,-10.058) AL26(6.129,-10.058) AL27(7.043,-10.058) AL28(7.958,-10.058) AL29(8.872,-10.058) AL30(9.787,-10.058) AL31(10.701,-10.058) AL32(11.615,-10.058) AL33(12.53,-10.058) AL34(13.444,-10.058) AL35(14.359,-10.058) AL36(15.273,-10.058) AL37(16.187,-10.058) AL38(17.102,-10.058) AM3(-17.102,-10.058) AM4(-16.187,-10.058) AM5(-15.273,-10.058) AM6(-14.359,-10.058) AM7(-13.444,-10.058) AM8(-12.53,-10.058) AM9(-11.615,-10.058) AM10(-10.701,-10.058) AM11(-7.587,-10.973) AM12(-6.673,-10.973) AM13(-5.758,-10.973) AM14(-4.844,-10.973) AM15(-3.929,-10.973) AM16(-3.015,-10.973) AM17(-2.101,-10.973) AM18(-1.186,-10.973) AM19(-0.272,-10.973) AM20(0.643,-10.973) AM21(1.557,-10.973) AM22(2.471,-10.973) AM23(3.386,-10.973) AM24(4.3,-10.973) AM25(5.215,-10.973) AM26(6.129,-10.973) AM27(7.043,-10.973) AM28(7.958,-10.973) AM29(8.872,-10.973) AM30(9.787,-10.973) AM31(10.701,-10.973) AM32(11.615,-10.973) AM33(12.53,-10.973) AM34(13.444,-10.973) AM35(14.359,-10.973) AM36(15.273,-10.973) AM37(16.187,-10.973) AM38(17.102,-10.973) AN3(-17.102,-10.973) AN4(-16.187,-10.973) AN5(-15.273,-10.973) AN6(-14.359,-10.973) AN7(-13.444,-10.973) AN8(-12.53,-10.973) AN9(-11.615,-10.973) AN10(-10.701,-10.973) AN11(-7.587,-11.887) AN12(-6.673,-11.887) AN13(-5.758,-11.887) AN14(-4.844,-11.887) AN15(-3.929,-11.887) AN16(-3.015,-11.887) AN17(-2.101,-11.887) AN18(-1.186,-11.887) AN19(-0.272,-11.887) AN20(0.643,-11.887) AN21(1.557,-11.887) AN22(2.471,-11.887) AN23(3.386,-11.887) AN24(4.3,-11.887) AN25(5.215,-11.887) AN26(6.129,-11.887) AN27(7.043,-11.887) AN28(7.958,-11.887) AN29(8.872,-11.887) AN30(9.787,-11.887) AN31(10.701,-11.887) AN32(11.615,-11.887) AN33(12.53,-11.887) AN34(13.444,-11.887) AN35(14.359,-11.887) AN36(15.273,-11.887) AN37(16.187,-11.887) AN38(17.102,-11.887) AP3(-17.102,-11.887) AP4(-16.187,-11.887) AP5(-15.273,-11.887) AP6(-14.359,-11.887) AP7(-13.444,-11.887) AP8(-12.53,-11.887) AP9(-11.615,-11.887) AP10(-10.701,-11.887) AP11(-7.587,-12.802) AP12(-6.673,-12.802) AP13(-5.758,-12.802) AP14(-4.844,-12.802) AP15(-3.929,-12.802) AP16(-3.015,-12.802) AP17(-2.101,-12.802) AP18(-1.186,-12.802) AP19(-0.272,-12.802) AP20(0.643,-12.802) AP21(1.557,-12.802) AP22(2.471,-12.802) AP23(3.386,-12.802) AP24(4.3,-12.802) AP25(5.215,-12.802) AP26(6.129,-12.802) AP27(7.043,-12.802) AP28(7.958,-12.802) AP29(8.872,-12.802) AP30(9.787,-12.802) AP31(10.701,-12.802) AP32(11.615,-12.802) AP33(12.53,-12.802) AP34(13.444,-12.802) AP35(14.359,-12.802) AP36(15.273,-12.802) AP37(16.187,-12.802) AP38(17.102,-12.802) AR3(-17.102,-12.802) AR4(-16.187,-12.802) AR5(-15.273,-12.802) AR6(-14.359,-12.802) AR7(-13.444,-12.802) AR8(-12.53,-12.802) AR9(-11.615,-12.802) AR10(-10.701,-12.802) AR11(-7.587,-13.716) AR12(-6.673,-13.716) AR13(-5.758,-13.716) AR14(-4.844,-13.716) AR15(-3.929,-13.716) AR16(-3.015,-13.716) AR17(-2.101,-13.716) AR18(-1.186,-13.716) AR19(-0.272,-13.716) AR20(0.643,-13.716) AR21(1.557,-13.716) AR22(2.471,-13.716) AR23(3.386,-13.716) AR24(4.3,-13.716) AR25(5.215,-13.716) AR26(6.129,-13.716) AR27(7.043,-13.716) AR28(7.958,-13.716) AR29(8.872,-13.716) AR30(9.787,-13.716) AR31(10.701,-13.716) AR32(11.615,-13.716) AR33(12.53,-13.716) AR34(13.444,-13.716) AR35(14.359,-13.716) AR36(15.273,-13.716) AR37(16.187,-13.716) AR38(17.102,-13.716) AT3(-17.102,-13.716) AT4(-16.187,-13.716) AT5(-15.273,-13.716) AT6(-14.359,-13.716) AT7(-13.444,-13.716) AT8(-12.53,-13.716) AT9(-11.615,-13.716) AT10(-10.701,-13.716) AT11(-7.587,-14.63) AT12(-6.673,-14.63) AT13(-5.758,-14.63) AT14(-4.844,-14.63) AT15(-3.929,-14.63) AT16(-3.015,-14.63) AT17(-2.101,-14.63) AT18(-1.186,-14.63) AT19(-0.272,-14.63) AT20(0.643,-14.63) AT21(1.557,-14.63) AT22(2.471,-14.63) AT23(3.386,-14.63) AT24(4.3,-14.63) AT25(5.215,-14.63) AT26(6.129,-14.63) AT27(7.043,-14.63) AT28(7.958,-14.63) AT29(8.872,-14.63) AT30(9.787,-14.63) AT31(10.701,-14.63) AT32(11.615,-14.63) AT33(12.53,-14.63) AT34(13.444,-14.63) AT35(14.359,-14.63) AT36(15.273,-14.63) AT37(16.187,-14.63) AT38(17.102,-14.63) AU3(-17.102,-14.63) AU4(-16.187,-14.63) AU5(-15.273,-14.63) AU6(-14.359,-14.63) AU7(-13.444,-14.63) AU8(-12.53,-14.63) AU9(-11.615,-14.63) AU10(-10.701,-14.63) AU11(-7.587,-15.545) AU12(-6.673,-15.545) AU13(-5.758,-15.545) AU14(-4.844,-15.545) AU15(-3.929,-15.545) AU16(-3.015,-15.545) AU17(-2.101,-15.545) AU18(-1.186,-15.545) AU19(-0.272,-15.545) AU20(0.643,-15.545) AU21(1.557,-15.545) AU24(4.3,-15.545) AU25(5.215,-15.545) AU26(6.129,-15.545) AU27(7.043,-15.545) AU28(7.958,-15.545) AU29(8.872,-15.545) AU30(9.787,-15.545) AU31(10.701,-15.545) AU32(11.615,-15.545) AU33(12.53,-15.545) AU34(13.444,-15.545) AU35(14.359,-15.545) AU36(15.273,-15.545) AU37(16.187,-15.545) AU38(17.102,-15.545) AV3(-17.102,-15.545) AV4(-16.187,-15.545) AV5(-15.273,-15.545) AV6(-14.359,-15.545) AV7(-13.444,-15.545) AV8(-12.53,-15.545) AV9(-11.615,-15.545) AV10(-10.701,-15.545) AV11(-7.587,-16.459) AV12(-6.673,-16.459) AV13(-5.758,-16.459) AV14(-4.844,-16.459) AV24(4.3,-16.459) AV25(5.215,-16.459) AV28(7.958,-16.459) AV29(8.872,-16.459) AV37(16.187,-16.459) AW4(-16.187,-16.459) AW9(-11.615,-16.459) AW10(-10.701,-16.459) AW11(-7.587,-17.374) AW12(-6.673,-17.374) AW13(-5.758,-17.374) AW14(-4.844,-17.374) AY10(-10.701,-17.374) B5(-15.273,17.374) B6(-14.359,17.374) B7(-13.444,17.374) B25(3.015,17.374) B26(3.929,17.374) B27(4.844,17.374) B28(5.758,17.374) B29(6.673,17.374) B30(7.587,17.374) B31(10.701,16.459) B32(11.615,16.459) B33(12.53,16.459) B34(13.444,16.459) B35(14.359,16.459) B36(15.273,16.459) C4(-16.187,16.459) C5(-15.273,16.459) C6(-14.359,16.459) C7(-13.444,16.459) C8(-12.53,16.459) C9(-11.615,16.459) C12(-8.872,16.459) C13(-7.958,16.459) C14(-7.043,16.459) C15(-6.129,16.459) C16(-5.215,16.459) C17(-4.3,16.459) C25(3.015,16.459) C26(3.929,16.459) C27(4.844,16.459) C28(5.758,16.459) C29(6.673,16.459) C30(7.587,16.459) C31(10.701,15.545) C32(11.615,15.545) C33(12.53,15.545) C34(13.444,15.545) C35(14.359,15.545) C36(15.273,15.545) C37(16.187,15.545) C38(17.102,15.545) D3(-17.102,15.545) D4(-16.187,15.545) D5(-15.273,15.545) D6(-14.359,15.545) D7(-13.444,15.545) D8(-12.53,15.545) D9(-11.615,15.545) D10(-10.701,15.545) D11(-9.787,15.545) D12(-8.872,15.545) D13(-7.958,15.545) D14(-7.043,15.545) D15(-6.129,15.545) D16(-5.215,15.545) D17(-4.3,15.545) D18(-3.386,15.545) D24(2.101,15.545) D25(3.015,15.545) D26(3.929,15.545) D27(4.844,15.545) D28(5.758,15.545) D29(6.673,15.545) D30(7.587,15.545) D31(10.701,14.63) D32(11.615,14.63) D33(12.53,14.63) D34(13.444,14.63) D35(14.359,14.63) D36(15.273,14.63) D37(16.187,14.63) D38(17.102,14.63) D39(18.016,14.63) E3(-17.102,14.63) E4(-16.187,14.63) E5(-15.273,14.63) E6(-14.359,14.63) E7(-13.444,14.63) E8(-12.53,14.63) E9(-11.615,14.63) E10(-10.701,14.63) E11(-9.787,14.63) E12(-8.872,14.63) E13(-7.958,14.63) E14(-7.043,14.63) E15(-6.129,14.63) E16(-5.215,14.63) E17(-4.3,14.63) E18(-3.386,14.63) E19(-2.471,14.63) E21(-0.643,14.63) E23(1.186,14.63) E24(2.101,14.63) E25(3.015,14.63) E26(3.929,14.63) E27(4.844,14.63) E28(5.758,14.63) E29(6.673,14.63) E30(7.587,14.63) E31(10.701,13.716) E32(11.615,13.716) E33(12.53,13.716) E34(13.444,13.716) E35(14.359,13.716) E36(15.273,13.716) E37(16.187,13.716) E38(17.102,13.716) E39(18.016,13.716) F4(-16.187,13.716) F5(-15.273,13.716) F6(-14.359,13.716) F7(-13.444,13.716) F8(-12.53,13.716) F9(-11.615,13.716) F10(-10.701,13.716) F11(-9.787,13.716) F12(-8.872,13.716) F13(-7.958,13.716) F14(-7.043,13.716) F15(-6.129,13.716) F16(-5.215,13.716) F17(-4.3,13.716) F18(-3.386,13.716) F19(-2.471,13.716) F20(-1.557,13.716) F21(-0.643,13.716) F22(0.272,13.716) F23(1.186,13.716) F24(2.101,13.716) F25(3.015,13.716) F26(3.929,13.716) F27(4.844,13.716) F28(5.758,13.716) F29(6.673,13.716) F30(7.587,13.716) F31(10.701,12.802) F32(11.615,12.802) F33(12.53,12.802) F34(13.444,12.802) F35(14.359,12.802) F36(15.273,12.802) F37(16.187,12.802) F38(17.102,12.802) F39(18.016,12.802) F40(18.931,12.802) G3(-17.102,12.802) G4(-16.187,12.802) G5(-15.273,12.802) G6(-14.359,12.802) G7(-13.444,12.802) G8(-12.53,12.802) G9(-11.615,12.802) G10(-10.701,12.802) G11(-9.787,12.802) G12(-8.872,12.802) G13(-7.958,12.802) G14(-7.043,12.802) G15(-6.129,12.802) G16(-5.215,12.802) G17(-4.3,12.802) G18(-3.386,12.802) G19(-2.471,12.802) G20(-1.557,12.802) G21(-0.643,12.802) G22(0.272,12.802) G23(1.186,12.802) G24(2.101,12.802) G25(3.015,12.802) G26(3.929,12.802) G27(4.844,12.802) G28(5.758,12.802) G29(6.673,12.802) G30(7.587,12.802) G31(10.701,11.887) G32(11.615,11.887) G33(12.53,11.887) G34(13.444,11.887) G35(14.359,11.887) G36(15.273,11.887) G37(16.187,11.887) G38(17.102,11.887) G39(18.016,11.887) G40(18.931,11.887) H4(-16.187,11.887) H5(-15.273,11.887) H6(-14.359,11.887) H7(-13.444,11.887) H8(-12.53,11.887) H9(-11.615,11.887) H10(-10.701,11.887) H11(-9.787,11.887) H12(-8.872,11.887) H13(-7.958,11.887) H14(-7.043,11.887) H15(-6.129,11.887) H16(-5.215,11.887) H17(-4.3,11.887) H18(-3.386,11.887) H19(-2.471,11.887) H20(-1.557,11.887) H21(-0.643,11.887) H22(0.272,11.887) H23(1.186,11.887) H24(2.101,11.887) H25(3.015,11.887) H26(3.929,11.887) H27(4.844,11.887) H28(5.758,11.887) H29(6.673,11.887) H30(7.587,11.887) H31(10.701,10.973) H32(11.615,10.973) H33(12.53,10.973) H34(13.444,10.973) H35(14.359,10.973) H36(15.273,10.973) H37(16.187,10.973) H38(17.102,10.973) H39(18.016,10.973) H40(18.931,10.973) J3(-17.102,10.973) J4(-16.187,10.973) J5(-15.273,10.973) J6(-14.359,10.973) J7(-13.444,10.973) J8(-12.53,10.973) J9(-11.615,10.973) J10(-10.701,10.973) J11(-9.787,10.973) J12(-8.872,10.973) J13(-7.958,10.973) J14(-7.043,10.973) J15(-6.129,10.973) J16(-5.215,10.973) J17(-4.3,10.973) J18(-3.386,10.973) J19(-2.471,10.973) J20(-1.557,10.973) J21(-0.643,10.973) J22(0.272,10.973) J23(1.186,10.973) J24(2.101,10.973) J25(3.015,10.973) J26(3.929,10.973) J27(4.844,10.973) J28(5.758,10.973) J29(6.673,10.973) J30(7.587,10.973) J31(10.701,10.058) J32(11.615,10.058) J33(12.53,10.058) J34(13.444,10.058) J35(14.359,10.058) J36(15.273,10.058) J37(16.187,10.058) J38(17.102,10.058) J39(18.016,10.058) J40(18.931,10.058) K4(-16.187,10.058) K5(-15.273,10.058) K6(-14.359,10.058) K7(-13.444,10.058) K8(-12.53,10.058) K9(-11.615,10.058) K10(-10.701,10.058) K11(-9.787,10.058) K12(-8.872,10.058) K13(-7.958,10.058) K14(-7.043,10.058) K15(-6.129,10.058) K16(-5.215,10.058) K17(-4.3,10.058) K18(-3.386,10.058) K19(-2.471,10.058) K20(-1.557,10.058) K21(-0.643,10.058) K22(0.272,10.058) K23(1.186,10.058) K24(2.101,10.058) K25(3.015,10.058) K26(3.929,10.058) K27(4.844,10.058) K28(5.758,10.058) K29(6.673,10.058) K30(7.587,10.058) K31(10.701,9.144) K32(11.615,9.144) K33(12.53,9.144) K34(13.444,9.144) K35(14.359,9.144) K36(15.273,9.144) K37(16.187,9.144) K38(17.102,9.144) K39(18.016,9.144) K40(18.931,9.144) L3(-17.102,9.144) L4(-16.187,9.144) L5(-15.273,9.144) L6(-14.359,9.144) L7(-13.444,9.144) L8(-12.53,9.144) L9(-11.615,9.144) L10(-10.701,9.144) L11(-9.787,9.144) L12(-8.872,9.144) L13(-7.958,9.144) L14(-7.043,9.144) L15(-6.129,9.144) L16(-5.215,9.144) L17(-4.3,9.144) L18(-3.386,9.144) L19(-2.471,9.144) L20(-1.557,9.144) L21(-0.643,9.144) L22(0.272,9.144) L23(1.186,9.144) L24(2.101,9.144) L25(3.015,9.144) L26(3.929,9.144) L27(4.844,9.144) L28(5.758,9.144) L29(6.673,9.144) L30(7.587,9.144) L31(10.701,8.23) L32(11.615,8.23) L33(12.53,8.23) L34(13.444,8.23) L35(14.359,8.23) L36(15.273,8.23) L37(16.187,8.23) L38(17.102,8.23) L39(18.016,8.23) L40(18.931,8.23) M4(-16.187,8.23) M5(-15.273,8.23) M6(-14.359,8.23) M7(-13.444,8.23) M8(-12.53,8.23) M9(-11.615,8.23) M10(-10.701,8.23) M11(-9.787,8.23) M12(-8.872,8.23) M13(-7.958,8.23) M14(-7.043,8.23) M15(-6.129,8.23) M16(-5.215,8.23) M17(-4.3,8.23) M18(-3.386,8.23) M19(-2.471,8.23) M20(-1.557,8.23) M21(-0.643,8.23) M22(0.272,8.23) M23(1.186,8.23) M24(2.101,8.23) M25(3.015,8.23) M26(3.929,8.23) M27(4.844,8.23) M28(5.758,8.23) M29(6.673,8.23) M30(7.587,8.23) M32(11.615,7.315) M33(12.53,7.315) M34(13.444,7.315) M35(14.359,7.315) M36(15.273,7.315) M37(16.187,7.315) M38(17.102,7.315) M39(18.016,7.315) M40(18.931,7.315) N3(-17.102,7.315) N4(-16.187,7.315) N5(-15.273,7.315) N6(-14.359,7.315) N7(-13.444,7.315) N8(-12.53,7.315) N33(12.53,6.401) N34(13.444,6.401) N35(14.359,6.401) N36(15.273,6.401) N37(16.187,6.401) N38(17.102,6.401) N39(18.016,6.401) N40(18.931,6.401) P4(-16.187,6.401) P5(-15.273,6.401) P6(-14.359,6.401) P7(-13.444,6.401) P8(-12.53,6.401) P33(12.53,5.486) P34(13.444,5.486) P35(14.359,5.486) P36(15.273,5.486) P37(16.187,5.486) P38(17.102,5.486) P39(18.016,5.486) P40(18.931,5.486) R3(-17.102,5.486) R4(-16.187,5.486) R5(-15.273,5.486) R6(-14.359,5.486) R7(-13.444,5.486) R8(-12.53,5.486) R33(12.53,4.572) R34(13.444,4.572) R35(14.359,4.572) R36(15.273,4.572) R37(16.187,4.572) R38(17.102,4.572) R39(18.016,4.572) R40(18.931,4.572) T4(-16.187,4.572) T5(-15.273,4.572) T6(-14.359,4.572) T7(-13.444,4.572) T8(-12.53,4.572) T33(12.53,3.658) T34(13.444,3.658) T35(14.359,3.658) T36(15.273,3.658) T37(16.187,3.658) T38(17.102,3.658) T39(18.016,3.658) T40(18.931,3.658) U4(-16.187,3.658) U5(-15.273,3.658) U6(-14.359,3.658) U7(-13.444,3.658) U8(-12.53,3.658) U33(12.53,2.743) U34(13.444,2.743) U35(14.359,2.743) U36(15.273,2.743) U37(16.187,2.743) U38(17.102,2.743) U39(18.016,2.743) U40(18.931,2.743) V4(-16.187,2.743) V5(-15.273,2.743) V6(-14.359,2.743) V7(-13.444,2.743) V8(-12.53,2.743) V33(12.53,1.829) V34(13.444,1.829) V35(14.359,1.829) V36(15.273,1.829) V37(16.187,1.829) V38(17.102,1.829) V39(18.016,1.829) V40(18.931,1.829) W4(-16.187,1.829) W5(-15.273,1.829) W6(-14.359,1.829) W7(-13.444,1.829) W8(-12.53,1.829) W33(12.53,0.914) W34(13.444,0.914) W35(14.359,0.914) W36(15.273,0.914) W37(16.187,0.914) W38(17.102,0.914) Y5(-15.273,0.914) Y6(-14.359,0.914) Y7(-13.444,0.914) Y8(-12.53,0.914) Y33(12.53,0) Y34(13.444,0) Y35(14.359,0) Y36(15.273,0) Y37(16.187,0) Y38(17.102,0)
  oval 0.356x0.457 smd: A11(-9.787,18.288) A12(-8.872,18.288) A13(-7.958,18.288) A14(-7.043,18.288) A15(-6.129,18.288) A16(-5.215,18.288) A17(-4.3,18.288) A18(-3.386,18.288) A23(1.186,18.288) A24(2.101,18.288) AU22(2.471,-15.545) AU23(3.386,-15.545) AV15(-3.929,-16.459) AV16(-3.015,-16.459) AV17(-2.101,-16.459) AV18(-1.186,-16.459) AV19(-0.272,-16.459) AV20(0.643,-16.459) AV21(1.557,-16.459) AV22(2.471,-16.459) AV23(3.386,-16.459) AV26(6.129,-16.459) AV27(7.043,-16.459) AV30(9.787,-16.459) AV31(10.701,-16.459) AV32(11.615,-16.459) AV33(12.53,-16.459) AV34(13.444,-16.459) AV35(14.359,-16.459) AV36(15.273,-16.459) AW5(-15.273,-16.459) AW6(-14.359,-16.459) AW7(-13.444,-16.459) AW8(-12.53,-16.459) AW15(-3.929,-17.374) AW16(-3.015,-17.374) AW17(-2.101,-17.374) AW18(-1.186,-17.374) AW23(3.386,-17.374) AW24(4.3,-17.374) AW25(5.215,-17.374) AW26(6.129,-17.374) AW27(7.043,-17.374) AW28(7.958,-17.374) AW29(8.872,-17.374) AW30(9.787,-17.374) AW31(10.701,-17.374) AW32(11.615,-17.374) AW33(12.53,-17.374) AW34(13.444,-17.374) AW35(14.359,-17.374) AW36(15.273,-17.374) AY5(-15.273,-17.374) AY6(-14.359,-17.374) AY7(-13.444,-17.374) AY8(-12.53,-17.374) AY9(-11.615,-17.374) AY11(-7.587,-18.288) AY12(-6.673,-18.288) AY13(-5.758,-18.288) AY14(-4.844,-18.288) AY15(-3.929,-18.288) AY16(-3.015,-18.288) AY17(-2.101,-18.288) AY18(-1.186,-18.288) AY23(3.386,-18.288) AY24(4.3,-18.288) AY25(5.215,-18.288) AY26(6.129,-18.288) AY27(7.043,-18.288) AY28(7.958,-18.288) AY29(8.872,-18.288) AY30(9.787,-18.288) AY31(10.701,-18.288) B8(-12.53,17.374) B9(-11.615,17.374) B10(-10.701,17.374) B11(-9.787,17.374) B12(-8.872,17.374) B13(-7.958,17.374) B14(-7.043,17.374) B15(-6.129,17.374) B16(-5.215,17.374) B17(-4.3,17.374) B18(-3.386,17.374) B23(1.186,17.374) B24(2.101,17.374) C10(-10.701,16.459) C11(-9.787,16.459) C18(-3.386,16.459) C19(-2.471,16.459) C20(-1.557,16.459) C21(-0.643,16.459) C22(0.272,16.459) C23(1.186,16.459) C24(2.101,16.459) D19(-2.471,15.545) D20(-1.557,15.545) D21(-0.643,15.545) D22(0.272,15.545) D23(1.186,15.545) E20(-1.557,14.63) E22(0.272,14.63)
  oval 0.457x0.356 smd: AA3(-17.102,0) AA4(-16.187,0) AB3(-17.102,-0.914) AB4(-16.187,-0.914) AB38(17.102,-1.829) AB39(18.016,-1.829) AB40(18.931,-1.829) AC1(-18.931,-1.829) AC2(-18.016,-1.829) AC3(-17.102,-1.829) AC4(-16.187,-1.829) AC38(17.102,-2.743) AC39(18.016,-2.743) AC40(18.931,-2.743) AD1(-18.931,-2.743) AD2(-18.016,-2.743) AD38(17.102,-3.658) AD39(18.016,-3.658) AD40(18.931,-3.658) AE1(-18.931,-3.658) AE2(-18.016,-3.658) AE39(18.016,-4.572) AE40(18.931,-4.572) AF1(-18.931,-4.572) AF2(-18.016,-4.572) AF3(-17.102,-4.572) AF39(18.016,-5.486) AF40(18.931,-5.486) AG1(-18.931,-5.486) AG2(-18.016,-5.486) AG3(-17.102,-5.486) AG39(18.016,-6.401) AG40(18.931,-6.401) AH1(-18.931,-6.401) AH2(-18.016,-6.401) AH39(18.016,-7.315) AH40(18.931,-7.315) AJ1(-18.931,-7.315) AJ2(-18.016,-7.315) AJ39(18.016,-8.23) AJ40(18.931,-8.23) AK1(-18.931,-8.23) AK2(-18.016,-8.23) AK39(18.016,-9.144) AK40(18.931,-9.144) AL1(-18.931,-9.144) AL2(-18.016,-9.144) AL39(18.016,-10.058) AL40(18.931,-10.058) AM1(-18.931,-10.058) AM2(-18.016,-10.058) AM39(18.016,-10.973) AM40(18.931,-10.973) AN1(-18.931,-10.973) AN2(-18.016,-10.973) AN39(18.016,-11.887) AN40(18.931,-11.887) AP1(-18.931,-11.887) AP2(-18.016,-11.887) AP39(18.016,-12.802) AP40(18.931,-12.802) AR1(-18.931,-12.802) AR2(-18.016,-12.802) AR39(18.016,-13.716) AR40(18.931,-13.716) AT1(-18.931,-13.716) AT2(-18.016,-13.716) AT39(18.016,-14.63) AU2(-18.016,-14.63) E1(-18.931,14.63) E2(-18.016,14.63) F1(-18.931,13.716) F2(-18.016,13.716) F3(-17.102,13.716) G1(-18.931,12.802) G2(-18.016,12.802) H1(-18.931,11.887) H2(-18.016,11.887) H3(-17.102,11.887) J1(-18.931,10.973) J2(-18.016,10.973) K1(-18.931,10.058) K2(-18.016,10.058) K3(-17.102,10.058) L1(-18.931,9.144) L2(-18.016,9.144) M1(-18.931,8.23) M2(-18.016,8.23) M3(-17.102,8.23) N1(-18.931,7.315) N2(-18.016,7.315) P1(-18.931,6.401) P2(-18.016,6.401) P3(-17.102,6.401) R1(-18.931,5.486) R2(-18.016,5.486) T1(-18.931,4.572) T2(-18.016,4.572) T3(-17.102,4.572) U1(-18.931,3.658) U2(-18.016,3.658) U3(-17.102,3.658) V1(-18.931,2.743) V2(-18.016,2.743) V3(-17.102,2.743) W1(-18.931,1.829) W2(-18.016,1.829) W3(-17.102,1.829) Y3(-17.102,0.914) Y4(-16.187,0.914)
