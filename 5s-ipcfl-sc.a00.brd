# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
MX_SOD123
  rect 1.321x1.372 smd: 1(1.74,0) 2(-1.74,0)
MX_SOIC_8P_26_118X110_MAXIM
  rect 0.356x1.092 smd: 1(-0.975,-1.465) 2(-0.325,-1.465) 3(0.325,-1.465) 4(0.975,-1.465) 5(0.975,1.465) 6(0.325,1.465) 7(-0.325,1.465) 8(-0.975,1.465)
MX_SOIC_8P_50_197X236
  rect 0.61x1.524 smd: 1(-1.905,-2.857) 2(-0.635,-2.857) 3(0.635,-2.857) 4(1.905,-2.857) 5(1.905,2.857) 6(0.635,2.857) 7(-0.635,2.857) 8(-1.905,2.857)
MX_SOIC_8P_50_201X236_P_NIK
  rect 0.635x1.549 smd: 1(-1.905,-2.833) 2(-0.635,-2.833) 3(0.635,-2.833) 4(1.905,-2.833) 5(1.905,2.833) 6(0.635,2.833) 7(-0.635,2.833) 8(-1.905,2.833)
  rect 3.607x2.692 smd: 9(0,0)
MX_SOIC_8P_50_201X236_PAD
  rect 0.635x1.549 smd: 1(-1.905,-2.835) 2(-0.635,-2.835) 3(0.635,-2.835) 4(1.905,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
  rect 3.505x2.515 smd: 9(0,0)
MX_SOIC_8P_50_213X311
  rect 0.635x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
MX_SOT23
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
MX_SOT23_2D4_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
MX_SOT23_2D4_H44
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
MX_SOT23_2D4_H51
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
MX_SOT23_2D4_H55
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
MX_SOT23_H43
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
MX_SOT23_H43_COLAY
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
MX_SOT23_H61
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
MX_SOT23_S5_2D4_122X67_H35
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
MX_SOT23_S5_H57
  rect 1.118x0.61 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
MX_SOT23_S6_FITI
  rect 0.61x1.118 smd: 1(-0.95,-1.451) 2(0,-1.451) 3(0.95,-1.451) 4(0.95,1.451) 5(0,1.451) 6(-0.95,1.451)
MX_SOT323
  rect 0.914x0.813 smd: 1(0.97,-0.65) 2(0.97,0.65) 3(-0.97,0)
MX_SOT323_S5
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(-0.65,1.19)
MX_SOT363
  rect 0.406x0.762 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
MX_SOT363_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
MX_SOT1220_NXP
  rect 0.356x0.432 smd: 1(-0.65,-0.935) 2(0,-0.935) 3(0.65,-0.935) 4(0.65,0.935) 5(0,0.935) 6(-0.65,0.935)
  rect 1.245x1.092 smd: 7(-0.285,0)
  rect 0.356x0.66 smd: 8(0.775,0)
MX_SW_4P_181X126
  rect 1.041x0.66 smd: 1(-2.075,1.075) 2(2.075,1.075) 3(-2.075,-1.075) 4(2.075,-1.075)
MX_TO252_LF3
  rect 2.286x0.965 smd: 1(-3.48,2.311) 3(-3.48,-2.286)
  rect 6.223x6.68 smd: 2(3.023,0)
MX_TPC26T_S4_68
  round 0.66 smd: 1(0,0)
MX_USB_4X4P_6HD_RA_FOX_LF5
  oval 1.6x2.718 hole 1.194x2.311: 1(-6.45,11.18) 2(6.45,11.18)
  round 3.073 hole 2.311: 3(-6.57,5.68) 4(6.57,5.68) 5(-6.57,0) 6(6.57,0)
  rect 1.321x1.321 hole 0.914: 11(-3.5,2.71)
  round 1.321 hole 0.914: 12(-1,2.71) 13(1,2.71) 14(3.5,2.71) 21(-3.5,5.33) 22(-1,5.33) 23(1,5.33) 24(3.5,5.33) 31(-3.5,7.95) 32(-1,7.95) 33(1,7.95) 34(3.5,7.95) 41(-3.5,10.57) 42(-1,10.57) 43(1,10.57) 44(3.5,10.57)
MX_USBX4_CON_36P_6HD_RA_LF5
  oval 1.524x3.2 hole 0.508x2.184: 1(-6.57,11.18) 2(6.57,11.18)
  round 3.073 hole 2.311: 3(-6.57,5.68) 4(6.57,5.68) 5(-6.57,0) 6(6.57,0)
  rect 1.118x1.118 hole 0.711: 11(-3.5,2)
  round 1.118 hole 0.711: 12(-1,2) 13(1,2) 14(3.5,2) 15(4,3.5) 16(2,3.5) 17(0,3.5) 18(-2,3.5) 19(-4,3.5) 21(-3.5,5.2) 22(-1,5.2) 23(1,5.2) 24(3.5,5.2) 25(4,6.7) 26(2,6.7) 27(0,6.7) 28(-2,6.7) 29(-4,6.7) 31(-3.5,8.4) 32(-1,8.4) 33(1,8.4) 34(3.5,8.4) 35(4,9.9) 36(2,9.9) 37(0,9.9) 38(-2,9.9) 39(-4,9.9) 41(-3.5,11.6) 42(-1,11.6) 43(1,11.6) 44(3.5,11.6) 45(4,13.1) 46(2,13.1) 47(0,13.1) 48(-2,13.1) 49(-4,13.1)
MX_VARISTOR_0402
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
MX_WAFER_HD_1X12P_79_HD_LF5
  round 1.245 hole 1.245 unplated: (-11,1.8)
  rect 1.372x1.372 hole 0.965: 1(11,0)
  round 1.372 hole 0.965: 2(9,0) 3(7,0) 4(5,0) 5(3,0) 6(1,0) 7(-1,0) 8(-3,0) 9(-5,0) 10(-7,0) 11(-9,0) 12(-11,0)
MX_WF_HD_1X4P_1H_LF3
  round 1.245 hole 1.245 unplated: (-3.81,-2.16)
  rect 1.575x1.575 hole 1.168: 1(3.81,0)
  round 1.575 hole 1.168: 2(1.27,0) 3(-1.27,0) 4(-3.81,0)
MX_WF_HD_1X4P_100_HD_LF3
  round 1.245 hole 1.245 unplated: (-3.81,-2.16)
  rect 1.575x1.575 hole 1.168: 1(3.81,0)
  round 1.575 hole 1.168: 2(1.27,0) 3(-1.27,0) 4(-3.81,0)
MX_WTOB_4P_49_2H_XINA
  rect 0.787x1.6 smd: 1(1.875,2.9) 2(0.625,2.9) 3(-0.625,2.9) 4(-1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
MX_XTAL_4P_126X98_HELE
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
MX_XTAL_4P_126X98_HELE_H31
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
MX_XTAL_4P_126X98_HOSON_H35
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
MX_XTAL_4P_272X55
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)
SHORTPIN
  custom 0.184x0.184 smd: 1(-0.521,0) 2(0.521,0)
SOIC_8P_50_197X236
  rect 0.61x1.524 smd: 1(-1.905,-2.857) 2(-0.635,-2.857) 3(0.635,-2.857) 4(1.905,-2.857) 5(1.905,2.858) 6(0.635,2.858) 7(-0.635,2.858) 8(-1.905,2.858)
TX_R0402
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
unnamed#2
  custom 0.286x0.286 smd: 1(0,0)

## Nets
1VSB_POWERIN: PR70249.1 U104.95(BACKFEED_CUT#/GP116)
3VA_ADJ_A: PC241.1 PQ33.1(ADJ) PR192.1 PR193.1
3VA_ADJ_C_A: PJP20.1 PR192.2
3VA_ADJ_R_A: PR193.2 PR194.2
5V_PRSENT: PQ9779.3(COLLECTOR) RN25.7(3) U104.100((5V_PRSNT)GP047/TXD1)
5VDUAL_EN: PR196.1 U104.67(LATCHED_BF_CUT/GP035)
+1V_DCPDSW: PCH.BC29(DCPDSW_1P0) SCB19.1 SCB122.1
+1V_ST: HC3.1 HC4.1 HR9.1 HR11.1 HR23.1 HR24.1 HR25.2 HR32.1 HR33.1 O2CB10.1 OR3.1 OR52.1 PC272.1 PC5814.1 PQ60.2(SOURCE) PR340.2 PR5817.1 PR5818.1 PR5821.1 PR5823.1 SR287.1 SR289.1 SR292.1 U104.29(PECIVREF) XU1.V4(VCCPLL) XU1.V5(VCCST_1) XU1.V6(VCCST_2)
+1VSB: PC213.1 PC273.1 PCE18.1 PCH.AA23(VCCPRIM_1P0_4) PCH.AA25(VCCPRIM_1P0) PCH.AB23(VCCPRIM_1P0_1) PCH.AB26(VCCPRIM_1P0_2) PCH.AB28(VCCPRIM_1P0_3) PCH.AD23(VCCPRIM_1P0_6) PCH.AD26(VCCPRIM_1P0_7) PCH.AD28(VCCPRIM_1P0_8) PCH.AF23(VCCPRIM_1P0_10) PCH.AF26(VCCPRIM_1P0_11) PCH.AK5(VCCUSB2PLL_1P0_2) PCH.AK20(VCCPRIM_1P0_12) PCH.AK21(VCCPRIM_1P0_13) PCH.AK23(VCCPRIM_1P0_14) PCH.AK25(VCCPRIM_1P0_15) PCH.AM5(VCCUSB2PLL_1P0_1) PCH.AM22(VCCPRIM_1P0_16) PCH.AR19(VCCHDAPLL_1P0) PCH.N17(VCCCLK1) PCH.T17(VCCCLK2_1) PCH.T19(VCCCLK3) PCH.V20(VCCCLK4) PCH.V21(VCCMPHY_1P0_5) PCH.V23(VCCMPHY_1P0_4) PCH.V25(VCCMPHY_1P0_3) PCH.V26(VCCMPHY_1P0_2) PCH.V28(VCCMPHY_1P0_6) PCH.V29(VCCMPHY_1P0_1) PCH.W28(VCCAPLLEBB_1P1) PJP19.1 PL13.2 PQ60.3(DRAIN) PR340.1 PR70246.1 SCB1.1 SCB2.1 SCB8.1 SCB9.1 SCB11.1 SCB16.1 SR12.1 SR43.1 SR49.1 SR165.1 SR400.1 SR411.1 XDP2.43(VCC_OBS_AB) XDP2.44(VCC_OBS_CD)
+1VSB_BOT_C: PR161.1 PU9.10(BOOT)
+1VSB_BOTR_C: PC210.2 PR161.2
+1VSB_DUAL_IN_CRT_MAIN: PR70249.2 PR70250.2 Q53.2(GATE) Q53.5(GATE)
+1VSB_DUAL_IN_CRT_MAIN_R: PR134.1 PR302.2 Q53.6(DRAIN)
+1VSB_DUAL_IN_CRT_MAIN_R3: PC339.1 PQ56.4(G) PR134.2 PR139.1
+1VSB_DUAL_IN_CRT_SB_R: PR135.1 PR305.2 Q53.3(DRAIN)
+1VSB_DUAL_IN_CRT_SB_R3: PC131.1 PQ54.1(GATE) PR135.2 PR137.1
+1VSB_EN_A: PC209.1 PR162.2 PU9.3(EN)
+1VSB_FB_A: PC217.2 PR172.1 PR175.1 PU9.4(FB)
+1VSB_FB_C_A: PC217.1 PR172.2 PR173.1
+1VSB_FB_RC_A: PC218.1 PJP19.2 PR173.2
+1VSB_HG_D: PR163.1 PU9.9(UGATE)
+1VSB_HGR_D: PC211.1 PQ40.1(G1) PR163.2 PR164.2
+1VSB_LG_D: PR70291.1 PU9.6(LGATE)
+1VSB_LG_SW_D: PC343.1 PQ40.8(G2) PR171.1 PR70291.2
+1VSB_PWRGD: PR167.2 PR170.1 PU9.1(PGOOD)
+1VSB_SN: PC215.1 PR166.2
+1VSB_SW_C: PC210.1 PC211.2 PC214.1 PL13.1 PQ40.9(S1/D2) PR164.1 PR166.1 PU9.8(PHASE)
+1VSB_TRIP: PR174.2 PU9.2(CS)
+1VSB_TST_A: PR168.2 PR170.2 PU9.5(RF)
+1VSB_VCC_A: PC212.1 PR165.2 PU9.7(VCC)
+1VSB_VIN: PC205.1 PC206.1 PC207.1 PCE17.1 PL12.1 PQ40.2(D1_1) PQ40.3(D1_2) PQ40.4(D1_3) PQ40.10(D1_4)
+3.3V_SUS: APR112.1 AR237.1 AR238.1 AR241.2 AR242.2 AR243.2 AR244.1 PC640681.1 PQ9786.3(DRAIN) PR341.2 U4.20(VCCSUS1) U4.24(VCCSUS2) U5.5(VCC_1) U5.29(VCC_2) UC75.1 UC965.1 UC971.1
+5V: AC187.1 CON4.4(+5V1) CON4.6(+5V2) CON4.21(+5V3) CON4.22(+5V4) CON4.23(+5V5) M1R4.1 M1R5.1 MQ15.1(GATE) P1CB3.1 P1CB5.1 P1CB12.1 P1R1.1 P_HDDFAN.4 PQ34.1(S_1) PQ34.2(S_2) PQ34.3(S_3) PQ56.1(S_1) PQ56.2(S_2) PQ56.3(S_3) PQ9779.2(EMITTER) PR6.1 PR5806.2 PR5809.2 PR5876.1 PT1.1 PT2.1 PT3.1 PT4.1 PT5.1 S/PDIF.2(VCC) SR17.1 U2FC1.1 U2FC2.1 UF7.1
+5V_1VSB_IN: C9357.2 C941399.1 CB4123.1 PC208.1 PC341.1 PL12.2 PQ54.3(DRAIN) PQ56.5(D) SR7676.1 U51.1(IN) U942691.1(IN) UCE11.1 UR5.1 UR69714.1 UR69715.1 UR69717.1 UU51.5(IN)
+5V_CHARGER_1: C941400.1 P24.2 SR7564.1 U51.12(OUT) UC9.1 UC11.1 UC974.1
+5V_CHARGER_2: C941401.1 P24.1 P24.3 SR7565.1 U942691.12(OUT) UC10.1 UC12.1 UC16.1 UC973.1
+5V_DISCHARGE: MQ26.6(DRAIN) PR6.2
+5V_DUAL: CB4112.1 CB4114.1 CB4116.1 CB4119.1 CB4125.1 CB4126.1 CR19.1 PC118.1 PC243.1 PC6526.1 PCE6212.1 PL1.2 PQ34.5(D) PQ37.3(DRAIN) PR8.1 PR6601.1 PR6602.1 PR6605.1 PR6607.1 PR70219.1 PU7.8(SVIN) PU7.9(PVIN1) PU7.10(PVIN2) SR7677.2 SR7678.2 TUU2.5(IN) UF5.1 UR30.1 UR69710.2 UR69711.2 UR69719.1 UR69721.1 UR69723.1 UR69726.1 UR69729.1 UR69730.1 UU45.5(IN) UU47.5(IN) UU50.5(IN) UU54.5(IN)
+5V_DUAL_CRT_MAIN: PR196.2 Q35.2(GATE) Q35.5(GATE)
+5V_DUAL_CRT_MAIN_R: PR121.1 PR195.2 Q35.6(DRAIN)
+5V_DUAL_CRT_MAIN_R3: PC242.1 PQ34.4(G) PR121.2 PR138.1
+5V_DUAL_CRT_SB_R: PR122.1 PR199.2 Q35.3(DRAIN)
+5V_DUAL_CRT_SB_R3: PC132.1 PQ37.1(GATE) PR122.2 PR198.1
+5V_DUAL_DISCHARGE: MQ24.3(DRAIN) PR8.2
+5V_LDO: AC16.1 AC17.1 AC18.1 AC19.1 AU1.25(LDO-OUT1) AU1.38(LDO-OUT2)
+5VA: AD2.1(ANODE) AL1.1 AR233.2 AR235.2 CON4.9(5VSB) M1R40.1 OR5.2 OR68.1 OR69.1 P1CB2.1 P1R3.1 PC233.1 PC238.1 PQ31.2(SOURCE) PQ33.3(VIN) PR165.1 PR188.1 PR189.1 PR199.1 PR248.1 PR305.1 PR511.1 PR512.1 PT6.1 PT7.1 PT8.1 PT9.1 PT10.1 R36.1
+5VSB: M2R52.1 PC234.1 PQ31.3(DRAIN) PR123.1 PR6810.1 PR70296.1 RFC116.1
+5VSB_AUDIO: AC3.1 AC4.1 AL1.2 AU1.29(LDO-IN)
+12V: CON4.10(+12V1) CON4.11(+12V2) P1CB1.1 PC151.1 PR5.1 PR195.1 PR302.1 PR70254.1 PT11.1 PT12.1 PT13.1 PT14.1 PT15.1 PU5.6(VCC) SR628.1
+12V_CPU: FC14.1 FC15.1 FC16.1 FCE1.1 FCE4.1 FCE5.1 O2R3.2 P1CB10.1 P1CB11.1 P1CB13.1 P1CB14.1 P1CB15.1 P1CB16.1 P1CB17.1 P3.3 P3.4 P29.2 P70.2 P458.2 P461.2 PC137.1 PC138.1 PC617.1 PC618.1 PC619.1 PC620.1 PC5917.1 PC5918.1 PC5919.1 PC5920.1 PC6117.1 PC6118.1 PC6119.1 PC6120.1 PC640683.1 PC640686.1 PCE11.1 PCE591.1 PCE601.1 PCE611.1 PJP595.2 PJP615.2 PQ28.1(DRAIN1) PQ28.2(DRAIN2) PQ28.5(DRAIN3) PQ28.6(DRAIN4) PQ28.7(DRAIN5) PQ591.5(D) PQ591.6(D_1) PQ591.7(D_2) PQ591.8(D_3) PQ591.9(D_4) PQ591.10(D_5) PQ591.11(D_6) PQ591.12(D_7) PQ591.13(D_8) PQ591.14(D_9) PQ594.5(D) PQ594.6(D_1) PQ594.7(D_2) PQ594.8(D_3) PQ594.9(D_4) PQ594.10(D_5) PQ594.11(D_6) PQ594.12(D_7) PQ594.13(D_8) PQ594.14(D_9) PQ601.5(D) PQ601.6(D_1) PQ601.7(D_2) PQ601.8(D_3) PQ601.9(D_4) PQ601.10(D_5) PQ601.11(D_6) PQ601.12(D_7) PQ601.13(D_8) PQ601.14(D_9) PQ604.5(D) PQ604.6(D_1) PQ604.7(D_2) PQ604.8(D_3) PQ604.9(D_4) PQ604.10(D_5) PQ604.11(D_6) PQ604.12(D_7) PQ604.13(D_8) PQ604.14(D_9) PQ611.5(D) PQ611.6(D_1) PQ611.7(D_2) PQ611.8(D_3) PQ611.9(D_4) PQ611.10(D_5) PQ611.11(D_6) PQ611.12(D_7) PQ611.13(D_8) PQ611.14(D_9) PQ614.5(D) PQ614.6(D_1) PQ614.7(D_2) PQ614.8(D_3) PQ614.9(D_4) PQ614.10(D_5) PQ614.11(D_6) PQ614.12(D_7) PQ614.13(D_8) PQ614.14(D_9) PR602.1 PR609.1 PR5875.1 PR5902.1 PR5909.1 PR6102.1 PR6109.1 PR70202.1 PT51.1 PT52.1 PT53.1 PT54.1 PT55.1 PT56.1 PT57.1 PT58.1 PT59.1 PT60.1 RFC118.1 RFC119.1
+12V_DISCHARGE: MQ26.3(DRAIN) PR5.2
+12V_GFX: GPU_PWR.5 GPU_PWR.6 GPU_PWR.7 GPU_PWR.8 PCE23.1 PT265.1 PT266.1 PT267.1 PT268.1 PT269.1 PT270.1 PT271.1 PT272.1 PT273.1 PT274.1 SLOT1.A2(+12V_3) SLOT1.A3(+12V_4) SLOT1.B1(+12V_1) SLOT1.B2(+12V_2) SLOT1.B3(RSVD1) SLOT2.A2(+12V_4) SLOT2.A3(+12V_5) SLOT2.B1(+12V_1) SLOT2.B2(+12V_2) SLOT2.B3(+12V_3) SLOT3.A2(+12V_4) SLOT3.A3(+12V_5) SLOT3.B1(+12V_1) SLOT3.B2(+12V_2) SLOT3.B3(+12V_3) SLOT4.A2(+12V_3) SLOT4.A3(+12V_4) SLOT4.B1(+12V_1) SLOT4.B2(+12V_2) SLOT4.B3(RSVD1) XC90.1 XC95.1 XC129.1 XC130.1 XCE14.1 XCE16.1
+AVDDH: LCB11.1 LCB12.1 LCB20.1 U10.9(AVDDH_REG) U10.22(AVDDH)
+AVDDL: L1.1 L2.1 LCB6.1 LCB7.1 LCB9.1 LCB14.1 LCB15.1 U10.6(AVDDL_REG) U10.13(AVDDL1) U10.19(AVDDL2) U10.31(AVDDL3)
+AVDDVCO: L1.2 LCB10.1 LCB13.1 LCB19.1 U10.34(AVDDL4)
+DVDDL: L2.2 LCB21.1 LCB22.1 U10.37(DVDDL_REG)
+V1P0A_VCCAMPHYPLL_W25MIL: PCH.A43(VCCAMPHYPLL_1P0_1) PCH.B43(VCCAMPHYPLL_1P0_2) PCH.C44(VCCPCIE3PLL_1P0_1) PCH.C45(VCCPCIE3PLL_1P0_2) SCB12.1 SCB13.1 SCB15.1 SR49.2
+V1P0A_VCCCLK2: PCH.W17(VCCCLK2_2) SR43.2
+V1P0A_VCCF24_W15MIL: PCH.K1(VCCCLK5_1) PCH.K2(VCCCLK5_2) SCB4.1 SCB5.1 SCB14.1 SR411.2
+VCC_USB2: J10.11(VCC1) J10.21(VCC2) J10.31(VCC3) J10.41(VCC4) TUU2.1(OUT) UCB9.1 UCB25.1 UCE10.1
+VCC_USB2_1: CB4117.1 J9.U1 J9.U5 UCB5.1 UCB6.1 UU47.1(OUT)
+VCC_USB3_1: J133.11(VBUS1) J133.21(VBUS2) RFC14.1 UCB1.1 UCB4.1 UCB23.1 UU45.1(OUT)
+VCC_USB3_2: J133.31(VBUS3) J133.41(VBUS4) RFC15.1 UCB2.1 UCB3.1 UCB24.1 UU50.1(OUT)
+VCC_USB3_3: CB4124.1 P150.18 P150.19 UC968.1 UC972.1 UCE12.1 UU51.1(OUT)
+VCCGT: PC7.1 PC8.1 PC9.1 PC10.1 PC11.1 PC12.1 PC6106.1 PC6114.1 PC6221.1 PC6222.1 PC6223.1 PC6224.1 PC6225.1 PC6226.1 PC6227.1 PC6228.1 PC6229.1 PC6230.1 PC6231.1 PC6232.1 PC6233.1 PC6234.1 PC6235.1 PC6236.1 PC6241.1 PC6242.1 PC6243.1 PC6244.1 PCE6206.1 PCE6207.1 PCE6208.1 PCE6209.1 PCE6210.1 PJP612.1 PJP614.1 PL611.2 PL612.2 PR623.2 XU1.AA34(VCCGT_1) XU1.AA35(VCCGT_2) XU1.AA36(VCCGT_3) XU1.AA37(VCCGT_4) XU1.AA38(VCCGT_5) XU1.AB33(VCCGT_6) XU1.AB34(VCCGT_7) XU1.G36(VCCGT_8) XU1.G37(VCCGT_9) XU1.G38(VCCGT_10) XU1.G39(VCCGT_11) XU1.G40(VCCGT_12) XU1.H36(VCCGT_13) XU1.H38(VCCGT_14) XU1.H40(VCCGT_15) XU1.J36(VCCGT_16) XU1.J37(VCCGT_17) XU1.J38(VCCGT_18) XU1.J39(VCCGT_19) XU1.J40(VCCGT_20) XU1.K36(VCCGT_21) XU1.K38(VCCGT_22) XU1.K40(VCCGT_23) XU1.L34(VCCGT_24) XU1.L35(VCCGT_25) XU1.L36(VCCGT_26) XU1.L37(VCCGT_27) XU1.L38(VCCGT_28) XU1.L39(VCCGT_29) XU1.L40(VCCGT_30) XU1.M33(VCCGT_31) XU1.M34(VCCGT_32) XU1.M36(VCCGT_33) XU1.M38(VCCGT_34) XU1.M40(VCCGT_35) XU1.N34(VCCGT_36) XU1.N35(VCCGT_37) XU1.N36(VCCGT_38) XU1.N37(VCCGT_39) XU1.N38(VCCGT_40) XU1.N39(VCCGT_41) XU1.N40(VCCGT_42) XU1.P33(VCCGT_43) XU1.P34(VCCGT_44) XU1.P36(VCCGT_45) XU1.P38(VCCGT_46) XU1.P40(VCCGT_47) XU1.R34(VCCGT_48) XU1.R35(VCCGT_49) XU1.R36(VCCGT_50) XU1.R37(VCCGT_51) XU1.R38(VCCGT_52) XU1.R39(VCCGT_53) XU1.R40(VCCGT_54) XU1.T33(VCCGT_55) XU1.T34(VCCGT_56) XU1.T36(VCCGT_57) XU1.T38(VCCGT_58) XU1.T40(VCCGT_59) XU1.U34(VCCGT_60) XU1.U35(VCCGT_61) XU1.U36(VCCGT_62) XU1.U37(VCCGT_63) XU1.U38(VCCGT_64) XU1.U39(VCCGT_65) XU1.U40(VCCGT_66) XU1.V33(VCCGT_67) XU1.V34(VCCGT_68) XU1.V36(VCCGT_69) XU1.V38(VCCGT_70) XU1.V40(VCCGT_71) XU1.W34(VCCGT_72) XU1.W35(VCCGT_73) XU1.W36(VCCGT_74) XU1.W37(VCCGT_75) XU1.W38(VCCGT_76) XU1.Y33(VCCGT_77) XU1.Y34(VCCGT_78) XU1.Y36(VCCGT_79) XU1.Y38(VCCGT_80)
+VCCGT_SENSE+_A: PJP623.1 PR623.1 PR5848.1
+VCCGT_SENSE-_A: PC5820.1 PC5824.2 PJP624.1 PR624.1 PU581.32(RGNDA)
+VCCPGPP_EFG: PCH.AE41(VCCPGPPG) PCH.AK41(VCCPGPPEF_2) PCH.AM41(VCCPGPPEF_1) SCB7.1 SR54.1
+VCCPRIM_1P0_5&9: PCH.AD17(VCCPRIM_1P0_5) PCH.AE16(VCCPRIM_1P0_9) SR12.2
+VDD: U15.1(VDD_1) U15.24(VDD_2) U15.36(VDD_3) U15.48(VDD_4) UCC4.1 UCC5.1 UCC6.1 UCC7.1 UCC8.1 UCR26.2 UCR27.1
+VDDA: U15.9(VDDA) UCC9.1 UCC10.1 UCR27.2
+VDDQ_SN: PC640660.1 PR70216.2
AGND: AC3.2 AC4.2 AC16.2 AC17.2 AC18.2 AC19.2 AC23.2 AC24.1 AC25.1 AC26.1 AC27.1 AC52.1 AC55.1 AC73.1 AC74.2 AC75.2 AC76.2 AC77.2 AC129.1 AC130.1 AC173.2 AC174.2 AC175.2 AC176.2 AC177.2 AC178.2 AC179.2 AC180.2 AC181.2 AC182.2 AC183.2 AC184.2 ACE3.2 AD3.2(CATHODE) AD4.2(CATHODE) AD5.2(CATHODE) AD6.2(CATHODE) AD7.2(CATHODE) AD13.2(CATHODE) AD14.2(CATHODE) AD15.2(CATHODE) AD16.2(CATHODE) AD17.2(CATHODE) AD18.2(CATHODE) AD19.2(CATHODE) AQ1.1 AQ1.4 AQ2.1 AQ2.4 AQ16.1 AQ16.4 AQ17.1 AQ17.4 AQ18.1 AQ18.4 AR9.2 AR10.2 AR23.1 AR26.2 AR205.2 AR206.2 AR220.2 AR221.2 AR222.2 AR224.2 AR225.2 AR226.2 AR231.1 AR232.1 AU1.26(AVSS1) AU1.42(AVSS2) HC30.2 HC31.2 J83.1 J83.4 J83.24 J83.34 J83.41 J83.44 J83.54 J83.64 J83.66(P_GND1) J83.67(P_GND2) J83.68(P_GND3) J83.69(P_GND4) P23.2 P23.7
