# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_BA0: length 82.2
  TOP w0.203: v1(135.03,159.86) 135.1,159.86 XU1.AL18
  IN1 w0.102: v1(135.03,159.86) 136.19,159.86 136.58,160.25 137.27,160.25 137.39,160.36 137.98,160.36 138.32,160.02 139.73,160.02 140.36,159.38 140.92,159.38 141.07,159.54 142.97,159.54
  IN1 w0.178: CON_XMM2.81 199.99,157.31 197.13,157.31 196.61,157.83 195.14,157.83 194.62,157.31 192.55,157.31 CON_XMM4.81 191,157.15 190.44,156.58 190.44,155.99 189.74,155.28 188.87,155.28 188.02,154.43 187.17,154.43 186.32,153.58 184.89,153.58 184.04,154.43 183.46,154.43 182.61,153.58 180.91,153.58 180.06,154.43 179.43,154.43 178.58,153.58 177.11,153.58 176.26,154.43 175.57,154.43 175.43,154.29 174.94,154.29 174.47,154.76 171.62,154.76 171.42,154.56 171.42,153.79 171.21,153.59 170.93,153.59 170.73,153.79 170.73,154.56 170.53,154.76 170.25,154.76 170.04,154.56 170.04,153.79 169.84,153.59 169.56,153.59 169.36,153.79 169.36,154.56 169.16,154.76 168.87,154.76 168.67,154.56 168.67,153.79 168.47,153.59 168.19,153.59 167.99,153.79 167.99,154.56 167.79,154.76 167.5,154.76 167.3,154.56 167.3,153.79 167.1,153.59 166.82,153.59 166.62,153.79 166.62,154.56 166.41,154.76 166.13,154.76 165.93,154.56 165.93,153.79 165.73,153.59 165.44,153.59 165.24,153.79 165.24,154.56 165.04,154.76 163.63,154.76 160.19,158.2 145.67,158.2 144.89,158.98 143.54,158.98 142.97,159.54
M_CHB_BA1: length 81.8
  TOP w0.203: v1(136.86,160.78) 136.86,160.7 XU1.AM18
  IN1 w0.102: v1(136.86,160.78) 137.84,160.78 138.4,160.22 140.79,160.22 141.15,159.87
  IN1 w0.178: 141.15,159.87 143.1,159.87 143.66,159.31 145.11,159.31 145.75,158.67 160.49,158.67 161.93,157.23 162.31,157.23 162.52,157.01 162.52,156.63 162.69,156.46 163.07,156.46 163.25,156.64 163.25,157.1 163.37,157.23 164.08,157.23 164.31,157 164.31,156.67 163.66,156.02 163.66,155.49 163.88,155.27 164.39,155.27 164.59,155.47 164.59,155.98 164.8,156.18 165.08,156.18 165.28,155.98 165.28,155.47 165.48,155.27 174.98,155.27 175.49,154.76 176.44,154.76 177.29,153.91 178.04,153.91 178.89,154.76 180.24,154.76 181.09,153.91 182.13,153.91 182.98,154.76 183.46,154.76 183.47,154.76 184.03,154.76 184.04,154.76 184.21,154.76 185,153.97 185.07,153.91 185.86,153.91 186.71,154.76 187.27,154.76 187.83,154.76 188.68,155.61 189.56,155.61 189.95,156 189.95,156.73 191.38,158.17 192.09,158.17 192.1,158.16 192.67,158.16 192.68,158.17 192.9,158.17 193.41,158.68 194.83,158.68 195.1,158.96 195.34,158.96 195.47,158.83 195.47,158.28 195.59,158.15 197.63,158.15 CON_XMM4.224 200.51,158 201.29,158.77 202.48,158.77 203.25,158 CON_XMM2.224
M_CHB_BG0: length 74.8
  TOP w0.102: XU1.AW28 143.17,169.76 146.01,169.76
  TOP w0.203: 146.01,169.76 146.07,169.81 147.91,169.81 148.33,169.39 149.06,169.39 149.28,169.6 149.28,170.29 149.5,170.51 149.93,170.51 150.14,170.29 150.14,169.59 150.36,169.38 150.79,169.38 151.01,169.59 151.01,170.34 151.22,170.55 151.66,170.55 151.87,170.34 151.87,169.58 152.09,169.36 152.44,169.36 152.65,169.58 152.65,170.31 153.26,170.91 154.17,170.91 154.46,171.2 154.46,172.11 155.72,173.37 156.05,173.37 156.27,173.15 v1(156.27,172.39)
  IN1 w0.178: v1(156.27,172.39) 156.99,172.39 162.6,178 165.57,178 166.91,179.34 167.45,179.34 167.65,179.14 167.65,178.74 167.85,178.54 168.13,178.54 168.34,178.74 168.34,179.14 168.54,179.34 168.82,179.34 169.02,179.14 169.02,178.74 169.2,178.56 169.49,178.56 169.71,178.78 169.71,179.14 169.91,179.34 170.19,179.34 170.39,179.14 170.39,178.79 170.59,178.59 170.88,178.59 171.08,178.79 171.08,179.14 171.28,179.34 174.63,179.34 175.42,178.56 176.44,178.56 177.29,177.71 178.01,177.71 178.86,178.56 180.24,178.56 181.09,177.71 181.75,177.71 182.6,178.56 184.22,178.56 185.07,177.71 185.71,177.71 186.56,178.56 188.01,178.56 188.86,177.71 189.85,177.71 190.17,178.03 190.75,178.03 191.24,177.55 CON_XMM4.63 193.14,177.55 193.3,177.71 194.33,177.71 194.54,177.92 195.34,177.92 195.66,178.23 196.65,178.23 197.17,177.71 198.16,177.71 198.44,177.99 199.71,177.99 CON_XMM2.63
M_CHB_BG1: length 72.3
  TOP w0.102: 146.3,169.44 143.77,169.44 XU1.AY28
  TOP w0.203: v1(155.88,171.73) 155.49,172.12 155.18,172.12 154.96,171.9 154.96,170.78 154.52,170.33 153.4,170.33 153.12,170.06 153.12,169.16 152.86,168.89 147.97,168.89 147.37,169.5 146.36,169.5 146.3,169.44
  IN1 w0.178: CON_XMM2.207 201.32,177.55 200.63,176.86 199.8,176.86 199.28,177.38 196.35,177.38 CON_XMM4.207 195.38,177.55 195.21,177.38 193.64,177.38 193.12,176.86 191.87,176.86 191.7,177.03 190.91,177.03 190.56,177.38 188.68,177.38 187.83,178.23 187.17,178.23 186.32,177.38 184.88,177.38 184.03,178.23 183.36,178.23 182.51,177.38 180.91,177.38 180.06,178.23 179.4,178.23 178.55,177.38 177.11,177.38 176.66,177.83 176.66,177.83 176.26,178.23 175.11,178.23 174.43,178.91 171.81,178.91 170.19,177.29 169.14,177.29 168.48,177.95 168.03,177.95 167.83,177.75 167.83,177.29 167.63,177.09 167.35,177.09 167.15,177.29 167.15,177.88 166.94,178.08 166.66,178.08 166.46,177.88 166.46,177.29 166.26,177.09 163.82,177.09 159.3,172.57 157.78,172.57 156.95,171.73 v1(155.88,171.73)
M_CHB_CKE0: length 60.5
  TOP w0.102: XU1.AY29 145.57,170.33 145.96,170.73 147.32,170.73
  TOP w0.159: 147.32,170.73 147.46,170.73 v1(147.75,170.43)
  IN1 w0.14: v1(147.75,170.43) 148.18,170 149.49,170 160.85,181.36 162.66,181.36 162.94,181.08 162.94,180.31 163.13,180.13 164.05,180.13 165.29,181.36 166.69,181.36 167.06,180.99 168.12,180.99 168.43,181.3 168.43,181.64 168.77,181.98 176.54,181.98 177.03,182.46 179.02,182.46 179.5,181.98 180.05,181.98 180.54,182.46 181.9,182.46 182.38,181.98 184.26,181.98 184.75,182.46 186.45,182.46 186.93,181.98 188.07,181.98 188.56,182.46 191.12,182.46 191.82,181.76 193.07,181.76 193.98,180.85 CON_XMM4.60
M_CHB_CKE1: length 62.7
  TOP w0.102: XU1.AV29 142.26,169.99 143.95,169.99 144.06,170.1 145.84,170.1 146.05,170.31 v1(147.07,170.31)
  IN1 w0.14: v1(147.07,170.31) 147.85,169.52 149.69,169.52 159.11,178.94 162.23,178.94 162.94,179.64 165.89,179.64 166.53,180.28 176.27,180.28 177.26,180.76 178.48,180.76 179.33,181.61 180.05,181.61 180.44,181.22 180.44,181.22 180.9,180.76 182.16,180.76 183.01,181.61 184.22,181.61 185.07,180.76 186.22,180.76 187.07,181.61 187.86,181.61 188.71,180.76 190.76,180.76 191.44,180.09 192.79,180.09 193.44,179.43 194.67,179.43 CON_XMM4.203
M_CHB_CKE2: length 69.2
  TOP w0.102: XU1.AW29 143.16,170.66 145.11,170.66 145.45,171 147.32,171
  TOP w0.159: 147.32,171 147.98,171 v1(148.49,170.5)
  IN1 w0.14: v1(148.49,170.5) 148.5,170.48 149.29,170.48 160.65,181.84 166.58,181.84 167.36,182.63 174.68,182.63 175.36,183.31 176.45,183.31 176.94,182.83 178.33,182.83 179.18,183.68 180.02,183.68 180.87,182.83 181.96,182.83 182.81,183.68 183.96,183.68 184.81,182.83 186.03,182.83 186.88,183.68 187.75,183.68 188.6,182.83 190.25,182.83 191.1,183.68 192.67,183.68 193.7,182.65 194.87,182.65 195.68,181.84 196.54,181.84 197.26,181.13 198.25,181.13 198.42,181.31 199.09,181.31 199.34,181.05 199.34,180.72 199.96,180.1 CON_XMM2.60
M_CHB_CKE3: length 72.5
  TOP w0.102: XU1.AU29 141.53,170.86 144.87,170.86 145.33,171.33 147.32,171.33
  TOP w0.159: 147.32,171.33 148.74,171.33 v1(149.1,170.97)
  IN1 w0.14: CON_XMM2.203 201.35,180.95 200.46,181.84 199.72,181.84 198.86,182.7 197.33,182.7 196.55,183.49 195.55,183.49 194.72,184.33 193.62,184.33 192.94,185.01 190.19,185.01 189.71,184.53 188.57,184.53 188.09,185.01 186.51,185.01 186.03,184.53 184.86,184.53 184.2,185.19 182.7,185.19 182.04,184.53 180.88,184.53 180.26,185.14 178.97,185.14 178.18,184.35 177.14,184.35 176.46,183.68 161.8,183.68 v1(149.1,170.97)
M_CHB_CLK0: length 73
  TOP w0.198: XU1.AM20 v1(135.97,162.56)
  IN1 w0.102: 141.64,163.56 141.63,163.58 141.03,163.58 140.72,163.88 137.63,163.88 136.56,162.81 136.23,162.81 v1(135.97,162.56)
  IN1 w0.165: CON_XMM4.74 193.5,167.36 193.43,167.24 193.43,166.93 192.84,166.33 191.92,166.33 190.75,165.16 189.44,165.16 189.29,165.01 189.29,163.71 188.95,163.37 187.99,163.37 187.65,163.7 187.65,164.1 187.38,164.38 186.99,164.38 186.71,164.1 186.71,163.73 186.36,163.37 185.57,163.37 185.24,163.7 185.24,164.08 184.97,164.35 184.58,164.35 184.3,164.08 184.3,163.73 183.95,163.37 183.23,163.37 182.78,163.82 182.78,164.08 182.5,164.35 182.12,164.35 181.84,164.08 181.84,163.82 181.39,163.37 180.76,163.37 180.32,163.82 180.32,164.08 180.04,164.35 179.65,164.35 179.38,164.08 179.38,163.82 178.93,163.37 178.3,163.37 177.85,163.82 177.85,164.08 177.58,164.35 177.19,164.35 176.91,164.08 176.91,163.82 176.47,163.37 174.73,163.37 174.29,163.8 174.29,165.92 174,166.21 173.58,166.21 173.35,165.98 173.35,163.98 172.94,163.56 141.64,163.56
M_CHB_CLK0#: length 73
  TOP w0.198: XU1.AM21 v1(135.97,163.47)
  IN1 w0.102: 141.58,163.83 141.06,163.83 140.81,164.08 137.54,164.08 136.48,163.02 136.12,163.02 135.97,163.17 v1(135.97,163.47)
  IN1 w0.165: 141.58,163.83 172.83,163.83 173.09,164.09 173.09,166.09 173.47,166.48 174.11,166.48 174.56,166.03 174.56,163.92 174.84,163.64 176.36,163.64 176.65,163.93 176.65,164.19 177.08,164.62 177.69,164.62 178.12,164.19 178.12,163.93 178.41,163.64 178.82,163.64 179.11,163.93 179.11,164.19 179.54,164.62 180.15,164.62 180.58,164.19 180.58,163.93 180.87,163.64 181.28,163.64 181.57,163.93 181.57,164.19 182,164.62 182.62,164.62 183.05,164.19 183.05,163.93 183.34,163.64 183.84,163.64 184.04,163.84 184.04,164.19 184.47,164.62 185.08,164.62 185.51,164.19 185.51,163.81 185.68,163.64 186.25,163.64 186.45,163.84 186.45,164.21 186.88,164.64 187.49,164.64 187.92,164.21 187.92,163.81 188.1,163.64 188.84,163.64 189.03,163.82 189.03,165.13 189.33,165.43 190.64,165.43 191.81,166.6 192.73,166.6 193.14,167.01 193.14,167.56 192.98,167.72 192.76,167.72 CON_XMM4.75
M_CHB_CLK1: length 70.6
  TOP w0.198: v1(138.71,163.44) 138.71,163.47 XU1.AP22
  IN1 w0.102: v1(138.71,163.44) 138.53,163.44 138.37,163.28 138.37,163.16 138.53,163 141.18,163 141.71,162.47 142.94,162.47 143.09,162.63 144.58,162.63 144.61,162.66 144.64,162.66
  IN1 w0.165: CON_XMM4.218 197.39,167.8 197.21,167.8 196.85,168.17 196.66,168.36 195.61,168.36 195.58,168.33 195.34,168.33 194.76,167.76 194.76,166.23 194.22,165.69 193.53,165.69 192.44,164.6 191.78,164.6 189.82,162.65 175.66,162.65 175.23,162.22 175.23,161.16 174.94,160.87 174.53,160.87 174.24,161.16 174.24,162.22 173.81,162.65 172.89,162.65 172.46,162.22 172.46,161.14 172.2,160.87 171.79,160.87 171.47,161.19 171.47,162.22 171.04,162.65 169.54,162.65 168.9,162.01 168.18,162.01 167.53,162.66 144.64,162.66
M_CHB_CLK1#: length 70.6
  TOP w0.198: v1(137.79,163.45) 137.82,163.45 XU1.AP21
  IN1 w0.102: v1(137.79,163.45) 138.45,162.79 141.1,162.79 141.62,162.27 143.02,162.27 143.18,162.43 144.58,162.43 144.61,162.39 144.64,162.39
  IN1 w0.165: CON_XMM4.219 196.66,167.35 196.87,167.55 196.87,167.73 196.53,168.07 195.45,168.07 195.03,167.65 195.03,166.12 194.33,165.42 193.64,165.42 192.55,164.33 191.89,164.33 189.94,162.38 175.78,162.38 175.5,162.11 175.5,161.05 175.05,160.6 174.42,160.6 173.98,161.05 173.98,162.11 173.7,162.38 173,162.38 172.73,162.11 172.73,161.03 172.31,160.6 171.67,160.6 171.2,161.08 171.2,162.11 170.93,162.38 169.65,162.38 169.01,161.75 168.07,161.75 167.42,162.39 144.64,162.39
M_CHB_CLK2: length 77.8
  TOP w0.198: v1(136.96,162.57) 137.34,162.19 XU1.AN20
  IN1 w0.102: v1(136.96,162.57) 137.27,162.57 137.74,162.1 138.35,162.1 138.51,162.26 140.65,162.26 141.18,161.72 146.38,161.72 146.71,161.39 148.29,161.39 148.31,161.37 148.34,161.37
  IN1 w0.165: 148.34,161.37 165.24,161.37 165.49,161.12 165.49,159.91 166.5,158.9 171.1,158.9 171.7,159.5 172.71,159.5 173.31,158.9 174.78,158.9 175.55,159.67 176.13,159.67 177.09,158.71 178.18,158.71 179.22,159.75 179.7,159.75 181.21,161.26 181.79,161.26 182.02,161.04 182.02,160.7 182.36,160.35 182.99,160.35 183.44,160.8 183.44,161.09 183.62,161.26 184.02,161.26 184.26,161.02 184.26,159.31 184.37,159.21 184.87,158.71 186.04,158.71 187.11,159.78 187.64,159.78 188.83,160.97 190.19,160.97 191.83,162.61 192.48,162.61 194.23,164.36 197.66,164.36 198.81,165.51 198.81,166.01 199.13,166.33 200.62,166.33 201.21,166.92 201.21,167.25 201.58,167.89 CON_XMM2.74
M_CHB_CLK2#: length 77.8
  TOP w0.198: XU1.AN21 137.43,163.02 v1(137.8,162.64)
  IN1 w0.102: v1(137.8,162.64) 137.8,162.38 137.87,162.31 138.27,162.31 138.42,162.46 140.73,162.46 141.26,161.93 146.47,161.93 146.77,161.62 148.27,161.62 148.29,161.64 148.31,161.64
  IN1 w0.165: 148.31,161.64 165.35,161.64 165.76,161.23 165.76,160.02 166.61,159.17 170.99,159.17 171.59,159.77 172.82,159.77 173.42,159.17 174.67,159.17 175.44,159.94 176.24,159.94 177.21,158.98 178.06,158.98 179.11,160.02 179.59,160.02 181.1,161.53 181.9,161.53 182.28,161.15 182.28,160.81 182.48,160.62 182.88,160.62 183.17,160.91 183.17,161.2 183.51,161.53 184.13,161.53 184.53,161.13 184.53,159.42 184.98,158.98 185.93,158.98 187,160.05 187.53,160.05 188.72,161.24 190.08,161.24 191.72,162.88 192.37,162.88 194.12,164.63 197.55,164.63 198.54,165.62 198.54,166.12 199.02,166.6 200.51,166.6 200.95,167.03 200.95,167.99 200.71,168.22 200.46,168.22 200.16,167.92 CON_XMM2.75
M_CHB_CLK3: length 75.8
  TOP w0.198: XU1.AP19 137.84,161.6 v1(137.84,161.68)
  IN1 w0.102: v1(137.84,161.68) 138.04,161.68 138.73,161 145.81,161 146.44,160.36 147.28,160.36 147.31,160.33
  IN1 w0.165: CON_XMM2.218 205.08,167.4 205.08,167.05 204.37,166.34 203.41,166.34 202.24,165.17 198.31,163.41 195.09,163.41 193.66,162.33 193.66,162.33 192.23,161.24 189.7,158.72 188.87,158.72 188,157.85 187.3,157.85 185.91,157.02 184.91,157.02 184.06,157.87 183.39,157.87 181.62,158.71 181.09,158.71 180.22,157.83 179.35,157.83 178.04,157.01 177.08,157.01 176.24,157.85 166.13,157.85 163.65,160.33 147.31,160.33
M_CHB_CLK3#: length 75.8
  TOP w0.198: XU1.AP20 138.69,161.67 v1(138.71,161.67)
  IN1 w0.102: v1(138.71,161.67) 138.71,161.3 138.81,161.2 145.9,161.2 146.53,160.57 147.26,160.57 147.29,160.6
  IN1 w0.165: 147.29,160.6 163.76,160.6 166.24,158.12 176.35,158.12 177.19,157.28 177.96,157.28 179.27,158.1 180.11,158.1 180.98,158.98 181.68,158.98 183.45,158.13 184.17,158.13 185.02,157.28 185.83,157.28 187.23,158.12 187.89,158.12 188.76,158.98 189.59,158.98 192.05,161.44 195,163.67 198.25,163.67 202.09,165.39 203.3,166.6 204.26,166.6 204.81,167.16 204.81,167.86 204.49,168.18 204.18,168.18 203.96,167.97 CON_XMM2.219
M_CHB_CS#0: length 67.6
  TOP w0.159: v1(137.8,158.81) 137.8,158.9 XU1.AP17
  IN1 w0.102: 147.07,156.32 146.74,156.64 144.34,156.64 142.89,158.09 140.41,158.09 139.69,158.81 v1(137.8,158.81)
  IN1 w0.14: CON_XMM4.84 193.8,154.41 192.03,154.41 191.67,154.06 191.67,153.78 189.76,151.86 188.87,151.86 188.02,151.01 187.16,151.01 186.31,150.16 184.88,150.16 184.03,151.01 183.37,151.01 182.52,150.16 180.91,150.16 180.06,151.01 179.41,151.01 178.56,150.16 177.17,150.16 176.32,151.01 175.52,151.01 175.2,150.69 170.98,150.69 170.82,150.85 170.82,151.22 170.63,151.41 170.36,151.41 170.17,151.22 170.17,150.85 169.98,150.66 169.71,150.66 169.52,150.85 169.52,151.22 169.33,151.41 169.07,151.41 168.88,151.22 168.88,150.85 168.69,150.66 168.42,150.66 168.23,150.85 168.23,151.22 168.04,151.41 167.77,151.41 167.58,151.22 167.58,150.85 167.39,150.66 167.12,150.66 166.93,150.85 166.93,151.22 166.72,151.44 161.62,151.44 156.87,156.19 147.19,156.19 147.07,156.32
M_CHB_CS#1: length 69.7
  TOP w0.159: XU1.AN15 136.86,157.05 v1(136.86,157.01)
  IN1 w0.102: 146.49,153.86 146.12,154.23 143.96,154.23 142.86,155.32 141.01,155.32 140.01,156.32 137.56,156.32 v1(136.86,157.01)
  IN1 w0.14: 146.49,153.86 147.16,153.19 155.41,153.19 161.78,146.82 170.39,146.82 170.58,146.63 170.58,146.11 170.77,145.92 171.04,145.92 171.23,146.11 171.23,146.63 171.42,146.82 171.69,146.82 171.88,146.63 171.88,146.11 172.07,145.92 172.33,145.92 172.52,146.11 172.52,146.63 172.71,146.82 172.98,146.82 173.17,146.63 173.17,146.11 173.36,145.92 173.63,145.92 173.82,146.11 173.82,146.63 174.01,146.82 174.26,146.82 175.17,145.91 176.26,145.91 177.11,145.06 178.65,145.06 179.5,145.91 180.06,145.91 180.91,145.06 182.62,145.06 183.53,145.97 183.97,145.97 184.88,145.06 186.42,145.06 187.27,145.91 188.02,145.91 188.87,146.76 190.06,146.76 191.48,148.19 191.48,148.99 191.78,149.28 191.99,149.28 192.38,149.68 CON_XMM4.89
M_CHB_CS#2: length 77.7
  TOP w0.159: v1(136.88,158.88) 136.88,158.9 XU1.AN17
  IN1 w0.102: 144.53,156.95 144.35,156.95 143,158.29 140.5,158.29 139.55,159.25 137.25,159.25 v1(136.88,158.88)
  IN1 w0.14: 144.53,156.95 147.04,156.95 147.29,156.7 157.05,156.7 161.82,151.92 162.67,151.92 162.86,152.11 162.86,152.37 163.05,152.56 163.32,152.56 163.51,152.37 163.51,152.11 163.7,151.92 171.12,151.92 171.31,151.73 171.31,151.36 171.5,151.17 171.76,151.17 171.95,151.36 171.95,151.73 172.14,151.92 172.41,151.92 172.6,151.73 172.6,151.36 172.79,151.17 173.06,151.17 173.25,151.36 173.25,151.73 173.44,151.92 173.71,151.92 173.9,151.73 173.9,151.36 174.09,151.17 174.36,151.17 174.55,151.36 174.55,151.73 174.74,151.92 174.98,151.92 175.54,151.36 176.44,151.36 177.29,150.51 177.97,150.51 178.82,151.36 180.24,151.36 181.09,150.51 181.8,150.51 182.65,151.36 184.21,151.36 185.06,150.51 185.72,150.51 186.57,151.36 187.84,151.36 188.69,152.21 189.17,152.21 189.18,152.21 189.48,152.21 191.19,153.92 191.19,154.16 191.8,154.77 192.79,154.77 193.39,155.37 194.32,155.37 195.03,154.66 196.58,154.66 197.21,155.28 198.7,155.28 199.21,154.78 201.57,154.78 CON_XMM2.84
M_CHB_CS#3: length 78.9
  TOP w0.159: v1(135.98,156.99) 135.98,157.08 XU1.AM15
  IN1 w0.102: 142.95,154.23 142.41,154.76 140.96,154.76 139.81,155.91 137.02,155.91 135.98,156.95 v1(135.98,156.99)
  IN1 w0.14: 142.95,154.23 143.76,153.42 145.75,153.42 146.99,152.17 155.06,152.17 162.28,144.96 162.79,144.96 162.98,145.15 162.98,145.66 163.17,145.85 163.44,145.85 163.63,145.66 163.63,145.15 163.82,144.96 164.09,144.96 164.28,145.15 164.28,145.66 164.47,145.85 164.73,145.85 164.92,145.66 164.92,145.15 165.11,144.96 165.38,144.96 165.57,145.15 165.57,145.66 165.76,145.85 166.03,145.85 166.22,145.66 166.22,145.15 166.41,144.96 174.19,144.96 174.94,144.21 176.26,144.21 177.11,143.36 178.42,143.36 179.27,144.21 180.09,144.21 180.94,143.36 182.43,143.36 183.33,144.27 183.98,144.27 184.88,143.36 186.21,143.36 187.06,144.21 188.02,144.21 188.87,145.06 190.85,145.06 191.85,146.06 192.74,146.06 193.61,146.94 194.64,146.94 195.44,147.74 196.48,147.74 197.4,148.65 198.47,148.65 CON_XMM2.89
M_CHB_DQ0: length 121.5
  TOP w0.102: CON_XMM2.3 197.48,228.55 196.54,227.61 195.69,227.61 v1(195.43,227.87) 195.43,229.36 195.25,229.54 194.97,229.54 194.78,229.35 194.78,228.99 194.44,228.65 193.47,228.65 193.37,228.55 CON_XMM4.3
  TOP w0.159: v1(128.66,175.36) XU1.AD34
  IN1 w0.14: v1(128.66,175.36) 127.41,176.61 127.41,180.47 125.6,182.27 125.6,194.95 148.56,217.91 151.33,217.91 151.78,218.36 151.78,218.62 151.51,218.9 151.51,219.17 151.7,219.36 151.96,219.36 152.24,219.08 152.51,219.08 152.7,219.27 152.7,219.54 152.42,219.82 152.42,220.09 152.61,220.28 152.88,220.28 153.16,220 153.43,220 153.62,220.19 153.62,220.46 153.31,220.76 153.31,221 153.5,221.19 153.8,221.19 154.07,220.92 154.34,220.92 155.3,221.87 167.1,221.87 171.4,226.17 176.39,226.17 177.26,225.3 178.18,225.3 179.05,226.17 180.23,226.17 181.08,225.32 181.7,225.32 182.8,226.17 184.22,226.17 185.07,225.32 185.66,225.32 186.76,226.17 187.98,226.17 188.85,225.3 189.51,225.3 190.38,226.17 192.66,226.17 193.51,227.02 194.58,227.02 v1(195.43,227.87)
M_CHB_DQ1: length 120.9
  TOP w0.102: CON_XMM2.148 202.98,227.69 202.87,227.58 202.87,226.75 202.72,226.59 202.54,226.59 202.3,226.83 v1(201.26,226.83) 200.91,227.18 200.91,227.53 200.74,227.71 199.31,227.71 199.24,227.63 199.24,227.33 199.14,227.23 198.86,227.23 198.73,227.36 198.73,228.02 198.63,228.12 198.21,228.12 CON_XMM4.148
  TOP w0.159: v1(128.66,176.27) XU1.AD35
  IN1 w0.14: v1(201.26,226.83) 200.83,227.26 200.32,227.53 199.98,227.53 197.9,227.03 197.7,227.03 196.25,227.53 195.99,227.53 194.6,226.68 193.7,226.68 192.85,225.83 192.18,225.83 189.54,224.96 188.73,224.96 187.86,225.83 187.44,225.83 185.67,224.99 184.86,224.99 184.02,225.83 183.59,225.83 181.63,224.98 180.91,224.98 180.06,225.83 179.61,225.83 178.12,224.98 177.1,224.98 176.27,225.81 175.51,225.81 168.26,222.14 167.44,221.31 167.06,221.18 155.55,221.18 151.63,217.26 148.82,217.26 126.24,194.68 126.24,183.21 127.53,181.15 128.09,180.59 128.09,177.22 128.4,176.71 v1(128.66,176.27)
M_CHB_DQ2: length 120
  TOP w0.102: CON_XMM4.12 194.41,220.47 194.97,220.47 195.22,220.73 196.82,220.73 197.33,220.22 198.45,220.22 v1(198.65,220.42) 198.93,220.14 199.16,220.14 199.77,220.75 200.84,220.75 200.96,220.63 200.96,220.29 201.09,220.17 202.11,220.17 202.23,220.29 202.23,220.42 CON_XMM2.12
  TOP w0.159: XU1.AG35 v1(132.31,175.36)
  IN1 w0.102: v1(132.31,175.36) 131.7,175.97 131.7,177.56 131.8,177.66 131.8,179.45 131.32,179.93 131.32,181.3
  IN1 w0.14: 131.32,181.3 130.35,182.27 130.35,193.07 149.89,212.6 155.17,212.6 158.06,215.49 158.06,215.72 158.6,216.26 161.04,216.26 161.29,216 161.29,214.17 161.47,214 161.75,214 161.94,214.18 161.94,216.07 162.13,216.26 162.39,216.26 162.58,216.07 162.58,214.18 162.77,214 164.63,214 166.89,216.26 168.32,216.26 170.12,218.06 173.11,218.06 174.43,219.38 176.45,219.38 177.31,218.52 178.01,218.52 178.86,219.37 180.25,219.37 181.1,218.52 181.79,218.52 182.64,219.37 184.22,219.37 185.07,218.52 185.81,218.52 186.66,219.37 188.03,219.37 188.88,218.52 189.64,218.52 190.14,219.02 191.12,219.02 191.47,219.37 192.66,219.37 193.51,220.22 194.52,220.22 195.37,221.07 196.63,221.07 197.49,220.22 198.45,220.22 v1(198.65,220.42)
M_CHB_DQ3: length 119.5
  TOP w0.102: CON_XMM2.157 202.7,220.05 202.53,219.88 201.46,219.88 200.47,219.35 199.59,219.35 199.44,219.51 v1(199.06,219.51) 198.63,219.51 198.27,219.87 196.93,219.87 196.42,219.35 195.66,219.35 195.45,219.56 195.45,219.89 195.61,220.05 CON_XMM4.157
  TOP w0.159: XU1.AH35 v1(132.31,176.27)
  IN1 w0.102: v1(132.31,176.27) 131.9,176.68 131.9,177.39 132.01,177.49 132.01,179.9 131.75,180.15 131.75,181.48 130.99,182.25
  IN1 w0.14: 130.99,182.25 130.99,192.8 150.15,211.97 155.45,211.97 157.3,213.82 157.78,213.82 158.24,213.36 158.52,213.36 158.71,213.55 158.71,215.43 158.9,215.62 159.17,215.62 159.36,215.43 159.36,213.55 159.55,213.36 159.82,213.36 160.01,213.55 160.01,215.43 160.19,215.62 160.46,215.62 160.65,215.43 160.65,213.55 160.84,213.36 164.9,213.36 167.16,215.62 168.67,215.62 170.47,217.42 173.37,217.42 174.75,218.81 175.49,218.81 175.7,219.02 176.25,219.02 177.09,218.19 178.37,218.19 179.44,219.01 180.15,219.01 180.97,218.19 182.39,218.19 183.25,218.81 183.52,219.02 184.07,219.02 184.91,218.19 186.08,218.19 187.24,219.07 187.78,219.07 188.67,218.19 189.48,218.19 189.6,218.07 189.8,218.07 189.89,218.15 191.1,218.15 192.02,219.07 192.9,219.07 193.68,219.86 194.72,219.86 195.56,220.7 196.52,220.7 197.34,219.88 198.69,219.88 v1(199.06,219.51)
M_CHB_DQ4: length 120.6
  TOP w0.102: CON_XMM4.150 197.78,225.46 197.92,225.32 198.45,225.32 198.64,225.51 198.64,226.1 198.78,226.24 199.34,226.24 199.62,225.96 200.71,225.96 200.89,225.78 200.89,225.55 v1(201.24,225.2) 202.08,225.2 202.39,224.89 202.79,224.89 202.95,225.04 202.95,225.83 203.11,226 CON_XMM2.150
  TOP w0.159: v1(129.52,176.29) 129.55,176.29 XU1.AE35
  IN1 w0.102: 128.4,182.63 128.4,181.42 129.57,180.25 129.57,176.34 v1(129.52,176.29)
  IN1 w0.14: v1(201.24,225.2) 200.53,225.91 199.36,225.91 198.64,225.18 197.31,225.18 196.95,225.53 196.45,225.81 195.79,225.81 194.97,224.99 193.68,224.99 192.79,224.11 190.83,224.11 189.98,223.27 188.72,223.27 187.83,224.16 187.05,224.16 186.16,223.27 184.91,223.27 184.02,224.16 183.48,224.16 182.06,223.26 180.93,223.26 180.08,224.11 179.37,224.11 178.05,223.27 177.17,223.27 176.32,224.11 175.5,224.11 169.05,221.1 167,219.05 161.65,219.05 160.79,219.91 156.12,219.91 152.09,215.87 149.23,215.87 127.51,194.16 127.51,183.51 128.4,182.63
M_CHB_DQ5: length 121.7
  TOP w0.102: CON_XMM4.5 192.38,226.39 192.58,226.19 193.01,226.19 193.22,226.39 193.22,226.67 193.37,226.82 194.13,226.82 194.28,226.97 194.72,226.97 194.84,226.85 194.84,226.67 194.67,226.49 194.67,226.19 194.87,225.98 195.3,225.98 v1(195.52,226.2) 195.7,226.01 196.49,226.01 196.95,226.47 196.95,226.72 197.18,226.95 197.43,226.95 197.54,226.85 CON_XMM2.5
  TOP w0.159: v1(129.57,175.36) XU1.AE34
  IN1 w0.102: 127.85,182.21 127.85,181.44 129.27,180.02 129.27,176.9 129.07,176.7 129.07,175.86 v1(129.57,175.36)
  IN1 w0.14: v1(195.52,226.2) 194.65,225.33 193.52,225.33 192.67,224.48 191.7,224.48 191.49,224.69 190.42,224.69 190.04,224.31 190.04,223.98 189.69,223.62 188.87,223.62 188.02,224.47 186.34,224.47 186.16,224.28 186.16,223.77 186,223.62 185.07,223.62 184.22,224.47 182.38,224.47 182.22,224.31 182.22,223.77 182.07,223.62 181,223.62 180.67,223.95 180.67,224.23 180.43,224.47 178.65,224.47 178.36,224.18 178.36,223.9 178.08,223.62 177.24,223.62 176.39,224.47 175.58,224.47 175.39,224.66 175.11,224.66 168.69,221.63 166.89,219.84 166.42,219.84 166.18,220.08 166.18,220.38 166.01,220.55 165.62,220.55 165.43,220.36 165.43,219.87 165.24,219.68 164.97,219.68 164.78,219.87 164.78,220.36 164.59,220.55 164.32,220.55 164.13,220.36 164.13,219.87 163.94,219.68 163.68,219.68 163.49,219.87 163.49,220.36 163.3,220.55 163.03,220.55 162.84,220.36 162.84,219.87 162.65,219.68 162.38,219.68 162.19,219.87 162.19,220.36 162,220.55 155.81,220.55 151.84,216.58 149.03,216.58 126.87,194.42 126.87,183.19 127.85,182.21
M_CHB_DQ6: length 121.1
  TOP w0.102: CON_XMM2.10 201.21,222.5 200.34,222.5 198.75,221.94 197.56,221.94 196.84,222.53 v1(196.82,222.71) 195.38,222.71 195.07,222.4 195.07,222.15 194.87,221.95 193.32,221.95 193.19,222.07 193.19,222.48 193.31,222.6 CON_XMM4.10
  TOP w0.159: v1(131.4,174.45) XU1.AG34
  IN1 w0.102: v1(131.4,174.45) 131.07,174.78 131.07,176.46 130.46,177.07 130.46,180.45 129.57,181.35 129.57,182.37
  IN1 w0.14: v1(196.82,222.71) 196.76,222.77 195.26,222.77 194.41,221.92 193.51,221.92 192.67,221.08 191.29,221.08 191.05,221.32 190.72,221.32 190.55,221.15 190.55,220.72 190.37,220.55 189.92,220.55 189.6,220.23 188.86,220.23 188.02,221.07 186.58,221.07 185.72,220.22 185.08,220.22 184.22,221.07 182.72,221.07 181.62,220.22 181.1,220.22 180.25,221.07 178.83,221.07 177.98,220.22 177.29,220.22 176.44,221.07 174.32,221.07 173.52,220.27 173.2,220.27 172.93,220.54 172.61,220.54 172.42,220.34 172.42,219.49 172.25,219.33 171.95,219.33 171.73,219.54 171.73,219.83 171.54,220.02 171.27,220.02 171.08,219.83 171.08,219.49 170.92,219.33 169.53,219.33 167.73,217.53 156.52,217.53 156.36,217.37 156.36,217.14 156.95,216.56 156.95,216.44 156.43,215.93 156.23,215.93 156.03,216.13 156.03,216.33 156.03,216.33 156.03,216.53 155.77,216.8 155.36,216.8 154.97,216.4 154.97,216.2 155.68,215.49 155.68,215.19 155.43,214.94 155.24,214.94 154.5,215.68 154.25,215.68 153.35,214.78 153.35,214.53 152.76,213.94 149.43,213.94 129.03,193.54 129.03,184.12 129.57,183.59 129.57,182.37
M_CHB_DQ7: length 120.4
  TOP w0.102: CON_XMM2.155 201.4,221.75 200.71,221.06 199.77,221.06 v1(199.06,221.34) 199.06,221.34 198.83,221.56 197.21,221.56 196.7,221.06 195.63,221.06 195.4,221.28 195.4,221.59 195.55,221.75 CON_XMM4.155
  TOP w0.159: XU1.AH34 v1(132.31,174.45)
  IN1 w0.102: v1(132.31,174.45) 131.37,175.39 131.37,176.5 130.9,176.98 130.9,180.37 130.02,181.24 130.02,182.37
  IN1 w0.14: 130.02,182.37 130.02,183.95 129.67,184.3 129.67,193.28 149.67,213.28 154.15,213.28 154.38,213.51 154.38,213.92 153.99,214.31 153.99,214.53 154.26,214.8 154.49,214.8 155.19,214.1 155.5,214.1 158.29,216.89 163.07,216.89 163.25,216.7 163.25,215.33 163.44,215.14 163.71,215.14 163.9,215.33 163.9,216.7 164.09,216.89 167.99,216.89 169.79,218.69 172.84,218.69 174.51,220.36 175.2,220.36 175.56,220.73 176.24,220.73 177.1,219.86 178.22,219.86 179.35,220.73 180.09,220.73 180.94,219.87 182.17,219.87 183.3,220.73 184.02,220.73 184.89,219.86 186.03,219.86 187.15,220.73 187.83,220.73 188.7,219.86 189.59,219.86 189.69,219.76 190.96,219.76 191.91,220.71 192.77,220.71 193.68,221.62 194.8,221.62 195.82,222.4 196.48,222.4 197.14,221.74 198.12,221.74 198.53,221.34 v1(199.06,221.34)
M_CHB_DQ8: length 112.4
  TOP w0.102: CON_XMM4.159 196.87,218.35 197.03,218.19 198.88,218.19 199.39,217.68 200.74,217.68 v1(200.98,217.92) 201.4,218.34 202.08,218.34 202.56,217.86 202.82,217.86 203,218.03 203,218.97 203.2,219.18 203.76,219.18 203.96,218.98 CON_XMM2.159
  TOP w0.159: v1(134.14,176.27) XU1.AK35
  IN1 w0.102: 132.26,182.31 133.19,181.38 133.19,180.13 133.67,179.65 133.67,176.74 v1(134.14,176.27)
  IN1 w0.14: 132.26,182.31 132.26,192.28 150.68,210.7 155.98,210.7 156.58,211.3 157.72,211.3 157.86,211.44 157.86,211.71 158.01,211.86 158.6,211.86 158.72,211.73 158.72,211.48 158.9,211.3 159.41,211.3 159.55,211.44 159.55,211.72 159.72,211.89 160.12,211.89 160.25,211.76 160.25,211.44 160.39,211.3 164.66,211.3 167.65,214.29 169.2,214.29 171.06,216.15 173.9,216.15 174.94,217.2 175.39,217.2 175.5,217.31 176.31,217.31 177.16,216.46 178.09,216.46 178.97,217.35 180.06,217.35 180.95,216.46 181.95,216.46 182.8,217.31 184.03,217.31 184.42,216.92 184.42,216.91 184.87,216.46 185.89,216.46 185.98,216.55 187.06,217.42 187.71,217.42 187.82,217.31 187.83,217.31 188.22,216.92 188.22,216.91 188.67,216.46 189.43,216.46 189.43,216.45 190.17,216.45 190.57,216.86 191.43,216.86 191.89,217.31 192.87,217.31 193.36,216.83 194.35,216.83 195.19,217.67 196.46,217.67 196.98,218.19 198.72,218.19 199.22,217.68 200.74,217.68 v1(200.98,217.92)
M_CHB_DQ9: length 111.8
  TOP w0.102: CON_XMM4.161 196.87,216.65 197.05,216.46 199.36,216.46 200.23,215.6 200.61,215.6 v1(200.81,215.8) 200.81,216.36 201.1,216.65 202.18,216.65 202.56,216.26 202.74,216.26 202.9,216.41 202.9,216.99 203.05,217.14 203.86,217.14 203.96,217.05 CON_XMM2.161
  TOP w0.159: XU1.AL35 135.49,175.82 v1(135.02,176.29)
  IN1 w0.102: 133.81,181.79 133.81,180.91 134.27,180.44 134.27,177.28 135.02,176.53 v1(135.02,176.29)
  IN1 w0.14: 133.81,181.79 133.53,182.07 133.53,191.75 151.2,209.43 156.99,209.43 157.13,209.57 157.13,209.87 157.27,210.01 157.55,210.01 157.69,209.87 157.69,209.57 157.83,209.43 158.11,209.43 158.25,209.57 158.25,209.87 158.39,210.01 158.67,210.01 158.81,209.87 158.81,209.57 158.95,209.43 159.23,209.43 159.37,209.57 159.37,209.87 159.51,210.01 159.79,210.01 159.93,209.87 159.93,209.57 160.06,209.43 160.34,209.43 160.48,209.57 160.48,209.87 160.62,210.01 160.9,210.01 161.04,209.87 161.04,209.57 161.18,209.43 161.46,209.43 161.6,209.57 161.6,209.87 161.74,210.01 161.98,210.01 162.16,209.82 162.16,209.57 162.3,209.43 166.13,209.43 171.59,214.88 174.5,214.88 175.23,215.61 176.25,215.61 177.1,214.76 178.39,214.76 179.24,215.61 180.12,215.61 180.97,214.76 182.4,214.76 183.25,215.61 184.06,215.61 184.91,214.76 186.01,214.76 187.23,215.63 187.83,215.63 188.68,214.78 189.41,214.78 192.03,215.63 192.71,215.63 193.62,215.05 194.24,215.05 196.79,215.84 197.49,216.53 199.12,216.53 199.85,215.8 v1(200.81,215.8)
M_CHB_DQ10: length 114.8
  TOP w0.102: CON_XMM4.21 192.38,213.82 192.48,213.92 192.86,213.92 193.54,213.25 194.42,213.25 194.89,213.72 195.22,213.72 195.35,213.59 195.35,212.75 v1(195.53,212.57) 196.54,212.57 197.22,213.25 198.64,213.25 198.98,212.9 199.81,212.9 CON_XMM2.21
  TOP w0.159: v1(134.14,172.62) XU1.AK32
  IN1 w0.102: 135.74,181.64 135.74,178.91 135.84,178.81 135.84,174.94 135.49,174.58 135.49,173.37 135.17,173.05 134.57,173.05 v1(134.14,172.62)
  IN1 w0.14: 135.74,181.64 135.05,182.32 135.05,191.14 144.18,200.27 147.77,200.27 148.81,201.31 148.81,201.58 148.03,202.36 148.03,202.56 148.23,202.77 148.54,202.77 149.27,202.04 149.54,202.04 149.73,202.23 149.73,202.5 148.95,203.27 148.95,203.52 149.14,203.71 149.4,203.71 150.17,202.95 150.45,202.95 150.64,203.14 150.64,203.41 149.78,204.27 149.78,204.49 149.99,204.7 150.27,204.7 151.1,203.87 151.37,203.87 154.99,207.49 166.86,207.49 171.43,212.06 172.24,212.06 172.46,212.28 172.46,213.09 172.65,213.28 173.2,213.28 173.3,213.18 173.3,212.22 173.51,212.01 173.91,212.01 174.12,212.22 174.12,213.16 174.24,213.28 174.75,213.28 174.93,213.11 174.93,212.8 175.16,212.57 176.45,212.57 177.29,211.73 177.85,211.73 178.7,212.58 180.24,212.58 181.09,211.73 181.65,211.73 182.75,212.57 184.22,212.57 185.07,211.72 185.63,211.72 186.48,212.57 188.02,212.57 188.87,211.73 189.43,211.73 189.92,212.22 191.06,212.22 191.41,212.57 192.85,212.57 193.7,211.72 194.28,211.72 195.13,212.57 v1(195.53,212.57)
M_CHB_DQ11: length 114.1
  TOP w0.102: CON_XMM2.166 205.56,211.93 205.44,211.81 204.8,211.81 204.72,211.89 204.72,212.37 204.6,212.5 203.23,212.5 203.05,212.32 203.05,212.12 203.15,212.01 203.15,211.73 203,211.58 v1(202.26,211.58) 201.21,211.58 200.99,211.8 200.99,212.37 200.84,212.52 200.51,212.52 200.38,212.4 CON_XMM4.166
  TOP w0.159: XU1.AL32 v1(135.07,172.63)
  IN1 w0.102: 136.01,182.13 136.01,179.05 136.06,179 136.06,174.85 135.83,174.62 135.83,173.39 v1(135.07,172.63)
  IN1 w0.14: 136.01,182.13 135.69,182.45 135.69,190.87 144.45,199.63 148.83,199.63 151.54,202.34 151.82,202.34 152.07,202.08 152.3,202.08 152.5,202.29 152.5,202.51 152.22,202.79 152.22,203.02 152.64,203.44 152.91,203.44 153.43,202.92 153.7,202.92 153.89,203.11 153.89,203.38 153.37,203.9 153.37,204.17 153.82,204.62 154.08,204.62 154.39,204.31 154.66,204.31 154.85,204.5 154.85,204.77 154.54,205.07 154.54,205.34 156.06,206.86 167.13,206.86 170.9,210.62 171.79,210.62 172.01,210.85 172.01,210.97 172.14,211.1 172.59,211.1 172.72,210.97 172.72,210.8 172.9,210.62 173.59,210.62 174.8,211.83 175.31,211.83 175.69,212.21 176.25,212.21 177.1,211.36 178,211.36 179.11,212.21 180.05,212.21 180.44,211.82 180.44,211.82 180.9,211.36 181.82,211.36 182.94,212.21 184.03,212.21 184.88,211.36 185.87,211.36 186.97,212.21 187.27,212.21 187.83,212.21 188.68,211.36 189.9,211.36 190.22,211.68 191.39,211.68 191.92,212.21 192.66,212.21 193.51,211.36 194.75,211.36 195.86,212.22 196.47,212.22 197.13,211.56 198.63,211.56 199.44,212.37 200.42,212.37 201.21,211.58 v1(202.26,211.58)
M_CHB_DQ12: length 113.3
  TOP w0.102: CON_XMM2.14 201.09,219.02 199.75,219.02 198.13,218.52 197.46,218.52 196.93,218.98 v1(196.93,219.05) 195.45,219.05 195.35,218.95 195.35,218.31 195.2,218.16 194.97,218.16 194.84,218.29 194.84,219.46 194.67,219.63 194.42,219.63 CON_XMM4.14
  TOP w0.159: XU1.AK34 134.6,174.99 v1(134.15,175.44)
  IN1 w0.102: v1(134.15,175.44) 133.71,175.88 133.09,175.88 132.79,176.19 132.79,179.89 132.16,180.52 132.16,181.71
  IN1 w0.14: 132.16,181.71 131.62,182.25 131.62,192.54 150.41,211.33 155.71,211.33 156.09,211.7 156.09,211.7 156.32,211.94 156.92,211.94 157.07,212.09 157.07,212.32 156.98,212.42 156.98,212.59 157.11,212.72 162.36,212.72 162.56,212.52 162.56,212.06 162.69,211.94 163.07,211.94 163.22,212.09 163.22,212.52 163.42,212.72 163.78,212.72 163.93,212.57 163.93,212.12 164.11,211.94 164.39,211.94 164.59,212.14 164.59,212.5 164.82,212.72 165.18,212.72 167.39,214.93 168.94,214.93 170.8,216.79 173.63,216.79 174.78,217.94 175.25,217.94 175.52,217.67 176.41,217.67 177.25,216.83 177.91,216.83 178.75,217.67 180.25,217.67 181,216.92 181.01,216.92 181.1,216.83 181.71,216.83 182.56,217.68 184.22,217.68 185.08,216.82 185.71,216.82 186.56,217.67 188.03,217.67 188.88,216.82 189.62,216.82 190.32,217.52 191.36,217.52 191.51,217.67 192.96,217.67 193.65,218.36 194.31,218.36 194.56,218.11 194.97,218.11 195.1,218.24 195.1,218.64 194.84,218.9 194.84,219.35 195.1,219.61 195.48,219.61 195.89,219.2 196.78,219.2 v1(196.93,219.05)
M_CHB_DQ13: length 112.6
  TOP w0.102: CON_XMM2.16 200.69,217.3 199.72,217.3 198,216.79 197.5,216.79 196.93,217.27 v1(196.93,217.37) 195.86,217.37 195.63,217.6 195.1,217.6 194.89,217.4 194.89,217.22 195,217.12 195,216.84 194.87,216.71 194.51,216.71 194.44,216.79 193.62,216.79 193.55,216.87 193.55,217.06 CON_XMM4.16
  TOP w0.159: v1(135.01,175.39) 135.03,175.39 XU1.AL34
  IN1 w0.102: 132.89,182.19 133.52,181.57 133.52,180.4 134.02,179.9 134.02,177.07 134.57,176.51 134.57,175.82 v1(135.01,175.39)
  IN1 w0.14: v1(196.93,217.37) 196.86,217.31 195.77,217.31 195.45,217 195.45,216.28 195.27,216.1 194.96,216.1 194.59,216.46 193.68,216.46 192.54,215.97 190.71,215.97 190.35,215.61 189.95,215.61 189.47,215.12 188.87,215.12 188.02,215.97 187.18,215.97 186.69,216.46 186.42,216.46 186.17,216.21 186.17,215.41 185.88,215.12 185.07,215.12 184.22,215.97 183.4,215.97 183.02,216.35 182.59,216.35 182.31,216.07 182.31,215.37 182.06,215.12 181.61,215.12 181.1,215.12 180.25,215.97 179.48,215.97 178.97,216.48 178.72,216.48 178.4,216.17 178.4,215.39 178.14,215.12 177.3,215.12 176.45,215.97 175.52,215.97 175.37,216.12 174.9,216.12 174.29,215.52 171.33,215.52 168.69,212.88 168.42,212.88 167.91,213.39 167.64,213.39 167.45,213.2 167.45,212.93 167.96,212.42 167.96,212.16 167.77,211.97 167.5,211.97 167.03,212.44 166.77,212.44 166.58,212.25 166.58,211.98 167.05,211.51 167.05,211.24 166.45,210.64 156.82,210.64 156.24,210.06 150.94,210.06 132.89,192.01 132.89,182.19
M_CHB_DQ14: length 115.1
  TOP w0.102: CON_XMM2.23 199.33,211.55 198.96,211.91 198.63,211.91 198.27,211.56 197.41,211.56 196.72,210.87 v1(195.58,210.87) 195.25,211.2 195.25,211.63 195.1,211.79 194.56,211.79 194.23,211.46 193.5,211.46 193.24,211.71 193.24,212.06 193.04,212.27 192.51,212.27 192.38,212.15 CON_XMM4.23
  TOP w0.159: v1(134.14,171.7) XU1.AK31
  IN1 w0.102: v1(134.14,171.7) 134.6,172.16 135.2,172.16 135.51,172.47 135.51,172.75 136.11,173.35 136.11,174.59 136.31,174.8 136.31,179.37 136.85,179.9 136.85,181.92 136.32,182.45
  IN1 w0.14: v1(195.58,210.87) 195.33,210.87 194.22,210.02 193.71,210.02 192.86,210.87 190.53,210.87 189.68,210.03 188.87,210.03 188.02,210.87 187.27,210.87 186.82,211.32 186.29,211.32 186.07,211.1 186.07,210.15 185.93,210.02 185.07,210.02 184.22,210.87 182.82,210.87 181.98,210.03 181.1,210.03 180.25,210.87 179.44,210.87 179.22,211.09 178.75,211.09 178.51,210.86 178.51,210.34 178.19,210.02 177.3,210.02 176.45,210.87 175.54,210.87 175.38,211.03 174.93,211.03 173.89,209.99 171.99,209.99 171.14,209.15 170.88,209.15 170.73,209.29 170.46,209.29 170.27,209.1 170.27,208.83 170.42,208.69 170.42,208.42 170.23,208.23 169.96,208.23 169.81,208.37 169.55,208.37 169.36,208.18 169.36,207.92 169.5,207.77 169.5,207.5 169.31,207.31 169.04,207.31 168.9,207.46 168.63,207.46 168.44,207.27 168.44,207 168.58,206.85 168.58,206.59 168.13,206.14 157.34,206.14 157.07,205.87 157.07,205.38 157.61,204.85 157.61,204.5 157.42,204.31 157.15,204.31 156.68,204.77 156.49,204.77 156.24,204.52 156.24,204.3 156.69,203.85 156.69,203.58 156.5,203.39 156.23,203.39 155.88,203.74 155.61,203.74 155.42,203.55 155.42,203.29 155.77,202.93 155.77,202.66 155.58,202.47 155.32,202.47 154.96,202.83 154.69,202.83 154.5,202.64 154.5,202.37 154.86,202.01 154.86,201.75 154.67,201.56 154.4,201.56 154.05,201.91 153.78,201.91 153.59,201.72 153.59,201.45 153.94,201.1 153.94,200.83 153.75,200.64 153.48,200.64 153.13,200.99 152.86,200.99 152.67,200.8 152.67,200.54 153.02,200.18 153.02,199.91 152.83,199.72 152.57,199.72 152.21,200.08 151.94,200.08 150.86,199 144.71,199 136.32,190.61 136.32,182.45
M_CHB_DQ15: length 114.4
  TOP w0.102: CON_XMM2.168 203.58,210.7 203.23,211.05 202.74,211.05 202.56,210.87 202.56,210.13 202.31,209.87 v1(201.46,209.87) 201.15,209.87 201.04,209.98 201.04,210.57 200.89,210.72 199.72,210.72 199.39,210.39 199.21,210.39 199.11,210.49 199.11,210.95 199.03,211.02 198.7,211.02 198.38,210.7 CON_XMM4.168
  TOP w0.159: XU1.AL31 v1(135.06,171.7)
  IN1 w0.102: v1(135.06,171.7) 135.66,171.7 136.47,172.51 136.47,174.64 136.53,174.71 136.53,176.53 136.75,176.76 137.02,176.76 137.31,177.06 137.31,182.5
  IN1 w0.14: v1(201.46,209.87) 200.8,210.54 199.59,210.54 198.85,209.8 197.21,209.8 196.5,210.51 195.85,210.51 194.74,209.66 194.27,209.66 194.26,209.66 193.71,209.66 193.7,209.66 193.54,209.66 192.69,210.51 192.67,210.51 192.66,210.51 191.44,210.51 190.59,209.66 188.67,209.66 188.22,210.12 188.22,210.12 187.83,210.51 187.27,210.51 186.17,209.66 184.88,209.66 184.03,210.51 183.43,210.51 182.25,209.66 180.9,209.66 180.44,210.12 180.44,210.12 180.05,210.51 179.45,210.51 178.6,209.66 177.1,209.66 176.64,210.12 176.64,210.12 176.25,210.51 175.4,210.51 174.25,209.35 172.25,209.35 168.4,205.5 160.54,205.5 159.97,204.93 159.97,204.59 160.12,204.44 160.12,204.24 159.87,203.99 159.65,203.99 159.48,204.17 159.21,204.17 159.02,203.98 159.02,203.71 159.28,203.44 159.28,203.17 159.09,202.98 158.82,202.98 158.56,203.25 158.29,203.25 158.1,203.06 158.1,202.79 158.37,202.53 158.37,202.26 158.18,202.07 157.91,202.07 157.64,202.33 157.37,202.33 157.18,202.14 157.18,201.87 157.45,201.61 157.45,201.34 157.26,201.15 156.99,201.15 156.73,201.42 156.46,201.42 156.27,201.23 156.27,200.96 156.53,200.69 156.53,200.42 156.34,200.23 156.07,200.23 155.81,200.5 155.54,200.5 155.35,200.31 155.35,200.04 155.62,199.78 155.62,199.51 155.43,199.32 155.16,199.32 154.89,199.58 154.63,199.58 153.4,198.36 144.97,198.36 136.96,190.35 136.96,182.85 137.31,182.5
M_CHB_DQ16: length 98.2
  TOP w0.102: CON_XMM4.170 198.5,209 198.86,209.35 199.29,209.35 199.44,209.19 199.44,208.99 199.57,208.86 200.15,208.86 200.36,209.07 200.76,209.07 200.91,208.91 200.91,208.7 v1(201.46,208.15) 202.64,208.15 202.84,208.36 202.84,208.84 203,209 CON_XMM2.170
  TOP w0.159: v1(137.82,176.25) XU1.AP35
  IN1 w0.102: v1(137.82,176.25) 137.82,181.54
  IN1 w0.14: 137.82,181.54 138.23,181.94 138.23,189.44 145.88,197.09 155.79,197.09 160.76,202.06 166.8,202.06 172.8,208.05 174.71,208.05 175.47,208.81 176.3,208.81 177.15,207.96 178.03,207.96 179.36,208.81 180.05,208.81 180.9,207.96 181.97,207.96 183.25,208.81 184.08,208.81 184.93,207.96 186.17,207.96 187.27,208.81 187.83,208.81 188.22,208.42 188.22,208.42 188.67,207.96 190.42,207.96 192.11,208.81 192.66,208.81 193.51,207.96 194.43,207.96 195.78,208.81 196.46,208.81 196.83,208.55 197.32,208.34 198.32,208.34 199.56,208.81 200.8,208.81 v1(201.46,208.15)
M_CHB_DQ17: length 99.5
  TOP w0.102: CON_XMM4.25 192.38,210.27 192.58,210.46 193.12,210.46 193.29,210.29 193.29,209.93 193.45,209.78 194.23,209.78 194.49,210.03 195.17,210.03 195.45,209.75 v1(195.45,209.17) 196.55,209.17 197.94,209.85 CON_XMM2.25
  TOP w0.159: XU1.AN35 136.95,176.21 v1(136.95,176.27)
  IN1 w0.102: 137.55,182.43 137.55,176.87 v1(136.95,176.27)
  IN1 w0.14: v1(195.45,209.17) 195.16,209.17 194.31,208.33 193.7,208.33 192.85,209.17 191.06,209.17 190.21,208.32 188.87,208.32 188.84,208.35 188.84,208.35 188.02,209.17 186.41,209.17 186.2,208.96 186.2,208.47 186.06,208.33 185.02,208.33 184.17,209.18 182.64,209.18 181.79,208.32 181.1,208.32 180.24,209.18 178.71,209.18 177.86,208.33 177.29,208.33 176.45,209.17 175.51,209.17 175.42,209.26 175.03,209.26 174.45,208.69 172.52,208.69 166.52,202.69 166.01,202.69 165.93,202.78 165.93,204.7 165.78,204.85 165.43,204.85 165.28,204.7 165.28,202.76 165.21,202.69 164.49,202.69 164.29,202.9 164.29,203.53 164.03,203.78 163.5,203.78 163.19,203.48 163.19,202.87 163.02,202.69 160.35,202.69 155.39,197.73 145.61,197.73 137.59,189.71 137.59,182.47 137.55,182.43
M_CHB_DQ18: length 101.5
  TOP w0.102: CON_XMM2.32 201.76,203.38 201.63,203.25 201.04,203.25 200.89,203.4 200.89,203.73 200.66,203.96 200,203.96 199.06,203.02 198.77,203.02 v1(198.55,203.24) 197.34,203.24 196.2,203.9 CON_XMM4.32
  TOP w0.159: v1(137.8,173.53) XU1.AN32
  IN1 w0.102: 141.27,183.64 141.27,180.44 141.53,180.19 141.53,178.28 140.03,176.78 140.03,175.16 138.86,173.99 138.26,173.99 v1(137.8,173.53)
  IN1 w0.14: 141.27,183.64 141.99,184.35 142.54,184.35 142.75,184.15 142.75,183.24 142.98,183.01 143.64,183.01 146.63,186 146.63,190.25 147.07,190.68 148,190.68 148.39,191.07 148.39,191.32 147.7,192.01 147.7,192.3 147.89,192.49 148.13,192.49 148.82,191.8 149.12,191.8 149.31,191.99 149.31,192.26 148.77,192.8 148.77,193.07 148.96,193.26 149.23,193.26 149.77,192.72 150.03,192.72 150.22,192.91 150.22,193.17 149.68,193.71 149.68,193.98 150.01,194.31 165.4,194.31 175.16,204.07 176.42,204.07 177.27,203.22 177.95,203.22 178.8,204.07 180.25,204.07 181.1,203.22 181.73,203.22 182.58,204.07 184.22,204.07 185.07,203.22 185.7,203.22 186.55,204.07 188.02,204.07 188.87,203.22 189.71,203.22 190.56,204.07 192.84,204.07 193.69,203.22 194.32,203.22 195.13,204.04 196.69,204.04 197.51,203.22 198.53,203.22 v1(198.55,203.24)
M_CHB_DQ19: length 101
  TOP w0.102: CON_XMM2.177 202.25,203.05 200.22,202.36 199.57,202.36 v1(199.36,202.56) 198.88,202.56 198.78,202.46 198.45,202.46 198.07,202.84 197.15,202.84 196.67,202.36 195.85,202.36 195.78,202.44 195.78,202.64 CON_XMM4.177
  TOP w0.159: XU1.AP32 v1(138.71,173.53)
  IN1 w0.102: 141.96,178.36 141.96,178.28 140.28,176.61 140.28,175.1 v1(138.71,173.53)
  IN1 w0.14: v1(199.36,202.56) 198.44,202.56 198.14,202.86 197.32,202.86 196.48,203.71 195.78,203.71 194.94,202.86 193.51,202.86 192.66,203.71 191.75,203.71 190.9,202.86 188.73,202.86 187.88,203.71 186.97,203.71 186.12,202.86 184.92,202.86 184.07,203.71 182.96,203.71 182.11,202.86 180.9,202.86 180.05,203.71 179.1,203.71 178.25,202.86 177.17,202.86 176.32,203.71 175.7,203.71 165.46,193.47 153.69,193.47 153.16,192.95 152.89,192.95 152.16,193.68 151.87,193.68 151.68,193.49 151.68,193.24 152.43,192.49 152.43,192.22 152.24,192.03 151.98,192.03 151.23,192.77 150.96,192.77 150.77,192.58 150.77,192.32 151.52,191.57 151.52,191.3 151.33,191.11 151.06,191.11 150.33,191.84 150.06,191.84 149.87,191.65 149.87,191.38 150.6,190.65 150.6,190.39 150.41,190.2 150.14,190.2 149.41,190.93 149.14,190.93 148.95,190.74 148.95,190.47 149.68,189.74 149.68,189.47 149.35,189.13 148.66,189.13 148.44,189.36 148.03,189.36 147.42,188.75 147.42,185.79 143.97,182.33 143.97,182.14 141.96,180.14 141.96,178.36
M_CHB_DQ20: length 100.3
  TOP w0.102: CON_XMM4.27 192.38,208.62 192.63,208.86 193.07,208.86 193.24,208.69 193.24,208.25 193.35,208.15 194.35,208.15 194.46,208.25 195.1,208.25 195.28,208.08 195.28,207.7 v1(195.5,207.47) 196.51,207.47 197.6,208.15 CON_XMM2.27
  TOP w0.159: v1(136.95,175.36) 136.95,175.3 XU1.AN34
  IN1 w0.102: v1(136.95,175.36) 137.4,175.81 137.99,175.81 138.28,176.11 138.28,178.95 139.33,180 139.33,181.47 138.86,181.94
  IN1 w0.14: v1(195.5,207.47) 195,207.47 194.87,207.34 194.87,207.01 194.48,206.62 193.68,206.62 192.83,207.47 191.29,207.47 190.63,206.81 189.62,206.81 189.43,206.63 188.86,206.63 188.02,207.47 186.7,207.47 185.59,206.62 185.07,206.62 184.22,207.47 182.86,207.47 181.75,206.62 181.03,206.62 180.18,207.47 178.91,207.47 177.81,206.62 177.3,206.62 176.45,207.47 174.53,207.47 174.19,207.14 173.74,207.14 173.49,207.38 173.22,207.38 173.03,207.19 173.03,206.93 173.41,206.55 173.41,206.35 173.22,206.16 172.95,206.16 172.57,206.54 172.3,206.54 172.11,206.35 172.11,206.09 172.49,205.71 172.49,205.44 172.3,205.25 172.09,205.25 171.63,205.7 171.36,205.7 171.17,205.51 171.17,205.25 171.58,204.84 171.58,204.52 171.4,204.34 171.17,204.34 170.69,204.83 170.48,204.83 170.26,204.6 170.26,204.24 170.64,203.86 170.64,203.56 170.35,203.28 170.1,203.28 169.8,203.58 169.42,203.58 169.29,203.45 169.29,203.05 169.57,202.77 169.57,202.5 168.49,201.42 161.26,201.42 156.3,196.46 146.14,196.46 138.86,189.18 138.86,181.94
M_CHB_DQ21: length 99.6
  TOP w0.102: CON_XMM4.172 198.48,207.3 198.81,207.62 199.11,207.62 199.26,207.47 199.26,207.21 199.39,207.09 199.75,207.09 199.95,207.3 200.69,207.3 v1(201.54,206.45) 202.64,206.45 202.79,206.6 202.79,207.16 202.93,207.3 CON_XMM2.172
  TOP w0.159: XU1.AP34 v1(137.8,175.36)
  IN1 w0.102: v1(137.8,175.36) 138.1,175.36 138.56,175.82 138.86,175.82 139.15,176.1 139.15,178.67 139.63,179.16 139.63,181.67 139.5,181.81
  IN1 w0.14: v1(201.54,206.45) 200.82,207.16 199.26,207.16 198.57,206.47 197.11,206.47 196.46,207.11 195.78,207.11 194.93,206.26 193.56,206.26 192.71,207.11 191.89,207.11 191.64,206.86 191.64,206.19 191.44,205.99 190.87,205.99 190.6,206.26 188.68,206.26 187.83,207.11 187.23,207.11 186.13,206.26 184.88,206.26 184.03,207.11 183.41,207.11 182.31,206.26 180.96,206.26 180.11,207.11 179.25,207.11 178.4,206.26 177.18,206.26 176.33,207.11 175.49,207.11 174.73,206.35 174.32,206.35 168.76,200.79 162.05,200.79 159.69,198.42 159.69,197.74 157.77,195.82 146.4,195.82 139.5,188.92 139.5,181.81
M_CHB_DQ22: length 102.5
  TOP w0.102: CON_XMM4.34 194.76,202.2 194.94,202.01 196.58,202.01 197.39,201.54 198.47,201.54 v1(198.63,201.7) 199.52,201.7 199.82,202.01 200.94,202.01 201.04,201.9 201.04,201.63 201.17,201.5 202.08,201.5 202.21,201.63 202.21,201.74 CON_XMM2.34
  TOP w0.159: XU1.AN31 137.8,172.62 v1(137.82,172.62)
  IN1 w0.102: v1(137.82,172.62) 138.3,173.1 138.88,173.1 139.15,173.36 139.15,173.63 140.54,175.03 140.54,176.33 142.37,178.16 142.37,179.84
  IN1 w0.14: v1(198.63,201.7) 198.45,201.52 197.5,201.52 196.65,202.37 195.14,202.37 194.31,201.54 193.67,201.54 192.84,202.37 191.48,202.37 191.17,202.06 190.11,202.06 189.9,201.85 189.58,201.53 188.87,201.53 188.02,202.37 186.48,202.37 185.63,201.52 185.07,201.52 184.22,202.38 182.51,202.38 181.65,201.52 181.1,201.52 180.25,202.37 178.83,202.37 177.98,201.52 177.14,201.52 176.29,202.37 175.86,202.37 166.32,192.84 157.71,192.84 157.13,192.25 156.82,192.25 156.29,192.79 155.63,192.79 155.47,192.63 155.47,192.41 155.19,192.13 154.83,192.13 154.17,192.79 153.9,192.79 153.71,192.6 153.71,192.33 154.41,191.63 154.41,191.39 154.22,191.2 153.92,191.2 153.25,191.87 152.98,191.87 152.79,191.68 152.79,191.41 153.46,190.74 153.46,190.48 153.27,190.29 153.01,190.29 152.34,190.95 152.07,190.95 151.88,190.76 151.88,190.5 152.32,190.06 152.32,189.79 152.13,189.6 151.86,189.6 151.42,190.04 151.15,190.04 150.96,189.85 150.96,189.58 151.4,189.14 151.4,188.87 151.21,188.68 150.94,188.68 150.5,189.12 150.23,189.12 150.04,188.93 150.04,188.66 150.49,188.22 150.49,187.95 150.3,187.76 150.03,187.76 149.59,188.21 149.32,188.21 149.13,188.02 149.13,187.75 149.57,187.31 149.57,187.04 149.38,186.85 149.11,186.85 148.67,187.29 148.4,187.29 148.21,187.1 148.21,186.83 148.65,186.39 148.65,186.12 142.37,179.84
M_CHB_DQ23: length 101.5
  TOP w0.102: CON_XMM2.179 202.46,201.19 201.52,201.19 200.52,200.69 199.48,200.69 v1(199.3,200.88) 199.03,200.61 198.73,200.61 198.17,201.17 197.36,201.17 196.85,200.66 195.88,200.66 195.78,200.76 195.78,200.94 CON_XMM4.179
  TOP w0.159: XU1.AP31 v1(138.71,172.62)
  IN1 w0.102: v1(138.71,172.62) 138.84,172.62 139.29,173.07 139.82,173.07 140.08,173.33 140.08,173.78 140.79,174.5 140.79,176.3 142.74,178.24 142.74,178.93 143.48,179.68 143.73,179.68
  IN1 w0.14: 143.73,179.68 150.77,186.72 151.04,186.72 151.49,186.27 151.8,186.27 151.97,186.44 151.97,186.71 151.34,187.33 151.34,187.62 151.53,187.81 151.78,187.81 152.47,187.12 152.74,187.12 152.93,187.31 152.93,187.58 152.41,188.09 152.41,188.36 152.6,188.55 152.87,188.55 153.39,188.03 153.66,188.03 153.85,188.22 153.85,188.49 153.33,189.01 153.33,189.3 153.54,189.51 153.75,189.51 154.3,188.95 154.57,188.95 154.76,189.14 154.76,190.78 155.33,191.35 157.6,191.35 157.79,191.54 157.79,192.01 157.98,192.2 158.25,192.2 158.44,192.01 158.44,191.54 158.63,191.35 158.89,191.35 159.08,191.54 159.08,192.01 159.27,192.2 159.54,192.2 159.73,192.01 159.73,191.54 159.92,191.35 160.19,191.35 160.38,191.54 160.38,192.01 160.57,192.2 160.84,192.2 161.03,192.01 161.03,191.54 161.22,191.35 161.48,191.35 161.67,191.54 161.67,192.01 161.86,192.2 162.13,192.2 162.32,192.01 162.32,191.54 162.51,191.35 162.78,191.35 162.97,191.54 162.97,192.01 163.16,192.2 163.43,192.2 163.62,192.01 163.62,191.54 163.81,191.35 166.59,191.35 175.74,200.51 176.53,200.51 177.18,201.16 178.36,201.16 179.33,202.01 180.05,202.01 180.9,201.16 182.35,201.16 183.2,202.01 184.03,202.01 184.88,201.16 186.16,201.16 187.13,202.01 187.83,202.01 188.22,201.62 188.22,201.62 188.67,201.16 189.74,201.16 189.93,200.98 191,200.98 192.03,202.01 192.1,202.01 192.11,202.01 192.66,202.01 193.51,201.16 194.84,201.16 195.94,202.01 196.48,202.01 197.32,201.16 199.02,201.16 v1(199.3,200.88)
