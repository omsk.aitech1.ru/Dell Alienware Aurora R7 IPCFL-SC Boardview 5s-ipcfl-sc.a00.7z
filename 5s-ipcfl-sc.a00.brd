# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1VSB_TST_A: length 8.1
  TOP w0.254: PR170.2 v1(186.3,91.62) ; v1(190.25,90.03) 190.56,90.34 PU9.5 191.26,90.12 191.94,89.45 PR168.2
  BOTTOM w0.254: v1(190.25,90.03) v2(188.88,90.03) 187.89,90.03 186.3,91.62 v1(186.3,91.62)
+1VSB_VCC_A: length 4.5
  TOP w0.254: PU9.7 194.67,90.84 195.04,90.47 PC212.1
  TOP w0.508: PC212.1 195.47,89.74 v1(195.71,89.74) 195.71,88.67 PR165.2
  BOTTOM w0.254: v1(195.71,89.74) 195.48,89.74 v2(194.93,90.28)
+1VSB_VIN: length 7.6
  TOP w0.635: 210.13,96.87 PCE17.1 ; PCE17.1 209.19,97.81 ; PCE17.1 211.07,97.81 ; PCE17.1 210.13,98.75 ; 213.09,104.25 PL12.1 ; PL12.1 214.06,103.29 ; PL12.1 214.06,105.22 ; PL12.1 215.02,104.25
+3.3V_SUS: length 110.1
  TOP w0.229: U5.5 21.28,148.15 21.41,148.29 21.87,148.29 22.2,147.96 UC965.1
  TOP w0.254: 23.33,149.21 22.73,148.62 UC965.1 ; 23.33,149.21 23.33,150.01 AR238.1 22.94,150.41 22.94,151.08 23.22,151.36 24.41,151.36 26.47,153.42 35.77,153.42 35.77,153.42 v1(35.78,153.42) 38.21,153.42 UC971.1 39.59,152.04 39.59,150.27 39.02,149.7 U4.20 ; 23.33,149.21 23.7,148.84 v1(24.38,148.84) ; AR242.2 APR112.1 25.74,143.17 24.43,141.86 v1(23.67,141.86) 23.42,141.86 22.38,142.9 21.5,142.9 20.7,143.7 19.86,143.7 AR243.2 18.54,145.02 v1(18.54,145.19) 19,145.64 U5.29 ; AR241.2 16.42,154.13 v1(16.76,154.13) ; v1(24.17,146.35) 23.61,146.35 AR237.1
  TOP w0.279: v1(36.6,151.92) UC75.1 37.21,150.75 37.21,149.68 37.02,149.49 U4.24
  TOP w0.305: PQ9786.3 52.58,130.43 51.99,131.01 PC640681.1
  TOP w0.457: AR244.1 v1(33.76,160.74)
  TOP w0.508: v1(43.54,133.69) 44,133.69 49.53,128.17 PR341.2 51.07,128.17 52.58,129.67 PQ9786.3
  BOTTOM w0.254: v1(24.38,148.84) 24.73,148.49 24.73,147.59 24.17,147.03 v1(24.17,146.35) 23.99,146.18 23.99,142.18 v1(23.67,141.86) ; v1(16.76,154.13) 16.76,153.34 16.28,152.86 16.28,150.29 17.22,149.35 17.22,146.51 v1(18.54,145.19)
  BOTTOM w0.381: v1(36.6,151.92) 36.6,151.41 39.8,148.21 39.8,147.38 40.08,147.09 40.08,143.71 41.22,142.57 41.22,136.94 41.29,136.88 41.29,135.94 v1(43.54,133.69)
  BOTTOM w0.508: v1(36.6,151.92) 36.6,152.6 v1(35.78,153.42) 35.79,153.42 v2(35.79,155.73) 35.79,157.1 33.76,159.13 v1(33.76,160.74)
+5V: length 937.5
  TOP w0.203: 24.13,179.73 21.44,177.04 17.88,177.04 17.6,177.32 v1(17.6,177.32) ; M1R5.1 37.33,177.58 38.43,178.69 M1R4.1 ; S/PDIF.2 11.12,223.89 v1(13.34,226.1) 13.55,226.31 AC187.1 ; v1(50.7,236.22) 50.7,240.14 49.5,241.34 41.46,241.34 39.19,239.07 39.19,236.45 35.13,232.39 30.46,232.39 26.78,236.07 19.61,236.07 v1(19.38,235.84) 15.49,235.84 13.94,237.39 SR17.1
  TOP w0.254: v1(35.23,206.71) 35.94,207.42 38.95,207.42 40.32,208.79 40.74,208.79 43.31,211.35 43.31,218.28 43.65,218.62 43.65,219.98 v1(44.63,220.95) ; 24.13,179.73 v1(26.09,179.73) 27.53,179.73 29.68,177.58 M1R5.1 ; MQ15.1 16.03,171.97 v1(15.68,171.63)
  TOP w0.305: 230.12,200.61 P1CB3.1 ; P1CB3.1 230.12,201.47 ; P1CB3.1 230.56,201.04
  TOP w0.457: P1R1.1 230.78,167.86
  TOP w0.508: PR5806.2 79.1,206.76 78.23,205.89 78.23,204.98 78.63,204.58 PR5809.2 ; PQ9779.2 203.11,44.64 201.27,42.8 201.27,33.53 v1(201.02,33.27) ; PR5809.2 78.3,203.86 76.99,203.86 v1(76.45,203.33) ; PR5809.2 79.44,204.17 PR5876.1 ; v1(70.71,7.32) 70.28,7.75 70.28,10.59 70.59,10.9 UF7.1 ; v1(175.89,23.84) 175.89,23.42 177.46,21.85 177.46,19.09 175.16,16.79 175.16,10.79 175.4,10.55 175.4,6.95 171.93,3.47 159.53,3.47 v1(157.61,5.39) ; v1(66.04,212.34) 66.12,212.27 67.94,212.27 72.14,208.08 72.14,206.96 74.37,204.72 v1(74.8,204.72) ; v1(67.44,224.38) 67.44,222.66 v1(68.44,221.65) ; 85.52,11.48 85.52,9.35 86.03,8.84 v1(86.03,8)
  TOP w0.635: CON4.21 238.56,186.99 ; CON4.21 237.21,185.63 ; CON4.21 238.56,184.27 ; v3(57.1,122.45) 57.1,128.27 47.8,137.57 47.8,143.19 45.98,145.01 45.98,148.61 47.16,149.78 v1(47.89,149.78) ; CON4.6 233.06,174.39 ; CON4.6 234.42,173.03 ; CON4.6 233.06,171.67 ; 231.71,164.63 CON4.4 ; CON4.4 233.06,163.27 ; CON4.4 234.42,164.63 ; CON4.4 233.06,165.99 ; v3(75.79,102.41) 75.24,102.97 72.73,102.97 71.65,101.89 55.68,101.89 54.8,101 54.8,99.72 52.85,97.77 52.22,97.77 42.94,88.49 42.94,87.38 42.02,86.46 42.02,79.02 37.62,74.61 37.62,68.3 38.46,67.46 38.46,60.25 36.65,58.45 36.65,24.79 v3(31.9,20.04)
  TOP w0.762: v3(208.48,236.3) 208.48,237.69 v3(207.8,238.38)
  BOTTOM w0.203: v1(19.38,235.84) 16.57,233.03 16.57,228.76 13.91,226.1 v1(13.34,226.1)
  BOTTOM w0.254: v1(26.09,179.73) 26.09,180.54 26.7,181.15 26.7,188.73 29.35,191.39 29.35,196.15 34.02,200.83 34.02,205.5 v1(35.23,206.71) ; v1(15.68,171.63) 15.68,175.41 17.6,177.32 v1(17.6,177.32)
  BOTTOM w0.508: v1(70.71,7.32) 71.23,7.84 74.67,7.84 75.21,8.38 85.65,8.38 v1(86.03,8) 87.36,6.67 91.99,6.67 92.73,7.4 95.37,7.4 95.6,7.63 104.19,7.63 104.25,7.69 106.1,7.69 106.82,8.41 120.07,8.41 121.11,7.38 138.61,7.38 142.18,10.95 152.9,10.95 157.61,6.24 v1(157.61,5.39) ; 65.66,236.39 65.66,233.04 67.44,231.27 v1(67.44,224.38) ; v1(175.89,23.84) 175.89,24.13 177.14,25.37 179.29,25.37 181.17,27.25 187.59,27.25 188.18,27.84 196.23,27.84 198.59,30.2 198.7,30.2 201.02,32.52 v1(201.02,33.27) ; v1(66.04,212.34) 66.62,212.93 66.62,214.91 68.05,216.33 68.05,218.67 68.44,219.06 v1(68.44,221.65) ; v1(76.45,203.33) 76.2,203.33 v1(74.8,204.72)
  BOTTOM w0.635: v1(47.89,149.78) 47.89,161.02 46.6,162.32 46.6,171.46 43.97,174.09 43.97,180.49 44.58,181.1 44.58,181.14 44.59,181.15 44.59,194.31 44.6,194.32 44.6,205.22 45.69,206.31 45.69,206.43 45.71,206.44 45.71,219.88 v1(44.63,220.95) 45.47,221.79 PT4.1 45.47,224.76 45.85,225.14 PT5.1 45.85,231.37 v1(50.7,236.22) 50.87,236.39 65.66,236.39 ; v1(70.71,7.32) 44.63,7.32 v3(31.9,20.04) ; v3(75.79,102.41) 72.19,106.02 72.19,106.46 64.55,114.1 60.54,114.1 57.1,117.54 v3(57.1,122.45)
  BOTTOM w0.762: PT2.1 233.07,208.55 233.64,209.12 233.64,212.07 235.31,213.73 235.31,215.31 235.09,215.53 235.09,222.66 225.47,232.28 215.95,232.28 211.94,236.3 v3(208.48,236.3) ; 65.66,236.39 67.27,238 74.04,238 74.42,237.62 81.18,237.62 83.62,240.06 155.84,240.06 156.77,239.13 156.77,235.1 162.04,229.83 168.29,229.83 173.44,234.99 173.44,236.53 176.35,239.44 206.74,239.44 v3(207.8,238.38)
  vias: v3(220.45,146.1) v3(220.45,145.21) v3(221.62,147.09) v3(221.62,146.2) v3(232.28,202.56) v3(232.28,201.68) v3(232.28,200.53) v3(233.04,204.34) v3(233.04,201.04)
+5V_1VSB_IN: length 28.8
  TOP w0.203: 222.28,103.35 222.28,101.62 SR7676.1
  TOP w0.254: UR69715.1 224,106.6 v1(223.94,106.67)
  TOP w0.457: UR69717.1 222.12,134.62 ; UR69714.1 226.96,139.89
  TOP w0.635: UCE11.1 221.55,123.22 ; UCE11.1 220.66,124.1 ; UCE11.1 220.66,122.33 ; UCE11.1 219.77,123.22 ; 219.7,109.77 PL12.2 ; PL12.2 217.67,109.56 ; PL12.2 217.41,107.53 ; PL12.2 219.44,107.74
  BOTTOM w0.508: v1(222.5,103.73) 222.86,104.09 222.86,104.98 223.35,105.47 223.35,106.07 223.94,106.65 v1(223.94,106.67) 223.72,106.88 223.72,109.27 224,109.55 224,114.58 v2(223.46,115.13) 222.76,115.82 v1(222.07,115.82)
+5V_CHARGER_1: length 1.8
  TOP w0.635: 239.12,110.98 P24.2 239.12,109.2
  vias: v1(229.87,100.94) v1(230.35,103.66) v3(229.74,102.9) v3(229.92,99.49) v3(233.58,88.11) v3(234.57,88.32) v3(235.76,114.07) v3(235.76,113.16)
+5V_CHARGER_2: length 8.4
  TOP w0.406: SR7565.1 227.38,111.18 v1(227.51,111.3)
  TOP w0.635: 236.31,108.09 P24.3 237.13,108.91 ; P24.1 237.13,110.98 ; P24.1 236.24,110.09 ; P24.1 237.13,109.2
  BOTTOM w0.508: v1(228.35,114.33) 228.35,112.14 v1(227.51,111.3)
+5V_DISCHARGE: length 0.8
  BOTTOM w0.102: v2(228.85,201.8) v1(228.85,202.62)
+5V_DUAL: length 971.4
  TOP w0.254: 229.44,138.2 229.44,138.89 229.9,139.34 231.34,139.34 231.88,138.81 241.81,138.81 ; 229.44,138.2 UR69729.1 ; 229.44,138.2 229.82,137.82 229.82,137.11 228.52,135.81 UR69730.1 ; v1(212.97,127.83) 213.73,127.08 215.09,127.08 215.43,126.73 215.43,124.49 PR6607.1 ; UR69726.1 25.39,223.25 25.83,223.7 25.83,225.26 25.44,225.65 24.26,225.65 23.88,226.03 UR69711.2 v1(24.56,226.53) ; 39.2,201.97 CR19.1 38.11,202.41 37.21,202.41 36.73,201.93 UR69723.1
  TOP w0.457: PR6602.1 119.1,57.15 119.2,57.25 119.2,58.52 119.68,59 120.24,59 121.39,57.85 121.39,54.78 120.26,53.64 PR6605.1 120.72,53.22 121.26,52.68 121.26,50.6 120.32,49.66 ; 74.22,11.23 74.22,10.19 73.95,9.92 SR7678.2 ; 120.32,49.66 PR6601.1 ; 120.32,49.66 121.52,48.46 121.52,45.87 122.32,45.07 126.86,45.07 131.47,40.46 131.47,33.97 144.4,21.04 144.4,19.23 147.07,16.56 v1(147.07,14.78) ; 18.41,139.78 19.25,140.61 19.25,141.25 19.43,141.43 UR69710.2 19.8,142.13 19.84,142.16 UR69719.1 ; SR7677.2 73.03,9.92 73.53,10.41 73.53,11.3
  TOP w0.508: v3(117.04,4.83) 117.04,9.71 v1(118.24,10.91) ; UR69721.1 13.45,139.74 13.26,139.93 13.26,141.71 v1(13.45,141.9) ; v3(109.04,4.01) 109.04,6.78 110.46,8.2 114.16,8.2 115.25,7.1 v3(115.25,4.81) ; UR30.1 16.18,141.99
  TOP w0.635: PCE6212.1 210.52,137.03 ; PCE6212.1 211.46,136.09 ; PCE6212.1 210.52,135.15 ; PCE6212.1 209.58,136.09
  TOP w1.27: 240.28,205.87 241.81,204.34 241.81,88.16 239.45,85.81 237.61,85.8 235.28,85.8 231.8,82.32 231.8,77.7 235.25,74.24 238.58,74.24 241.81,71.01 241.81,4.57 239.27,2.03 121.67,2.03
  TOP w2.54: 222.81,202.44 222.81,189.51 221.67,188.37 221.67,166.55 221.16,166.04 221.16,153.5 212.14,144.48 212.14,143.26 ; 18.47,156.64 29.67,156.64 31.14,158.12
  IN1 w1.778: 218.11,241.55 176.2,241.55 171.83,237.19 171.83,235.64 167.72,231.52 162.64,231.52 158.37,235.79 158.37,239.8 156.51,241.66 58.51,241.66
  BOTTOM w0.254: v1(211.58,129.92) 211.58,129.22 v1(212.97,127.83) ; v1(24.56,226.53) 21.91,226.53
  BOTTOM w0.508: v1(118.24,10.91) 118.31,10.84 121.08,10.84 122.11,9.81 136.99,9.81 141.05,13.87 146.24,13.87 147.07,14.69 v1(147.07,14.78)
  BOTTOM w1.27: 56.64,241.55 40.89,241.55 38.86,239.52 38.86,235.2 34.54,230.89 24.71,230.89 21.29,227.46
  BOTTOM w1.778: 58.52,241.66 156.51,241.66 158.37,239.79 158.37,235.78 162.63,231.52 167.72,231.52 171.84,235.65 171.84,237.19 176.2,241.55 218.74,241.55
  vias: v1(15.9,156.24) v1(16.03,157.02) v1(16.71,156.29) v1(16.76,157.1) v1(16.89,139.78) v1(16.99,141.86) v1(17.63,139.78) v1(17.73,141.86) v1(239.37,206.53) v2(19.89,227.08) v3(17.48,226.52) v3(18.44,226.52) v3(35.33,159.79) v3(39.14,160.88) v3(40.51,204.47) v3(40.51,203.58) v3(40.51,202.69) v3(40.56,158.04) v3(40.56,157.15) v3(46.84,203.4) v3(47.52,204.09) v3(48.23,204.8) v3(54.97,235.43) v3(55.85,235.43) v3(55.98,240.03) v3(56.74,235.43) v3(56.87,240.03) v3(57.76,240.03) v3(58.65,240.03) v3(59.54,240.03) v3(79.3,6.02) v3(80.24,5.99) v3(81.15,5.99) v3(107.19,4.11) v3(108.13,4.09) v3(116.14,4.81) v3(221.77,235.51) v3(222.28,236.45) v3(222.66,235.51) v3(223.16,236.45) v3(223.57,235.51) v3(224.33,207.16) v3(224.33,206.27) v3(224.33,205.38) v3(225.22,207.16) v3(225.22,206.27) v3(239.37,205.64)
+5V_DUAL_CRT_MAIN: length 6.2
  TOP w0.102: Q35.2 Q35.5 231.42,216.15 231.55,216.28 PR196.2 231.94,216.68 232.25,216.99 v1(232.64,216.99)
  BOTTOM w0.102: v2(231.68,218.45) 232.05,218.08 232.05,217.58 v1(232.64,216.99)
+5V_DUAL_CRT_MAIN_R: length 12.9
  TOP w0.381: Q35.6 231.56,216.8 232.46,217.7 v1(232.97,217.7)
  TOP w0.508: v1(232.97,217.7) 233.3,217.7 233.81,217.2 233.81,216 234.38,215.43 PR121.1 PR195.2
  BOTTOM w0.102: v2(233.17,216.52) 233.17,217.5 v1(232.97,217.7)
+5V_DUAL_CRT_MAIN_R3: length 18.8
  TOP w0.457: PR121.2 v1(240.39,216.27)
  TOP w0.508: PQ34.4 234.06,204.65 234.19,204.52 PC242.1 234.86,203.9 234.9,203.94 PR138.1 236.12,203.94 v1(236.65,204.47)
  BOTTOM w0.508: v1(236.65,204.47) 236.94,204.76 236.94,209.64 v2(238.3,211) 239.78,212.47 239.78,215.66 v1(240.39,216.27)
+5V_DUAL_CRT_SB_R: length 4.8
  TOP w0.102: Q35.3 228.84,215.03 228.97,214.9 229.23,214.9 PR199.2 PR122.1 230.59,214.69 230.94,215.04 v1(231.55,215.04)
  BOTTOM w0.102: v1(231.55,215.04) 231.22,215.37 v2(231.22,215.82)
+5V_DUAL_CRT_SB_R3: length 14.4
  TOP w0.102: PQ37.1 240.06,209.05 240.06,211 PC132.1 239.57,212.2 PR198.1 238.33,213.45 235.18,213.45 234.25,214.38 v1(232.38,214.38) PR122.2
  BOTTOM w0.102: v1(232.38,214.38) 232.92,214.38 v2(233.1,214.55)
+5V_DUAL_DISCHARGE: length 9.6
  TOP w0.406: MQ24.3 209.95,214.36 210.39,213.92
  TOP w0.508: 210.39,213.92 216.15,213.92 v1(216.61,214.38) PR8.2
  BOTTOM w0.102: v2(217.4,214.38) v1(216.61,214.38)
+5V_LDO: length 8.9
  BOTTOM w1.016: v3(12.42,10.03) v2(12.42,11.25) 12.42,13.2 9.29,16.33 v3(9.29,17.62)
+5VA: length 973.4
  TOP w0.254: OR5.2 214.78,19.51 v1(214.15,19.51) ; v1(223.9,95.94) 223.9,90.33 220.9,87.33 220.9,80.67 224.38,77.19 224.38,70.11 222.4,68.12 222.4,53.84 221.77,53.21 221.77,53.01 v1(220.4,51.64) ; v1(229.03,124.92) 229.03,135.71 231.39,138.07 v1(231.57,138.07)
  TOP w0.381: v1(232.31,147.19) 229.72,147.19 PR511.1 ; v1(20.04,84.87) 21.73,86.56 21.73,93.77 35.59,107.63 44.17,107.63 46.74,110.21 49.53,110.21 52.98,113.66 56.71,113.66 58.32,115.27 58.32,128.64 48.67,138.29 48.67,147.13 47.88,147.91 v1(47.88,148.74) ; v1(142.94,231.2) 146.85,231.2 147.32,231.67 149.71,231.67 150.25,232.22 154.5,232.22 155.8,230.91 168.7,230.91 178.04,240.26 222.87,240.26 227.66,235.46 227.66,216.97 v1(227.13,216.43) ; v1(98.93,236.35) 66.29,236.35 61.85,240.79 55.7,240.79 54.71,239.8 54.71,237.21 54.03,236.52 52.43,236.52 50.93,235.03 50.93,233.55 50.32,232.94 47.83,232.94 46.99,233.78 v1(46.99,234.95)
  TOP w0.457: v1(220.14,49.83) 217.35,49.83 216.32,48.81 213.36,48.81 OR68.1 212.66,49.01 212.65,49 OR69.1
  TOP w0.508: v1(214.68,132.22) 214.86,132.22 215.27,131.81 215.27,131.29 215.23,131.25 AR233.2 215.23,128.87 v1(214.38,128.02) 216.92,128.02 v1(217.58,128.68) ; v1(153.52,105.69) 152.55,106.66 143.83,106.66 139.53,110.96 PR248.1 ; PR165.1 197.46,90.02 198.41,90.97 198.41,92.04 198.12,92.33 v1(198.12,96.72) 198.12,98.98 v1(199.29,100.15) ; v1(21.46,32.49) 21.97,32.99 v1(23.57,32.99) ; v1(211.96,223.32) 211.95,223.33 211.77,223.33 211.29,222.84 209.96,222.84 PR512.1 ; v1(227.13,216.43) 227.13,215.87 228.63,214.38 PR199.1 228.92,213.98 229.62,213.28 v1(232.26,213.28) 234.75,213.28 235.33,212.7 AR235.2 ; M1R40.1 140.5,96.43 143.38,99.31 152.65,99.31 v1(152.91,99.06) ; v1(25.1,31.75) 25.12,31.72 30.68,31.72 32.38,33.43 33.6,33.43 34.05,33.88 34.05,34.4 33.54,34.9 30.44,34.9 29.78,35.56 29.78,37.71 31.47,39.4 R36.1 ; v1(232.31,147.19) P1R3.1 ; v1(214,137.21) PR305.1
  TOP w0.635: 234.42,185.63 CON4.9 ; CON4.9 233.06,184.27 ; CON4.9 233.06,186.99 ; CON4.9 231.71,185.63
  BOTTOM w0.102: v2(21.21,29.36) v1(22,29.36)
  BOTTOM w0.254: v1(214.15,19.51) 214.72,18.94 219.38,18.94 220.18,19.74 220.18,21.78 220.78,22.38 220.78,27 220.09,27.69 220.09,28.6 219.39,29.3 219.39,34.2 220.13,34.93 220.13,36.63 220.93,37.43 220.93,42.94 222.52,44.53 222.52,45.86 220.99,47.38 220.99,48.98 v1(220.14,49.83) 220.14,51.38 v1(220.4,51.64) ; v1(231.57,138.07) 232.28,138.79 PT7.1 PT6.1 PT8.1 232.28,146.02 232.31,146.05 v1(232.31,147.19) ; v1(223.9,95.94) 223.9,97.03 223.69,97.24 223.69,99.05 225.56,100.93 225.56,104.63 226.5,105.58 226.5,106.44 226.75,106.68 226.75,121.46 229.03,123.74 v1(229.03,124.92)
  BOTTOM w0.381: v1(21.46,32.49) 21.44,32.51 21.44,38.94 20.93,39.45 20.93,55.75 20.38,56.3 20.38,84.52 v1(20.04,84.87) ; v1(98.93,236.35) 98.93,232.99 100.13,231.8 117.32,231.8 118.16,230.96 142.7,230.96 v1(142.94,231.2) ; v1(47.88,148.74) 47.27,149.35 47.27,160.71 45.97,162 45.97,171.17 43.31,173.84 43.31,180.75 43.97,181.41 43.97,194.56 43.98,194.58 43.98,205.48 45.07,206.57 45.07,218.54 43.26,220.35 43.26,221.64 43.03,221.87 43.03,230.99 v1(46.99,234.95)
  BOTTOM w0.508: v1(25.1,31.75) 24.97,31.75 23.72,32.99 v1(23.57,32.99) ; v1(214.38,128.02) 213.52,127.16 211.93,127.16 211.4,127.69 209.25,127.69 208.08,126.52 208.08,116.76 207.15,115.84 207.15,102.73 206.07,101.65 200.79,101.65 v1(199.29,100.15) ; v1(230.29,190.25) 230.55,190.51 230.55,203.12 231.33,203.9 231.33,209.06 231.95,209.68 PT10.1 231.95,212.98 v1(232.26,213.28) ; v1(153.52,105.69) 152.91,105.08 v1(152.91,99.06) 152.91,98.25 153.85,97.31 170.72,97.31 171.24,96.79 171.35,96.67 171.35,96.67 173.18,94.84 184.68,94.84 185.38,95.54 190.32,95.54 190.63,95.23 196.37,95.23 197.86,96.72 v1(198.12,96.72) ; v1(211.96,223.32) 212.52,223.32 213.02,223.81 218.22,223.81 219.65,225.25 223.62,225.25 227.37,221.5 227.37,216.69 227.13,216.45 v1(227.13,216.43) ; v1(217.58,128.68) 221.84,132.94 PT9.1 223.38,146.72 223.38,171.03 224.66,172.31 v1(224.66,184.73) ; v1(214,137.21) 214,132.91 v1(214.68,132.22)
  BOTTOM w0.762: v1(232.31,147.19) 232.31,148.46 230.02,150.74 230.02,157.73 228.32,159.44 228.32,161.72 229.02,162.42 229.02,165.24 229.81,166.03 229.81,174.54 230.53,175.26 230.53,182.44 231.05,182.96 231.05,184.11 230.5,184.65 v3(230.5,187.5)
+5VSB: length 414.8
  TOP w0.381: v1(34.06,156.08) v1(46.38,156.08) ; v1(32.38,154.08) 32.36,154.05 M2R52.1
  TOP w0.508: PR6810.1 42.04,239.45 42.47,239.88 44.88,239.88 v1(45.39,239.37) ; v1(213.33,140.36) 214.2,139.5 v1(214.2,138.94) ; v1(215.06,134.14) 215.06,134.03 215.64,133.45 217.04,133.45 v1(217.78,132.72) ; PR123.1 v1(210.4,144.19)
  TOP w1.016: 78.38,238.68 79.73,237.34 104.52,237.34 ; 122.07,235.97 122.66,235.38 122.66,233.12 123.95,231.83 131.8,231.83 ; 192.76,232.87 192.15,233.48 173.51,233.48 168.91,228.88 154.81,228.88 153.87,229.82
  BOTTOM w0.381: v1(46.38,156.08) 46.41,156.11 46.41,160.38 45.26,161.52 45.26,170.74 42.6,173.41 42.6,181.13 43.22,181.75 43.22,194.82 43.27,194.87 43.27,205.77 44.36,206.87 44.36,218.2 44.32,218.24 44.32,218.28 42.55,220.06 42.55,221.35 42.32,221.58 42.32,236.3 v1(45.39,239.37) ; v1(32.38,154.08) 32.38,154.41 v1(34.06,156.08)
  BOTTOM w0.508: v1(215.06,134.14) 215.04,134.14 214.91,134.26 214.91,138.02 214.2,138.73 v1(214.2,138.94) ; v1(213.33,140.36) 211.56,142.14 211.56,143.03 v2(211.24,143.34) v1(210.4,144.19)
  BOTTOM w0.762: v1(217.78,132.72) 219.35,134.29 219.35,146.96 222.63,150.24 222.63,171.34 223.85,172.55 223.85,188.32 224.74,189.2 224.74,190.44 224.74,190.44 224.74,191.67 226.31,193.24 226.31,195.43 225.91,195.83
  BOTTOM w1.016: 133.3,232.16 143.66,232.16 144.36,231.46 146.15,231.46 146.39,231.7 153.09,231.7 ; 224.92,198.48 224.71,198.68 224.71,203.56 227.65,206.49 227.65,211.86 227.65,215.71 228,216.07 228,216.08 228.09,216.17 228.1,216.17 228.24,216.31 228.24,221.86 228.07,222.04 228.07,222.07 223.95,226.19 219.35,226.19 217.86,224.69 215.93,224.69 214.1,226.52 212.72,226.52 211.9,227.34 211.46,227.34 210.19,228.62 210.19,231.24 209.65,231.78 208.29,231.78 207.61,232.46 194.38,232.46 ; v1(45.39,239.37) 47.52,239.37 48.92,237.97 61.67,237.97 62.7,239 76.44,239 ; 105.77,237.34 108.32,234.79 117.56,234.79 118.76,235.99 v1(120.73,235.99)
  vias: v1(76.66,238.79) v1(77.5,238.76) v1(105.56,238.58) v1(105.71,237.82) v1(121.74,235.99) v1(132.13,231.98) v1(132.87,231.98) v1(153.7,231.52) v1(153.7,230.78) v1(193.22,232.56) v1(193.98,232.58) v1(225.91,197.92) v1(225.91,197.26)
+5VSB_AUDIO: length 15.6
  BOTTOM w0.762: 11.67,28.14 10.33,28.14 9.7,27.51 9.7,19.51 8.08,17.88 v2(8.08,16.69) 8.08,15.42 v3(8.51,14.99)
  vias: v1(13.92,27.99) v1(14.38,28.44)
+12V: length 550.2
  TOP w0.381: v1(80.39,240.03) 81.38,239.04 v1(102.87,239.04) ; P1CB1.1 230.8,194.18 ; P1CB1.1 230.29,194.72 ; P1CB1.1 230.29,193.65 ; v1(49.31,240.36) 49.1,240.58 41.78,240.58 40.31,239.11 v1(40.31,232.87) 40.31,231.64 PR70254.1 ; v1(160.05,229.95) 168.63,229.95 177.92,239.24 v1(208.97,239.24)
  TOP w0.508: PC151.1 129.19,98.05 ; 129.19,98.05 v1(129.21,98.05) ; 129.19,98.05 129.19,98.03 129.17,98.01 129.17,97.98 128.78,97.58 128.75,97.58 128.69,97.52 PU5.6 ; v1(132.46,116.51) 132.99,115.98 136.86,115.98 v1(138.03,114.81) ; v1(214.12,142.95) 214.03,142.86 PR302.1 ; v1(225.43,193.7) 225.96,193.17 230.25,193.17 ; PR195.1 v1(241,213.78) ; PR5.1 230.4,196.91 230.4,196.14 ; v1(205.88,100.65) 204.48,100.65 204.14,100.99 v1(198.32,100.99) ; SR628.1 27.2,170.31 28.75,171.86 36.98,171.86 38.48,173.35 40.21,173.35 v1(40.74,173.89)
  BOTTOM w0.381: v1(160.05,229.95) 155.69,234.3 146.71,234.3 146.15,234.86 143.55,234.86 143.07,235.34 138.87,235.34 138.38,234.85 137.57,234.85 136.95,234.24 122.94,234.24 121.91,233.21 107.66,233.21 102.87,238.01 v1(102.87,239.04) ; v1(49.31,240.36) 50.53,239.14 61.19,239.14 62.27,240.22 80.2,240.22 v1(80.39,240.03) ; 241,212.19 v1(241,213.78) 241.6,214.39 241.6,226.59 237.19,231.01 234.54,231.01 233.32,232.23 229.83,232.23 227.62,234.44 218.72,234.44 213.93,239.24 v1(208.97,239.24)
  BOTTOM w0.508: v1(132.46,116.51) 131.67,115.72 131.67,114.05 130.63,113 127.73,113 126.86,112.13 126.86,102.67 129.21,100.33 v1(129.21,98.05) ; v1(40.31,232.87) 40.31,230.35 41.54,229.12 41.54,225.79 40.98,225.23 40.98,221.92 41.85,221.06 41.85,219.77 43.56,218.05 43.56,218.01 43.66,217.91 43.66,207.16 42.57,206.06 42.57,195.16 42.52,195.11 42.52,182.04 41.87,181.39 41.87,175.02 v1(40.74,173.89) ; v1(138.03,114.81) 147.72,114.81 155.68,106.86 170.81,106.86 172.21,105.46 172.21,104.97 175.38,101.8 196.95,101.8 197.76,100.99 v1(198.32,100.99) ; v1(225.43,193.7) 224.26,193.7 PT13.1 223.85,193.29 223.85,190.8 223.85,189.57 222.96,188.68 222.96,187.95 222.96,187.95 222.96,174.38 PT14.1 222.5,172.46 221.74,171.7 221.74,153.25 214.12,145.63 v1(214.12,142.95) 214.12,142.06 216,140.18 216.29,140.18 217.83,138.64 217.83,134.33 216.56,133.06 216.56,131.55 216.79,131.32 216.79,129.46 216.6,129.27 216.6,126.85 217.32,126.13 217.32,125.43 216.97,125.08 216.97,112.65 214.44,110.13 214.44,106.13 215.34,105.24 215.34,103.25 215.15,103.06 214.76,102.67 214.76,99.71 213.17,98.12 212.06,98.12 210.99,99.19 209.67,99.19 208.22,100.65 v1(205.88,100.65)
  vias: v3(238.63,200.28) v3(239.65,200.28)
+12V_CPU: length 617.1
  TOP w0.102: v1(229.41,5.22) 230.18,4.45 233.36,4.45 234.16,5.26 236.65,5.26 237.16,4.75 239.09,4.75 240.61,6.27 240.61,38.1 239.6,39.12 237.67,39.12 236.51,37.96 228.54,37.96 225.6,40.89 225.3,40.89 223.96,42.23 223.96,44.59 221.53,47.03 221.53,48.05 220.43,49.15 217.49,49.15 O2R3.2 ; v1(171.68,9.58) 169.34,7.24 150.65,7.24 150.45,7.43 145.64,7.43 145.11,7.96 138.27,7.96 132.37,13.87 132.37,16.38 v1(131.22,17.53) ; v1(28.42,32.57) 26.99,32.57 21.45,38.11 21.45,59.22 23.67,61.44 23.67,95.2 35.74,107.28 44.31,107.28 46.89,109.86 49.68,109.86 53.13,113.3 56.86,113.3 59.08,115.52 59.08,125.01 63.29,129.23 64.79,129.23 66.14,130.58
  TOP w0.508: PR5875.1 70.61,224.79 67.64,227.76 ; PR5909.1 64.85,212.01 v3(62.23,214.63) ; PR602.1 64.69,170.51 63.88,169.69 PQ601.11 ; PR70202.1 74.05,125.09 73.48,125.65 69.67,125.65 67.77,127.56 67.77,128.37 67.44,128.7 67.44,129.36 ; PR5902.1 67.33,187.32 62.48,187.32 PQ591.11 ; PR609.1 62.81,152.58 ; PR6109.1 142.65,227.43 ; PR6102.1 91.54,231.5
  TOP w0.635: P70.2 152.53,239.45 ; P70.2 153.59,238.38 ; P70.2 152.53,237.31 ; 122.05,239.45 P461.2 ; P461.2 123.11,238.38 ; P461.2 120.98,238.38 ; 103.73,232.61 PCE611.1 ; PCE611.1 104.67,233.55 ; PCE611.1 102.79,233.55 ; P458.2 134.24,239.75 ; P29.2 237.21,220.8 ; P29.2 238.27,221.87 ; P29.2 238.27,219.74 ; P29.2 239.34,220.8
  TOP w0.889: 63.49,229.56 P3.4 ; P3.4 62.06,228.12 ; P3.4 60.62,229.56 ; P3.4 62.06,230.99 ; PCE591.1 54.46,218.16 ; PCE591.1 54.46,216.43 ; PCE591.1 53.59,217.3 ; PCE591.1 55.32,217.3 ; 50.57,145.26 PCE11.1 ; PCE11.1 51.51,146.2 ; PCE11.1 50.57,147.14 ; P3.3 62.06,226.79 ; P3.3 60.62,225.36 ; P3.3 62.06,223.92 ; P3.3 63.49,225.36
  TOP w1.27: 229.26,219.79 229.26,237.13 225.09,241.3 176.88,241.3 167.43,231.85 159.94,231.85 158.32,233.48
  BOTTOM w0.102: v1(229.41,5.22) 228.95,4.75 215.57,4.75 211.69,8.64 193.65,8.64 191.92,10.36 191.92,12.4 191.4,12.92 184.32,12.92 183.8,12.4 183.52,12.12 182.74,12.12 182.74,12.12 177.36,12.12 176.43,11.18 174.14,11.18 172.54,9.58 v1(171.68,9.58) ; v1(131.22,17.53) 130.74,17.53 129.56,16.34 89.44,16.34 89.01,15.91 42.09,15.91 41.11,16.89 41.11,17.28 28.42,29.97 v1(28.42,32.57)
  BOTTOM w0.635: PT54.1 50.16,183.69 ; PT54.1 50.16,182.47 ; PT54.1 49.56,183.08 ; PT54.1 50.77,183.08 ; PCE601.1 49.36,176.91 ; PCE601.1 50.39,175.88 ; PCE601.1 51.42,176.91 ; PCE601.1 50.39,177.94
  BOTTOM w0.889: 50.57,145.25 PCE11.1 ; PCE11.1 50.57,147.16 ; PCE11.1 51.52,146.2 ; P3.4 60.54,229.56 ; P3.4 62.06,231.08 ; P3.4 62.06,228.03 ; P3.4 63.58,229.56 ; 63.58,225.36 P3.3 ; P3.3 62.06,226.88 ; P3.3 60.54,225.36 ; P3.3 62.06,223.83 ; PCE591.1 54.46,218.33 ; PCE591.1 53.43,217.3 ; PCE591.1 54.46,216.27
  vias: v1(51.14,214.35) v3(50.01,188.95) v3(50.01,187.81) v3(50.01,186.41) v3(50.16,197.87) v3(50.16,196.47) v3(50.16,195.07) v3(50.34,181.28) v3(50.5,204.52) v3(50.77,169.88) v3(50.77,168.73) v3(50.77,167.34) v3(51.21,210.34) v3(51.21,148.49) v3(51.18,143.38) v3(51.44,199.85) v3(51.41,156.82) v3(51.44,155.93) v3(51.44,154.1) v3(51.44,153.19) v3(51.46,161.39) v3(51.79,184.33) v3(51.79,177.7) v3(51.87,191.47) v3(51.94,165.02) v3(51.99,173.23) v3(52.2,139.95) v3(52.78,207.14) v3(52.83,137.54) v3(52.96,149.86) v3(53.95,210.67) v3(54.64,188.34) v3(55.12,153.8) v3(55.5,136.27) v3(55.63,170.31) v3(55.88,171.7) v3(56.13,189.36) v3(56.08,151) v3(56.29,213.39) v3(56.77,153.8) v3(56.9,208.46) v3(57.4,206.88) v3(57.4,189.36) v3(57.53,171.7) v3(59.18,136.27) v3(62.15,136.42) v3(64.14,134.87) v3(65.18,133.86) v3(65.41,231.93) v3(65.38,131.57) v3(65.53,229.36) v3(119.25,228.88) v3(120.83,227.05) v3(123.09,229.11) v3(126.49,229.17) v3(130.33,229.17) v3(133.25,229.16) v3(137.29,227.84)
+12V_DISCHARGE: length 3.5
  TOP w0.254: PR5.2 229.7,198.12 v1(228.78,198.12) 228.22,198.12 227.98,198.36 MQ26.3
  BOTTOM w0.102: v2(228.78,197.31) v1(228.78,198.12)
+12V_GFX: length 83.2
  TOP w0.305: 42.67,76.4 XC90.1 ; XC90.1 43.1,76.83 ; XC90.1 42.67,77.27
  TOP w0.457: XC95.1 43.35,25.4 ; XC95.1 42.84,25.93 ; XC95.1 42.84,24.87
  TOP w0.635: SLOT4.B3 47.45,20.13 ; SLOT4.B3 46.69,19.37 ; SLOT4.B3 47.45,18.61 ; 46.71,42.19 SLOT3.A3 47.45,41.38 ; 46.45,65.25 SLOT2.A2 45.64,64.51 ; 45.04,70.26 PCE23.1 ; PCE23.1 44.18,71.12 ; PCE23.1 45.9,71.12 ; PCE23.1 45.04,71.98 ; SLOT4.B1 44.69,19.37 ; SLOT4.B1 45.45,20.13 ; SLOT4.B1 45.45,18.61 ; SLOT4.B1 46.21,19.37 ; 46.45,23.03 SLOT4.A2 46.45,24.71 ; SLOT3.B3 46.64,39.69 ; SLOT3.B3 47.45,38.95 ; SLOT3.B3 48.19,39.69 ; SLOT3.B3 47.45,40.43 ; SLOT3.B1 45.45,40.43 ; SLOT3.B1 46.19,39.69 ; SLOT3.B1 45.45,38.95 ; SLOT3.B1 44.64,39.69 ; 45.45,79.57 SLOT1.B1 ; SLOT1.B1 44.69,80.33 ; SLOT1.B1 45.45,81.09 ; SLOT1.B1 46.21,80.33 ; 46.69,82.83 SLOT1.A3 ; SLOT1.A3 47.45,82.07 ; SLOT1.A3 48.21,82.83 ; SLOT1.A3 47.45,83.59 ; 64.71,99.09 GPU_PWR.7 ; GPU_PWR.7 63.43,100.37 ; GPU_PWR.7 65.99,100.37 ; 46.45,43.45 SLOT3.A2 ; SLOT3.A2 46.45,44.93 ; SLOT3.A2 45.64,44.19 ; SLOT3.A2 47.19,44.19 ; 45.18,29.71 XCE16.1 ; XCE16.1 45.18,31.44 ; XCE16.1 44.32,30.57 ; XCE16.1 46.05,30.57 ; SLOT1.B2 46.45,79.09 ; SLOT1.B2 47.21,78.33 ; SLOT1.B2 45.69,78.33 ; SLOT1.B2 46.45,77.57 ; SLOT2.B1 46.19,60.01 ; SLOT2.B1 45.45,60.75 ; SLOT2.B1 45.45,59.2 ; SLOT2.B1 44.71,60.01 ; SLOT2.A3 46.64,62.51 ; 46.45,18.13 SLOT4.B2 45.69,17.37 ; 46.71,60.01 SLOT2.B3 47.45,59.2 ; 57.59,100.37 GPU_PWR.5 56.31,98.88 ; 60.51,99.09 GPU_PWR.6 ; GPU_PWR.6 59.23,100.37 ; GPU_PWR.6 61.79,100.37 ; SLOT3.B2 47.19,37.69 ; SLOT3.B2 46.45,38.43 ; SLOT3.B2 45.64,37.69 ; SLOT3.B2 46.45,36.95 ; 47.45,79.57 SLOT1.B3 ; SLOT1.B3 47.45,81.09 ; SLOT1.B3 46.69,80.33 ; 47.45,21.11 SLOT4.A3 46.69,21.87 ; SLOT2.B2 45.64,58.01 ; SLOT2.B2 46.45,57.27 ; SLOT2.B2 46.45,58.75 ; SLOT2.B2 47.19,58.01 ; 46.45,84.07 SLOT1.A2 ; SLOT1.A2 46.45,85.59 ; SLOT1.A2 47.21,84.83 ; 68.91,99.09 GPU_PWR.8 67.63,100.37
  BOTTOM w0.889: 68.91,101.82 GPU_PWR.8 ; GPU_PWR.8 68.91,98.93 ; GPU_PWR.8 67.46,100.37 ; 64.71,98.93 GPU_PWR.7 ; GPU_PWR.7 64.71,101.82 ; GPU_PWR.7 63.26,100.37 ; GPU_PWR.7 66.16,100.37 ; 61.96,100.37 GPU_PWR.6 60.51,98.93
+AVDDH: length 22.1
  TOP w0.203: U10.22 33.58,212.27 ; U10.9 33.58,218.37 33.27,218.67
  TOP w0.254: 31.62,219.63 32.59,218.67 33.27,218.67
  TOP w0.305: 33.58,212.27 33.58,211.89 33.66,211.81 LCB20.1 LCB12.1 34.19,209.65 v1(34.19,209.32)
  TOP w0.508: 31.62,219.63 31.04,219.63 30.52,220.15 LCB11.1 31.14,220.6 v1(31.34,220.4)
  BOTTOM w0.508: v1(31.34,220.4) 31.55,220.4 32,219.94 32,217.75 32.77,216.99 32.77,213.74 v2(33.64,212.86) 34.19,212.32 v1(34.19,209.32)
+AVDDL: length 38.5
  TOP w0.203: U10.6 34.78,219.51 34.9,219.63 LCB7.1 ; LCB14.1 31.34,213.59 31.67,213.59 32.31,214.22 U10.19 ; LCB15.1 30.85,216.71 32.18,216.71 32.27,216.62 U10.13
  TOP w0.254: v1(31.32,217.27) 30.85,217.27 LCB15.1
  TOP w0.305: v1(32.25,213.22) 32,212.98 31.24,212.98 LCB14.1 ; v1(34.42,222.68) 34.26,222.53 34.26,220.52 34.57,220.22 LCB7.1
  TOP w0.457: v1(34.42,222.68) L2.1
  BOTTOM w0.508: v1(37.34,212.72) 37.21,212.85 37.21,217.68 36.3,218.59 36.3,221.13 34.75,222.68 v1(34.42,222.68) 33.6,221.87 32.64,221.87 31.8,222.71 30.84,222.71 30.58,222.45 30.58,219.53 v2(31.09,219.02) 31.09,217.5 v1(31.32,217.27) 32.14,216.45 32.14,213.33 v1(32.25,213.22)
+AVDDVCO: length 3.7
  TOP w0.203: 39.8,214.38 39.22,214.96 38.46,214.96 v1(38.35,214.86) 38.19,215.02 U10.34
  BOTTOM w0.102: v2(39.14,215.14) 38.86,214.86 v1(38.35,214.86)
+DVDDL: length 15.4
  TOP w0.203: U10.37 38.6,216.22 38.89,216.51
  TOP w0.508: L2.2 v1(34.42,225.55)
  BOTTOM w0.508: v1(34.42,225.55) 34.51,225.65 v2(35.32,225.65) 36.3,224.66 37.98,224.66 39.22,223.42 39.22,217.27 39.52,216.97 v1(40.23,216.97)
+V1P0A_VCCAMPHYPLL_W25MIL: length 8.2
  TOP w0.305: 185.7,63.07 186.82,64.18 188.14,64.18 189.31,65.35 189.31,66.38 189.51,66.58 SCB13.1 SCB12.1
  BOTTOM w0.254: v1(182.96,62.69) 182.43,62.69 v2(182.22,62.9)
+V1P0A_VCCCLK2: length 31.5
  TOP w0.254: PCH.W17 167.72,52.98 168.08,52.62 v1(168.87,52.62) ; v1(194.82,59.36) 194.22,59.96 SR43.2
  BOTTOM w0.254: v1(194.82,59.36) 192.99,57.53 187.09,57.53 185.78,56.21 184.94,56.21 183.58,54.85 181.38,54.85 180.63,54.11 v2(180.09,54.11) 178.29,54.11 177.97,53.78 175.07,53.78 174.43,53.14 169.4,53.14 v1(168.87,52.62)
+V1P0A_VCCF24_W15MIL: length 16.3
  TOP w0.152: 159.57,57.49 PCH.K1 160.1,57.59 PCH.K2
  TOP w0.381: v1(146.58,55.85) 146.58,56.02 SR411.2 148.03,55.87 SCB14.1 SCB4.1 151.64,55.87 152.13,56.37 SCB5.1 155.74,56.37 156.85,57.49 159.57,57.49
  BOTTOM w0.381: v2(147.42,55.85) v1(146.58,55.85)
+VCC_USB2: length 17.9
  TOP w0.635: 12.93,188.65 J10.11 ; J10.11 11.99,189.59 ; J10.11 11.99,187.71 ; J10.11 11.05,188.65 ; 15.55,188.65 J10.21 ; J10.21 14.61,189.59 ; J10.21 14.61,187.71 ; J10.21 13.67,188.65 ; UCE10.1 36.14,195.17 ; UCE10.1 37.08,194.23 ; UCE10.1 36.14,193.29 ; UCE10.1 35.2,194.23 ; J10.31 17.23,187.71 ; J10.31 17.23,189.59 ; J10.31 18.17,188.65 ; J10.31 16.29,188.65 ; 18.91,188.65 J10.41 ; J10.41 19.85,189.59 ; J10.41 20.79,188.65
  vias: v3(34.54,193.55) v3(34.54,192.53) v3(34.54,191.52) v3(35.56,192.15)
+VCC_USB2_1: length 4.7
  TOP w0.635: 12.99,208.73 J9.U1 12.05,209.67 ; J9.U5 14.67,209.67 ; J9.U5 13.73,208.73 ; J9.U5 15.61,208.73
+VCC_USB3_1: length 4.3
  BOTTOM w0.635: 9.79,132.65 J133.11 ; J133.11 10.64,133.5 ; J133.11 10.64,131.8 ; 13.84,133.5 J133.21 13.84,131.8
  vias: v1(10.13,142.27) v1(10.16,143) v1(10.9,142.98) v1(10.87,142.24) v1(10.92,135.89) v1(10.92,135.13) v1(11.18,137.92) v1(11.68,136.27) v1(11.68,135.51) v1(11.68,134.75) v2(11.48,141.6)
+VCC_USB3_2: length 2.2
  BOTTOM w0.635: J133.31 17.04,133.68 ; 20.24,133.81 20.24,133.8 J133.41
  vias: v1(20.93,137.29) v1(21.39,138.23) v1(21.69,137.29) v1(22.43,137.26) v2(17.22,138.43)
+VCC_USB3_3: length 10.7
  TOP w0.635: UCE12.1 226.17,128.05 ; UCE12.1 227.06,127.16 ; UCE12.1 225.28,127.16 ; UCE12.1 226.17,126.27 ; P150.19 237.13,119.04 ; P150.19 238.01,118.15 ; P150.19 237.13,117.26 ; P150.19 236.24,118.15 ; P150.18 238.24,120.15 ; P150.18 240.01,120.15 ; P150.18 239.12,121.04 ; P150.18 239.12,119.26
+VCCGT: length 103.6
  TOP w0.254: PR623.2 83.35,229.59 86.75,229.59 88.14,228.21 v1(88.14,227.66)
  TOP w0.889: 113.31,203.86 PCE6208.1 ; PCE6208.1 111.43,203.86 ; PCE6208.1 112.37,204.79 ; PCE6208.1 112.37,202.92 ; 105.84,203.86 PCE6207.1 ; PCE6207.1 104.9,202.92 ; PCE6207.1 103.96,203.86 ; PCE6207.1 104.9,204.79 ; PL611.2 101.56,212.87 ; PL611.2 102.87,214.78 ; PL611.2 103.69,211.97 ; PL611.2 105,213.88 ; PCE6209.1 118.9,203.86 ; PCE6209.1 120.78,203.86 ; PCE6209.1 119.84,204.79 ; PCE6209.1 119.84,202.92 ; 98.37,203.86 PCE6206.1 ; PCE6206.1 96.49,203.86 ; PCE6206.1 97.43,202.92 ; PCE6206.1 97.43,204.79 ; PL612.2 126.71,213.88 ; PL612.2 125.41,211.97 ; PL612.2 123.28,212.87 ; PL612.2 124.58,214.78 ; 126.42,203.86 PCE6210.1 ; PCE6210.1 128.3,203.86 ; PCE6210.1 127.36,204.79 ; PCE6210.1 127.36,202.92
  BOTTOM w0.127: 115.62,174.02 116.05,174.02 ; 116.31,174.22 116.31,174.73 ; 115.57,175.84 116.1,175.84 ; 114.48,174.24 114.48,174.73 ; 117.45,173.08 117.91,173.08 ; 113.56,175.11 113.56,175.64 ; 115.39,173.76 115.39,173.33 ; 116.54,173.99 117.02,173.99 ; 114.71,174.93 115.19,174.93 ; 115.39,175.13 115.39,175.62 ; 118.14,172.87 118.14,172.39 ; 117.22,173.79 117.22,173.3
  BOTTOM w0.254: v1(88.14,227.66) 88.14,227.62 91.88,223.88 91.88,219.68 95.63,215.93 95.63,205.67 96.47,204.83
  BOTTOM w0.635: PL612.2 124.56,214.86
  BOTTOM w0.889: PL611.2 105.35,213.38 ; PL611.2 103.72,211.89 ; PL611.2 101.48,212.85 ; PCE6207.1 104.9,204.88 ; PCE6207.1 105.93,203.86 ; PCE6207.1 103.87,203.86 ; PCE6207.1 104.9,202.83 ; PCE6208.1 111.34,203.86 ; PCE6208.1 112.37,202.83 ; PCE6208.1 113.4,203.86 ; PCE6208.1 112.37,204.88 ; PCE6210.1 127.36,204.88 ; PCE6210.1 128.38,203.86 ; PCE6210.1 126.33,203.86 ; PCE6210.1 127.36,202.83 ; 96.41,203.86 PCE6206.1 ; PCE6206.1 98.46,203.86 ; PCE6206.1 97.43,204.88 ; PCE6206.1 97.43,202.83 ; 123.19,212.85 PL612.2 ; PL612.2 125.43,211.89 ; PL612.2 127.02,213.38 ; 120.87,203.86 PCE6209.1 ; PCE6209.1 119.84,204.88 ; PCE6209.1 119.84,202.83 ; PCE6209.1 118.81,203.86
  vias: v1(101.65,202.54) v1(102.41,200.51) v1(102.41,199.69) v1(102.46,201.6) v1(109.4,202.62) v1(109.42,199.03) v1(110.13,200.13) v1(110.19,201.52) v1(113.16,179.02) v1(114.02,177.16) v1(114.94,180.83) v1(114.94,179.02) v1(114.94,177.2) v1(116.76,180.8) v1(116.79,178.99) v1(116.77,177.21) v1(116.89,202.62) v1(117.65,201.55) v1(117.68,200.51) v1(117.65,199.64) v1(118.59,180.81) v1(118.62,179.01) v1(118.6,177.23) v1(120.43,180.79) v1(120.44,177.2) v1(120.46,178.98) v1(122.26,180.79) v1(122.29,178.98) v1(122.27,177.2) v1(122.79,171.4) v1(122.79,170.76) v1(122.79,169.3) v1(122.79,168.67) v1(122.79,168.03) v1(124.03,199.11) v1(124.09,178.99) v1(124.1,177.18) v1(124.05,173.56) v1(124.13,171.42) v1(124.13,170.79) v1(124.13,169.3) v1(124.13,168.67) v1(124.13,168.03) v1(124.23,180.7) v1(124.92,202.08) v1(124.92,200.36) v1(124.99,201.27) v1(125.95,177.15) v1(126.81,174.48) v1(128.14,171.42) v1(128.14,170.76) v1(128.14,169.98) v1(128.14,169.34) v1(128.14,168.63) v1(128.14,167.94) v1(129.46,171.42) v1(129.46,170.69) v1(129.46,170) v1(129.46,169.37) v1(129.46,168.58) v1(129.46,167.87) v2(128.4,210.31) v3(98.3,200.41) v3(99.06,198.25) v3(99.44,206.88) v3(100.58,213.11) v3(100.58,204.34) v3(101.22,196.47) v3(101.47,207.26) v3(101.85,198.63) v3(102.74,202.95) v3(102.87,194.56) v3(103.63,200.03) v3(103.76,191.64) v3(104.52,189.99) v3(104.65,210.19) v3(104.65,198.5) v3(104.9,195.71) v3(104.9,193.17) v3(106.81,201.17) v3(107.31,191.52) v3(107.52,204.88) v3(107.57,194.18) v3(107.95,207.39) v3(107.95,197.1) v3(109.86,205.61) v3(110.36,198.88) v3(110.49,195.45) v3(110.62,192.41) v3(110.87,202.06) v3(111.25,186.31) v3(112.01,189.36) v3(112.65,183.77) v3(113.28,200.15) v3(113.28,196.98) v3(113.54,194.06) v3(113.67,191.52) v3(113.79,185.29) v3(115.32,203.96) v3(116.2,183.9) v3(116.28,189.1) v3(116.41,195.2) v3(116.36,186.49) v3(116.54,192.15) v3(116.71,206.88) v3(117.3,198.22) v3(118.49,201.68) v3(118.49,191.01) v3(118.75,196.85) v3(118.87,188.21) v3(119.13,185.17) v3(119.25,211.07) v3(120.4,198.88) v3(120.52,195.45) v3(120.65,192.41) v3(121.16,189.87) v3(121.28,202.31) v3(121.28,186.44) v3(121.28,183.9) v3(121.67,212.98) v3(123.7,206.38) v3(124.71,203.58) v3(125.98,201.93) v3(127.64,211.33) v3(128.52,208.15)
+VCCGT_SENSE+_A: length 66.3
  TOP w0.254: PR5848.1 82.21,226.86 82.55,227.2 82.55,227.95 PR623.1 83.68,229.08 86.28,229.08 87.31,228.05 v1(87.31,227.67) ; v1(96.8,197.21) 96.8,195.83 104.09,188.54 104.09,186.18 105,185.27 105.01,185.26 105.45,184.82 105.45,184.82 106.5,183.77 108.84,183.77 109.47,183.13 v1(109.47,182.75)
  BOTTOM w0.254: v1(87.31,227.67) 88.62,226.36 88.62,225.53 v2(88.77,225.37) 89.13,225.02 89.13,223.93 91.39,221.67 91.39,219.41 95.12,215.67 95.12,203.28 96.71,201.69 96.71,197.29 v1(96.8,197.21) ; 111.93,181.27 111.46,181.74 110.87,181.74 110.58,182.03 110.07,182.03 109.47,182.63 v1(109.47,182.75)
+VCCGT_SENSE-_A: length 68.5
  TOP w0.203: PU581.32 80.24,222.12
  TOP w0.254: v1(108.78,182.7) 108.78,183.06 108.58,183.26 106.29,183.26 103.58,185.97 103.58,188.29 96.14,195.73 v1(96.14,196.7) ; v1(86.51,227.66) 86.51,227.68 85.74,228.46 85.04,228.46 PR624.1 84.07,227.5 84.07,227.08 83.65,226.66 83.65,226.17 PC5820.1 82.72,225.23 PC5824.2 82.07,224.15 82.07,224.09 80.24,222.26 80.24,222.12
  BOTTOM w0.254: v1(96.14,196.7) 96.14,201.5 94.61,203.02 94.61,215.46 90.81,219.27 90.81,221.69 88.54,223.95 88.54,224.59 88.01,225.12 88.01,226.16 v2(87.55,226.62) 86.89,227.28 86.89,227.28 v1(86.51,227.66) ; v1(108.78,182.7) 109.87,181.61 110.01,181.61 PJP624.1
+VCCPGPP_EFG: length 20
  TOP w0.102: PCH.AM41 180.01,46.89 180.45,46.89 180.69,47.13
  TOP w0.152: PCH.AE41 179.47,49.97 179.14,50.3 178.85,50.3 178.66,50.1 178.66,48.67 PCH.AK41 180.25,47.58 180.69,47.13
  TOP w0.216: v1(190.42,46.74) 190.42,47.21 SCB7.1 191.83,48.04 191.86,48.07 SR54.1 ; 180.69,47.13 180.96,46.86 182.93,46.86 v1(183.64,46.15)
  BOTTOM w0.254: v1(183.64,46.15) 184.05,46.56 v2(187.91,46.56) 190.25,46.56 v1(190.42,46.74)
+VCCPRIM_1P0_5&9: length 33.7
  TOP w0.254: v1(168.11,50.29) 167.72,50.67 PCH.AD17 ; PCH.AE16 167.11,50.57 v1(167.18,50.65)
  TOP w0.457: v3(187.87,64.83) 188.81,65.77 188.81,67.63 189.07,67.88 SR12.2
  BOTTOM w0.457: 168.17,50.85 168.17,52.76 169.21,53.8 174.04,53.8 174.84,54.6 176.4,54.6 177.04,55.24 177.04,57.25 177.47,57.68 178.05,57.68 178.46,58.09 181.28,58.09 183.77,60.58 v2(183.77,60.96) 183.77,61.2 184.52,61.95 184.99,61.95 v3(187.87,64.83)
+VDD: length 71.2
  TOP w0.254: UCC5.1 117.69,30.64 v1(117.69,31.67)
  TOP w0.279: UCC5.1 116.92,30.26 U15.36 ; v1(107.01,31.44) 107.11,31.34 UCC4.1 107.75,31.34 108.36,31.95 108.36,32.41 109.21,33.27 U15.24 ; U15.48 119.78,38.77 UCC6.1 120.24,38.89 120.34,38.98 UCC8.1 ; U15.1 116.92,40.82 117.36,41.26 118.56,41.26 118.7,41.4 UCC7.1
  TOP w0.305: UCC7.1 119,40.89 119.04,40.85
  TOP w0.508: UCR26.2 120.34,41.21 121.03,41.91 v1(121.03,42.19) ; UCR26.2 UCC8.1 ; UCR26.2 119.2,40.69 119.04,40.85 ; v1(107.24,42.47) 107.34,42.57 UCR27.1 ; v1(103.23,43.26) 99.2,39.22 v1(99.2,31.19)
  BOTTOM w0.381: v2(107.73,31.47) 108.18,31.93 112.42,31.93 113.1,31.24 117.26,31.24 v1(117.69,31.67)
  BOTTOM w0.508: v1(99.2,31.19) 99.2,31.26 99.85,31.91 105.66,31.91 106.13,31.44 v1(107.01,31.44) 107.69,31.44 v2(107.73,31.47) ; v1(103.23,43.26) 103.74,42.75 105.01,42.75 105.3,42.47 v1(107.24,42.47) 108.24,42.47 109.12,41.59 119.8,41.59 120.4,42.19 v1(121.03,42.19)
+VDDA: length 7.4
  TOP w0.279: U15.9 112.92,41.19 112.65,41.47 111.96,41.47
  TOP w0.381: 111.96,41.47 UCC10.1 110.43,41.1 UCC9.1
  TOP w0.508: UCR27.2 v1(110.02,42.57) 110.04,42.55 UCC9.1
  BOTTOM w0.254: v2(109.24,42.57) v1(110.02,42.57)
+VDDQ_SN: length 0.8
  BOTTOM w0.102: v2(209.42,199.26) v1(208.64,199.26)
AGND: length 190.1
  TOP w0.254: v1(15.75,8.38) AU1.42 ; AU1.26 12.61,17.82 v1(12.85,18.06)
  TOP w0.305: AQ17.1 v1(8.12,57.77) ; AQ1.4 v1(15.38,63.51) ; AQ2.1 v1(10.78,63.51) ; v1(12.05,59.76) 11.92,59.63 AQ18.4 ; AQ17.4 5.16,59.07 v1(6.07,58.16) ; AQ1.1 17.34,62.22 17.6,61.95 v1(17.6,61.7) ; AQ2.4 v1(13.1,62.22) ; AQ16.1 v1(8.4,62.22) ; AQ16.4 v1(6.11,63.51)
  TOP w0.381: AC74.2 26.81,6.53 v1(26.76,6.48) ; v1(15.24,57.28) 14.69,57.83 AQ18.1 ; v1(20.75,10.34) 20.68,10.34 20.28,10.74 AC73.1
  TOP w0.457: AR23.1 20.15,28.38 v1(20.02,28.52) ; AR220.2 v1(8.69,66.29) ; v1(18.4,89.15) 18.6,88.95 AC180.2 ; v1(15.73,68.69) 15.83,68.58 AC177.2 ; AD18.2 14.06,70.19 v1(14.22,70.36) ; v1(6.78,87.18) 6.64,87.32 AC183.2 ; v1(15.41,66.29) AR205.2 ; v1(8.05,89.86) 8.67,89.86 AR225.2 ; v1(16.19,89.4) 16.59,89 AC179.2 ; AC178.2 v1(13.39,68.58) ; v1(17.58,66.04) 17.33,66.29 AR206.2 ; v1(17.53,71.78) 17.53,71.21 AC26.1 ; v1(17.57,57.25) 17.57,57.87 AC55.1 ; HC31.2 v1(6.81,42.2) ; AC174.2 v1(4.13,68.58) ; AC173.2 v1(6.44,68.58) ; v1(13.18,66.29) AR224.2 ; AR222.2 10.82,66.29 v1(11,66.11) ; v1(30.61,10.54) 30.95,10.88 AC25.1 ; AR226.2 13.12,87.35 v1(13.1,87.38) ; v1(34.04,10.16) 34.04,10.76 AR231.1 ; AC24.1 v1(29.72,10.22) ; v1(10.33,90.8) 10.11,90.59 AC182.2 ; v1(37.55,7.06) AC77.2 ; AC175.2 v1(8.74,68.58) ; HC30.2 v1(12.55,71.77) ; AC52.1 17.53,74.84 v1(17.53,74.22) ; AR232.1 17.55,76.39 v1(17.55,75.79) ; AD16.2 v1(11.3,69.6) ; AC27.1 19.01,35.53 v1(18.99,35.56) ; v1(11.52,87.39) AC181.2 ; AC76.2 v1(34.12,6.86)
  TOP w0.508: v1(18.82,90.72) 18.99,90.55 AD3.2 ; AD5.2 10.84,88.83 v1(10.84,88.05) ; AD19.2 v1(17.03,90.72) ; AC176.2 v1(11.05,68.58) ; v1(6.72,70.35) 6.72,69.85 AD13.2 ; AD6.2 v1(6.29,90.78) ; v1(4.83,70.48) 4.95,70.61 4.95,70.74 5.46,71.25 AC184.2 ; v1(8.65,69.45) 8.8,69.6 AD15.2 ; AR10.2 22.42,9.93 v1(22.28,9.93) ; v1(15.69,70.28) AD17.2 ; AD4.2 12.19,90.45 v1(11.78,90.86) ; v1(17.53,82.98) 17.83,82.68 AC130.1 ; v1(6.43,65.91) 6.05,66.29 AR221.2 ; AR9.2 v1(28.32,6.86) ; AD14.2 v1(4.06,69.6) ; v1(32.64,6.99) 32.51,7.11 31.62,7.11 31.28,7.45 AC75.2 ; v1(4.06,70.48) 4.06,71.06 AD7.2
  TOP w0.635: 5.18,115.09 J83.68 ; J83.68 3.36,113.27 ; J83.68 1.54,115.09 ; J83.64 7.16,112.53 ; J83.64 7.16,110.57 ; J83.64 6.18,111.55 ; J83.64 8.14,111.55 ; ACE3.2 17.42,4.75 ; ACE3.2 15.69,4.75 ; ACE3.2 16.56,3.89 ; ACE3.2 16.56,5.61 ; 8.14,109.05 J83.41 ; J83.41 7.16,108.07 ; J83.41 6.18,109.05 ; J83.41 7.16,110.03 ; 14.66,113.27 J83.66 ; J83.66 12.84,115.09 ; J83.66 16.48,115.09 ; J83.44 17.16,111.25 ; J83.44 18.11,110.3 ; J83.44 17.16,109.35 ; J83.44 16.21,110.3 ; 29.29,5.59 P23.7 ; P23.7 31.42,5.59 ; P23.7 30.35,4.52 ; 1.54,91.01 J83.69 3.36,92.82
  IN1 w0.635: 11.28,110.3 J83.54 ; J83.54 12.16,109.42 ; J83.54 13.04,110.3 ; J83.54 12.16,111.17 ; J83.67 12.84,91.01 ; J83.67 14.66,89.19 ; J83.67 14.66,92.82 ; J83.67 16.48,91.01 ; J83.64 8.06,111.55 ; J83.64 6.26,111.55 ; J83.64 7.16,110.65 ; J83.64 7.16,112.45 ; 7.16,108.15 J83.41 ; J83.41 8.06,109.05 ; J83.41 6.26,109.05 ; J83.41 7.16,109.95 ; 16.28,110.3 J83.44 ; J83.44 17.16,109.42 ; J83.44 17.16,111.17 ; J83.44 18.04,110.3 ; 1.62,91.01 J83.69 ; J83.69 3.36,89.27 ; J83.69 3.36,92.75 ; J83.69 5.1,91.01 ; 6.26,97.05 J83.1 ; J83.1 7.16,97.95 ; J83.1 8.06,97.05 ; J83.1 7.16,96.15 ; J83.66 16.4,115.09 ; J83.66 14.66,113.35 ; J83.66 12.92,115.09 ; 7.16,98.65 J83.4 ; J83.4 8.06,99.55 ; J83.4 7.16,100.45 ; J83.4 6.26,99.55 ; P23.7 30.35,6.65 ; P23.7 31.42,5.59 ; P23.7 30.35,4.52 ; P23.7 29.29,5.59 ; ACE3.2 16.56,5.61 ; ACE3.2 17.42,4.75 ; ACE3.2 16.56,3.89 ; ACE3.2 15.69,4.75 ; J83.68 5.1,115.09 ; J83.68 3.36,113.35 ; J83.68 1.62,115.09 ; J83.24 12.16,99.17 ; J83.24 11.28,98.3 ; J83.24 13.04,98.3 ; J83.24 12.16,97.42 ; J83.34 17.16,99.17 ; J83.34 16.28,98.3 ; J83.34 17.16,97.42 ; J83.34 18.04,98.3 ; P23.2 37.97,4.11
  BOTTOM w0.635: J83.41 7.16,110.11 ; J83.41 6.09,109.05 ; J83.41 8.23,109.05 ; J83.41 7.16,107.98 ; 7.16,112.61 J83.64 ; J83.64 6.09,111.55 ; J83.64 7.16,110.48 ; J83.64 8.23,111.55 ; 29.27,5.59 P23.7 ; P23.7 31.43,5.59 ; P23.7 30.35,4.51 ; P23.7 30.35,6.74 ; 14.66,113.18 J83.66 12.76,115.09 ; 7.16,100.61 J83.4 ; 3.36,113.18 J83.68 5.27,115.09 ; 13.2,110.3 J83.54 ; J83.54 11.12,110.3 ; J83.54 12.16,109.26 ; J83.54 12.16,111.34 ; J83.24 12.16,99.34 ; 17.16,97.22 J83.34 ; J83.34 15.44,98.3 ; J83.34 17.16,99.43 ; J83.44 17.16,111.34 ; J83.44 16.12,110.3 ; J83.44 18.2,110.3 ; J83.44 17.16,109.26 ; J83.1 7.16,98.11
  vias: v1(0.81,116.36) v1(0.84,113.84) v1(0.84,111.3) v1(0.84,108.76) v1(0.84,106.22) v1(0.84,103.68) v1(0.84,101.14) v1(0.84,98.6) v1(0.84,96.06) v1(0.84,93.52) v1(0.84,90.98) v1(0.84,88.44) v1(0.84,85.9) v1(0.84,83.36) v1(0.84,80.82) v1(0.84,78.28) v1(0.84,75.74) v1(0.84,73.2) v1(0.84,70.66) v1(0.84,68.12) v1(0.84,65.58) v1(0.84,63.04) v1(0.84,60.5) v1(0.84,57.96) v1(0.84,55.42) v1(0.84,52.88) v1(0.84,50.34) v1(0.84,47.8) v1(0.84,45.26) v1(0.84,42.72) v1(0.84,40.18) v1(0.84,37.64) v1(0.84,35.1) v1(0.84,32.56) v1(0.84,30.02) v1(0.84,27.48) v1(0.84,24.94) v1(0.84,22.4) v1(0.84,19.86) v1(0.84,17.32) v1(0.82,14.82) v1(0.82,12.25) v1(0.84,9.7) v1(0.84,7.16) v1(0.84,4.62) v1(1.24,2.51) v1(2.54,97.02) v1(2.61,101.95) v1(2.57,99.39) v1(2.69,108.88) v1(2.69,106.73) v1(2.8,111) v1(2.8,104.25) v1(2.93,18.25) v1(3.02,1.02) v1(3.13,6.48) v1(3.96,103.11) v1(4.01,100.54) v1(4.01,98.32) v1(3.96,96.17) v1(4.1,107.87) v1(4.09,105.62) v1(4.16,112.07) v1(4.16,110.06) v1(5.08,0.84) v1(5.91,3) v1(7.24,116.2) v1(7.62,0.84) v1(8.74,112.32) v1(8.77,110.18) v1(8.83,108.27) v1(10.16,0.84) v1(12.7,0.84) v1(15.08,110.6) v1(15.14,97.24) v1(15.18,100.02) v1(15.24,0.84) v1(15.53,112.42) v1(15.53,108.86) v1(16.09,2.7) v1(17.78,0.84) v1(18.67,2.56) v1(20.32,0.84) v1(21.24,2.12) v1(22.86,0.84) v1(23.74,2.12) v1(25.4,0.84) v1(26.06,2.18) v1(27.94,0.84) v1(29.08,6.48) v1(30.26,3.89) v1(30.48,0.84) v1(31.16,2.12) v1(31.65,3.95) v1(33.02,0.84) v1(39.52,7.39) v2(10.19,115.98)
GND: length 4978.8
  TOP w0.089: 178.7,63.88 179.91,65.08 v1(179.91,65.91) ; 177.39,62.57 177.39,61.85 177.49,61.75 177.49,61.52 177.46,61.42 177.46,61.3 177.5,61.26 177.5,61.09
  TOP w0.102: v1(159.91,55.7) 159.63,55.99 158.31,55.99 158.04,55.71 v1(158.04,55.3) ; v1(127.33,63.8) 126.85,63.32 125.83,63.32 v1(125.35,63.8) ; v1(184.48,71.54) 184.34,71.68 184.34,72.25 184.61,72.52 185.72,72.52 v1(186.11,72.14) ; v1(14,145.77) 14.47,146.25 14.47,147.42 v1(14.61,147.55) ; v1(161.37,62.76) 161.29,62.69 159.33,62.69 158.88,62.23 154.81,62.23 v1(154.7,62.34) ; v1(140.26,112.08) 140.09,111.9 139.26,111.9 138.56,112.6 138.56,112.99 v1(138.75,113.18) ; v1(147.73,110.29) 147.29,109.86 147.29,108.81 v1(147.78,108.33) ; v1(150.22,82.22) 150.88,82.89 v1(152,82.89) 152.22,82.67 v1(152.22,82.19) ; v1(39.5,127.14) 38.14,127.14 v1(37.74,127.53) ; v1(140.67,111.43) v1(141.91,111.43) 142.04,111.3 142.61,111.3 v1(142.98,111.66) 143.44,112.12 143.44,113.18 v1(143,113.61) ; 176.56,62.41 176.56,62.61 178.99,65.05 v1(178.99,67.03) ; v1(145.92,112.77) 146.38,112.31 146.38,111.25 145.95,110.82 v1(145.8,110.82) ; v1(175.82,91.36) 175.82,92.07 175.12,92.76 v1(174.47,92.76) ; 177.5,61.04 177.5,61.09 ; v1(147.32,112.52) 147.08,112.28 147.08,111.71 147.39,111.4 148.51,111.4 v1(148.87,111.76) 149.18,111.45 v1(149.18,109.91) 149.18,109.06 149.63,108.61 v1(149.96,108.61) 150.44,108.61 v1(150.98,109.14) ; v1(172.31,74.45) 172.31,75.08 173.02,75.79 173.71,75.79 v1(173.79,75.72) ; v1(158.43,70.52) 157.91,70 157.02,70 v1(156.52,70.5) ; v1(144.48,111.28) 144.93,111.73 144.93,112.77 v1(144.46,113.24) ; v1(184.96,81.08) 184.96,80.26 184.84,80.14 184.84,78.94 v1(185.27,78.51) v1(185.95,78.51) ; 190.21,170.01 v1(190.12,170.1) ; 177.39,62.57 178.7,63.88 ; 142.75,96.62 v1(142.77,96.6) 143.1,96.27 144.4,96.27 144.6,96.47 154.05,96.47 155.78,98.2 v1(155.78,98.48) 155.78,98.6 155.32,99.06 154.05,99.06 153.67,98.68 153.67,98.04 153.03,97.41 144.78,97.41 144.06,98.13 143.54,98.13 142.75,97.34 142.75,96.62 ; 227.28,70.38 v1(227.13,70.54) 226.75,70.54 224.64,68.43 224.64,53.39 v1(223.63,52.39) 223.39,52.39 222.44,51.44 222.44,50.68 222.83,50.3 223.37,50.3 v1(223.62,50.55) 225.65,52.58 225.65,67.49 227.28,69.11 227.28,70.38
  TOP w0.108: XU1.AN7 136.43,148.01 ; v1(127.66,144.81) 127.66,144.78
  TOP w0.127: v1(181.95,82.49) 182.42,82.97 182.42,83.34 182.02,83.74 v1(181.66,83.74) ; v1(33.07,219.23) 33.07,219.53 31.37,221.23 28.68,221.23 28.3,221.62 v1(28.3,222.1) 28.3,222.76 28.88,223.34 28.88,226.49 29.59,227.2 30.84,227.2 v1(31.11,226.92) 31.34,226.69 33.05,226.69 33.48,226.26 v1(33.48,225.65) 33.73,225.4 33.73,223.88 33.35,223.49 33.35,220.68 v1(34.32,219.71) ; v1(183.39,82.83) 183.54,82.68 184.33,82.68 v1(184.58,82.93) 184.58,83.62 183.85,84.35 v1(183.36,84.35) ; v1(87.83,76.53) 87.42,76.95 86.32,76.95 v1(85.88,76.5) v1(84.89,76.5) 84.63,76.76 82.63,76.76 v1(82.17,76.3) 81.76,76.71 80.64,76.71 v1(80.19,76.25) v1(79.07,76.25) 78.69,76.63 77.52,76.63 v1(77.09,76.2) ; v1(184.96,81.08) 184.96,81.51 184.61,81.86 183.66,81.86 182.48,80.69 v1(182.48,80.2) ; v1(149.62,85.64) 149.99,85.27 149.99,84.78 149.11,83.9 148.66,83.9 v1(148.58,83.98) ; v1(181.18,86.33) 181.28,86.44 181.91,86.44 182.17,86.18 182.17,85.15 181.9,84.88 181.34,84.88 v1(181.15,85.06) ; PCH.BC9 163.52,41.28 v1(163.27,41.53) ; v1(67.56,69.48) 68.53,70.44 68.53,74.96 67.69,75.79 65.58,75.79 65.13,75.34 65.13,70.56 63.6,69.03 v1(63.6,68.78) 63.93,68.45 65.37,68.45 65.76,68.84 v1(65.76,69.32) 66.02,69.32 66.17,69.48 v1(67.56,69.48) ; 211.2,76.2 211.2,77.34 211.54,77.69 211.54,87.73 210.4,88.87 210.4,94.39 211.27,95.25 v1(212.14,95.25) 212.34,95.05 212.34,94.44 211.15,93.24 211.15,89.18 212.34,87.99 212.34,78.11 v1(212.85,77.6) 212.85,76.83 211.96,75.95 v1(211.46,75.95) 211.2,76.2
  TOP w0.152: v1(173.2,38.73) 173.09,38.84 PCH.BG28 ; PCH.AD45 182.2,50.68 v1(182.27,50.75) ; v1(159.91,55.7) 160,55.62 PCH.R1 ; 177.67,52.07 178.23,51.51 PCH.AC38 ; PCH.BG37 177.67,39.1 178.18,38.59 v1(178.18,38.38) ; PCH.A25 172.01,61.96 172.01,61.51 PCH.B25 ; v1(149.66,90.04) 149.16,89.55 147.53,89.55 ; v1(159.49,43.85) PCH.AV1
  TOP w0.178: v1(214.17,39.32) 214.17,39.32 214.14,39.36 U104.83 ; v1(214.17,39.32) 213.21,39.32 212.94,39.59 U104.86 ; v1(214.17,39.32) 214.54,39.69 U104.82 ; v1(209.74,25.98) U104.3 ; v1(215.9,26.06) 215.74,25.9 U104.18 ; v1(221.34,36.47) 221.7,36.84 U104.59 ; U104.66 220.94,39.05 220.39,38.49 v1(220.39,38.02) ; v1(210.99,41.88) 211.34,41.53 U104.90 ; U104.35 222.19,27.24 v1(221.79,27.64) ; v1(208.94,26.01) U104.1 ; v1(221.79,29.24) U104.40 ; v1(208.46,30.84) U104.117
  TOP w0.203: PCH.AD25 171.6,50.67 v1(171.99,51.06) 171.6,51.45 PCH.AB25 ; PCH.AJ1 159.45,48.39 v1(159.4,48.34) ; PCH.AK39 v1(178.55,48.02) ; v1(162.4,41.28) 162.4,41.25 PCH.BD7 162.77,40.6 162.11,39.94 PCH.BF5 ; PCH.BD21 169.59,41.55 v1(169.7,41.66) ; PCH.H19 168.94,58.49 PCH.H17 ; v1(158.95,50.5) 159.12,50.67 PCH.AD1 ; v1(17.68,145.26) 17.4,145.55 U5.25 ; PCH.BG9 163.87,39.26 163.87,39.05 163.18,38.35 v1(163.18,38) ; PCH.AP39 v1(179.32,45.08) 179.94,45.08 PCH.AT42 ; PCH.K45 181.89,57.76 v1(183.06,57.76) ; v1(215.17,26.01) 215.34,25.83 U104.17 ; PU581.44 75.62,221.13 75.21,221.54 v1(75.21,221.82) ; PCH.W45 182.1,52.95 v1(182.32,53.17) ; v1(166.19,60.3) 166.47,60.3 PCH.D15 166.85,60.47 PCH.D16 ; PCH.AL42 179.63,47.17 v1(179.57,47.11) ; PCH.BD11 165.04,41.07 165.13,41.15 v1(165.13,41.63) ; v1(212.33,41.68) 212.32,41.68 212.29,41.71 212.22,41.71 212.14,41.63 U104.88 ; PCH.AV15 166.72,43.55 166.34,43.17 166.34,42.8 PCH.BA13 ; PCH.AY4 161.79,42.81 v1(161.98,42.62) 161.62,42.26 PCH.BA4 ; v1(174.18,60.97) 174.31,61.1 PCH.B30 PCH.A30 ; v1(182.46,48.52) 182.35,48.41 PCH.AJ45 ; PU581.56 75.66,216.33 75.23,215.9 v1(75.23,215.77) ; v1(166.28,38.38) PCH.BG14 ; v1(175.67,38.81) 175.37,39.11 PCH.BG32 ; PCH.BG23 170.82,37.52 v1(170.66,37.36) ; PCH.AN45 182.21,46.13 v1(182.22,46.12) ; v1(147.22,60.99) 147.22,60.72 147.52,60.42 150.77,60.42 v1(150.93,60.58) ; PCH.BG18 v1(168.55,38.85) ; PCH.AA28 v1(173.53,51.84) ; PCH.AV45 182,43.86 v1(182.14,44) ; 177.83,41.76 177,41.76 176.63,41.39 176.63,41.09 PCH.BD34
  TOP w0.229: U5.4 v1(21.64,147.76) ; XU1.E13 110.36,153.04 109.68,153.04 109.45,152.81 v1(109.45,152.21) ; PU581.16 82.07,216.33 v1(82.4,216) ; v1(81.99,221.69) 81.99,221.69 81.99,221.36 81.76,221.13 PU581.28 ; 164.42,43.34 164.75,43.02 PCH.AY11 ; U10.27 v1(35.58,212.5) ; v1(16.83,150.51) 17.4,149.95 U5.16
  TOP w0.254: v1(110.77,182.49) 110.77,181.84 110.82,181.78 XU1.D40 XU1.D39 ; v1(143.5,148.01) XU1.AY7 ; v1(35,136.53) 35,136.6 34.62,136.98 33.83,136.98 33.65,137.16 v1(33.65,138.28) ; v1(159.33,60.2) 158.83,60.71 153.97,60.71 v1(153.82,60.86) 153.26,60.86 152.98,60.58 v1(150.93,60.58) ; C93.2 138.64,15.15 v1(138.91,14.87) ; XU1.AW3 XU1.AY3 142.83,144.34 v1(143.3,143.87) ; UU53.8 UU53.3 v1(23.09,129.11) ; PC5814.2 91.25,222.97 v1(91.31,222.97) ; v1(7.49,153.59) 7.82,153.26 UU52.3 UU52.8 ; v1(113.11,153.95) 113.11,154.88 XU1.G15 ; J_TYPEC.A12 J_TYPEC.B1 5.01,143.68 v1(4.47,143.14) ; XU1.C8 109.44,149.37 109.44,150.31 XU1.C10 ; v1(179.43,49.45) PCH.AF42 ; v1(117.75,29.56) UCC5.2 ; XU1.AV2 140.81,143.44 140.35,143.9 139.66,143.9 v1(139.63,143.93) ; PR622.2 84.09,206.39 83.57,205.87 v1(82.22,205.87) ; v1(109.45,157.54) 109.51,157.6 110.38,157.6 XU1.E17 111.27,156.71 112.21,156.71 XU1.G17 113.12,156.69 114.04,156.69 XU1.J16 ; v1(75.21,229.13) 75.36,228.98 PC5808.2 ; v1(27.23,211.73) M1U9.3 M1U9.8 ; J_TYPEC.A1 J_TYPEC.B12 5,149.18 4.7,149.48 v1(4.32,149.48) ; v1(11.46,144.98) UU34.8 UU34.3 ; v1(149.66,90.04) 149.66,90.05 148.88,90.83 147.36,90.83 140.16,83.63 140.16,75.03 128.37,63.25 v1(128.37,61.7) 128.37,61.51 128.78,61.1 129.98,61.1 130.44,61.57 v1(130.44,62.08) 130.44,64.03 141.27,74.86 141.27,83.3 147.53,89.55 ; v1(156.49,34.14) 156.06,33.71 156.06,32.28 151.99,28.22 151.23,28.22 150.83,28.63 v1(149.28,28.63) 149.17,28.73 143.13,28.73 143.04,28.83 v1(143.04,29.36) 143.04,31.12 143.14,31.22 143.89,31.22 143.91,31.24 145.69,31.24 145.78,31.33 v1(146.61,31.33) 150.74,31.33 v1(151.11,31.7) 152.12,32.71 153.54,32.71 154.15,33.32 v1(154.33,33.32) ; v1(226.29,103.99) 226.58,103.69 U51.14 ; PCH.A30 174.31,63.7 v1(174.55,63.93) ; UU14.3 UU14.8 25.04,125.55 v1(25.22,125.73) ; v1(114.19,42.71) 114.19,45.65 113.59,46.25 v1(113.59,46.62) 113.59,46.65 114.24,47.3 118.32,47.3 119.16,46.45 v1(119.16,45.63) 119.16,45.02 119.29,44.89 119.29,44.16 118.85,43.71 v1(118.85,42.7) ; PR624.2 86.25,227.1 88.37,227.1 v1(88.9,227.63) ; XU1.F36 v1(113.08,177.16) ; XU1.E21 110.39,161.25 v1(110.39,161.26) ; v1(29.34,30.58) 29.12,30.37 AC198.2 ; XU1.AE4 128.69,145.69 128.69,145.69 v1(128.65,145.73) ; XU1.AW5 XU1.AY5 143.35,146.19 v1(143.45,146.09) ; PCH.AB42 180.52,51.72 v1(180.61,51.64) ; v1(23.11,132.26) UU40.3 UU40.8 ; PCH.W26 172.22,53.14 171.73,53.14 PCH.W25 v1(171.2,52.6) 171.2,52.62 PCH.W23 ; v1(34.87,133.83) 34.87,133.1 34.44,132.66 33.96,132.66 33.45,133.17 v1(32.97,133.17) 30.91,133.17 30.4,133.68 v1(30.4,136.37) 30.4,137.13 v1(32.6,139.33) ; XU1.E15 110.35,154.86 109.44,154.86 XU1.C14 ; XU1.G8 v1(112.18,149.4) 112.18,151.2 XU1.G11 ; v1(83.41,227.56) 83.12,227.27 PC5820.2 ; M1U8.8 M1U8.3 25.7,215.04 v1(25.53,214.86) ; U4.15 40.62,147.63 v1(40.38,147.86) ; v1(172,40.39) 172,40.73 PCH.BD25 ; AU1.7 v1(21.63,15.82) ; v1(28.78,122.1) 28.92,122.24 J60.7 ; PCH.AH38 177.8,49.33 v1(177.8,49.5) 178.23,49.93 PCH.AE38 ; PCH.AK35 177.06,47.93 v1(177.06,48.04) ; v1(134.1,61.99) 134.1,61.98 SC100.2 ; CB4127.2 v1(23.47,142.57) ; UU10.3 UU10.8 v1(9.93,150.04) ; XU1.E19 111.27,158.54 112.21,158.54 XU1.G19 ; v1(231.85,134.65) UU5.3 UU5.8 v1(234.01,134.65) ; XU1.AP40 138.26,181.04 v1(138.27,181.06) ; v1(154.7,62.34) 152.76,64.29 v1(151.97,64.29) 151.27,64.29 150.36,65.2 149.1,65.2 v1(148.59,64.69) 147.68,64.69 147.32,64.34 147.32,63.35 v1(147.19,63.22) 146.69,62.71 146.69,61.52 v1(147.22,60.99)
  TOP w0.279: XDP2.59 83.72,106.38 v1(83.26,106.38) ; PU601.6 70.29,167.78 v1(69.9,167.39) ; v1(98.48,108.03) 98.12,108.38 97.98,108.38 XDP2.14 ; M1U3.8 M1U3.3 v1(27.08,196.27) ; v1(234.37,99.82) UU26.8 UU26.3 v1(232.29,99.82) ; PU602.6 71.04,150.93 70.74,150.62 v1(70.74,150.39) ; U15.23 110.6,33.77 111.02,34.19 v1(111.02,34.88) 111.02,34.98 110.73,35.27 U15.20 ; v1(26.09,184.82) M1U5.8 M1U5.3 v1(23.85,184.82) ; v1(90.42,100.76) 89.99,100.33 89.77,100.33 XDP2.60 ; XDP2.2 100,110.61 100,110.19 v1(99.72,109.91) ; v1(90.98,107.24) 90.98,106.9 XDP2.38 ; U15.47 119.39,38.27 119.84,37.82 120.57,37.82 120.75,38 UCC6.2 ; UU44.8 UU44.3 v1(232.16,128.17) ; XDP2.19 91.83,112.41 v1(90.68,113.56) ; UU22.8 UU22.3 231.01,90.42 v1(230.7,90.73) ; v1(89.41,112.27) 89.85,112.27 XDP2.25 ; v1(88.65,111.63) 88.65,111.36 XDP2.31 ; XDP2.32 93.76,106.24 v1(92.61,107.39) ; v1(30.76,117.18) 31.28,117.18 31.67,116.79 J60.18 ; XDP2.13 v1(91.74,114.63) ; v1(89.87,108.2) 89.68,108.2 XDP2.37 ; v1(97.16,107.39) 96.85,107.39 XDP2.20 ; v1(32.64,122.15) 32.92,122.43 J60.23 ; U15.8 113.42,41.27 112.56,42.14 v1(112.56,42.21) ; v1(12.29,119.08) M1U6.3 M1U6.8 v1(10.13,119.08) ; v1(16.81,164.06) M1U1.3 M1U1.8 14.88,164.06 v1(14.73,163.9) ; XDP2.7 92.99,115.49 v1(92.74,115.49) ; v1(26.09,181.54) M1U4.8 M1U4.3 v1(23.85,181.54) ; M1U7.3 M1U7.8 v1(18.59,118.29) ; UU39.8 UU39.3 23.47,135.38 23.29,135.56 22.78,135.56 v1(22.63,135.41) ; U15.35 116.42,32.71 v1(116.34,32.79) ; XDP2.50 91.92,101.72 v1(91.92,101.06) ; v1(66.4,203.35) 66.76,203.71 PU592.6 ; PU611.6 97.2,227.21 v1(97.33,227.08) ; v1(70.18,184.63) 70.18,185.12 70.42,185.36 PU591.6 ; XDP2.49 v1(85.29,108.35) ; v1(14.71,167.67) M1U2.8 M1U2.3 v1(16.81,167.67) ; v1(96.44,106.68) 96.22,106.45 95.67,106.45 XDP2.26 ; XDP2.8 v1(99.21,109.27)
  TOP w0.305: v1(228.27,31.06) 228.24,31.04 227.63,31.04 227.33,31.34 O2CB19.2 ; v1(34.39,124.79) 34.42,124.76 J60.29 ; LCB20.2 32.6,211.2 v1(32.22,210.82) ; SS4.15 v1(224.11,12.5) ; v1(139.66,144.77) 140.09,145.19 XU1.AU4 ; v1(41.91,76.05) 42.16,76.3 XC90.2 ; v1(153.03,27.74) 152.98,27.69 SCB28.2 ; v1(232.32,120.52) UU43.3 UU43.8 ; XU1.AN4 v1(136.89,145.73) XU1.AP5 ; v1(208.47,21.74) 208.58,21.63 SCB69.1 ; UCB19.2 66.17,8.27 v1(66.18,8.27) ; v1(38.79,150.24) 38.86,150.32 UC72.2 38.86,151.57 UC971.2 ; v1(17.7,143.54) 17.83,143.54 CB4113.2 ; v1(136.51,141.89) 136.43,141.97 XU1.AN1 ; v1(23.11,18.5) 23.06,18.45 23.06,17.65 ; PC569.2 116.31,57.94 v1(116.46,58.09) ; v1(191.39,176) 191.31,176.07 D4CB74.2 ; XU1.AR5 138.26,146.16 v1(138.68,145.74) 138.26,145.31 XU1.AR4 ; v1(230.61,172.64) 230.61,172.19 EC22.2 ; v1(177.44,29.51) 177.44,29.61 SCB36.2 ; v1(117.5,58.06) 117.5,57.71 117.25,57.45 PC570.2 ; v1(222.5,12.27) 222.61,12.16 SS4.21 ; v1(137.79,144.83) 137.79,144.82 XU1.AR3 ; SS4.75 209.11,12.33 209.12,12.33 209.11,12.34 ; v1(121.59,38.51) 121.39,38.3 UCC6.2 ; D4CB70.2 190.07,149.78 v1(190.07,149.94) 190.22,149.94 D4CB77.2 ; XU1.AL2 XU1.AL1 v1(134.6,141.8) ; v1(35.92,151.89) 35.92,151.54 UC75.2 ; v1(190.07,179.6) 190.14,179.6 D4CB62.2 ; v1(140.55,147.56) 140.09,148.01 XU1.AU7 XU1.AT7 XU1.AT8 139.17,148.93 v1(139.6,149.36) 139.17,149.78 XU1.AT9 139.17,149.85 v1(139.61,150.29) 139.61,150.32 XU1.AT10 ; XU1.AD1 128.2,141.77 v1(128.23,141.73) ; v1(113.55,42.71) 113.55,42.5 113.76,42.28 113.76,42.12 UCC3.2 ; v1(143.43,149.95) 143.33,149.84 XU1.AY9 XU1.AW9 ; SS4.73 209.61,12.31 ; v1(109.45,171.69) 109.91,172.15 XU1.C31 ; XU1.C20 106.13,159.9 v1(106.03,160.01) ; LCB7.2 v1(34.9,221.36) ; MQ8.4 v1(40.92,176.13) ; P118.11 197.7,10.22 v1(197.64,10.28) ; XU1.AM17 v1(135.97,158.9) ; O2CB17.2 216.92,44.42 v1(216.89,44.45) ; v1(27.37,122.12) 27.37,122.15 27.42,122.2 J60.1 ; PC5801.2 72.29,209.04 v1(71.75,209.58) ; v1(135.02,145.73) 134.6,145.31 XU1.AL4 134.6,145.26 v1(134.14,144.8) 134.58,144.36 XU1.AL3 ; v1(135.02,145.73) 135.03,145.73 135.49,146.19 XU1.AM5 XU1.AN5 ; v1(135.02,145.73) 134.6,146.15 XU1.AL5 ; XC94.2 v1(52.76,12.95) ; v1(138.44,141.68) 138.26,141.87 XU1.AR1 XU1.AR2 ; SS4.39 218.11,12.32 v1(218.03,12.4) ; O2CB8.2 207.2,21.63 v1(207.11,21.72) ; v1(209.25,229.97) 208.89,229.62 208.41,229.62 ; v1(203.1,28.96) 203.1,29.36 203.38,29.64 O2CB1.2 ; v1(129.55,145.75) 129.55,145.75 XU1.AE5 XU1.AD6 128.18,147.1 v1(127.73,147.55) ; XU1.AV39 142.08,179.64 v1(142.79,179.64) 142.42,179.27 142.42,179.26 141.91,178.76 XU1.AV38 ; XU1.A17 106.54,157.16 v1(106.48,157.1) ; D4C13.2 206.41,230.25 v1(205.99,230.67) ; v1(144.34,168.57) 144.27,168.5 XU1.AY27 ; XU1.AF40 130.94,181.03 v1(130.76,181.21) ; XU1.AB39 127.2,179.48 126.52,180.15 v1(126.52,180.22) ; D4C7.2 190.63,106.09 v1(190.87,105.84) ; SR653.2 153.75,33.86 154.09,33.86 v1(154.24,34.01) ; J60.30 34.67,114.78 34.54,114.66 v1(34.25,114.66) ; J60.39 v1(36.92,122.15) ; v1(13.23,226.95) 13.36,226.82 AC187.2 ; PC5806.2 70.56,212.8 v1(70.51,212.75) ; XU1.AA33 126.38,173.99 v1(126.88,173.48) ; LCB12.2 32.35,210.19 v1(32.22,210.06) ; O2CB4.2 224.87,32.08 v1(225.27,32.49) 225.78,31.98 O2CB20.2 ; SS4.57 v1(213.61,12.4) ; v1(39.36,122.17) 38.84,122.17 38.42,122.59 J60.45 ; XU1.AF8 130.19,149.09 130.46,149.37 v1(130.51,149.37) XU1.AG8 ; XU1.AW38 143.05,178.56 v4(143.54,179.04) ; D4CB7.2 191.48,103.12 v1(191.52,103.09) ; v1(127.73,147.55) 128.19,148.01 XU1.AD7 v1(128.66,148.48) XU1.AE8 128.67,149.37 v1(128.66,149.37) 128.64,149.37 XU1.AD8 ; v1(127.73,147.55) 127.28,147.11 XU1.AC6 XU1.AB5 ; J60.75 45.92,124.72 46.37,125.17 v1(46.94,125.17) ; v1(143.48,176.84) 143.37,176.73 XU1.AW36 ; D4CB64.2 v1(171.53,181.48) ; v1(44.89,124.79) 44.42,124.31 J60.69 ; PC5804.2 76.07,207.65 v1(76.2,207.52) ; XU1.AN6 136.91,147.58 v1(136.91,147.59) 136.86,147.59 136.43,148.01 v1(136.91,148.49) 136.47,148.93 XU1.AN8 136.43,148.93 v1(136.89,149.4) 136.45,149.84 XU1.AN9 136.43,149.85 v1(135.95,150.33) 136.38,150.76 XU1.AN10 ; XU1.A13 105.96,153.5 v1(105.9,153.44) ; UC94.2 v1(38.99,190.6) ; XU1.AK10 133.68,150.77 v1(134.13,151.22) ; SS4.45 v1(216.61,12.4) ; XU1.AT6 139.22,147.1 139.65,146.67 v1(139.65,146.65) 139.65,146.64 139.19,146.19 XU1.AT5 ; XCB5.2 49.61,54.6 v1(49.36,54.36) ; v1(233.81,105.69) UU4.3 UU4.8 231.85,105.69 v1(231.7,105.54) ; v1(34.25,113.89) 35.13,113.89 36.17,114.94 J60.36 ; SCB29.2 171.82,24.4 SCB35.2 ; v1(130.49,145.74) 130.04,146.19 XU1.AF5 ; v1(130.49,145.74) 130.94,145.29 XU1.AG4 130.94,145.25 v1(130.48,144.79) 130.51,144.79 XU1.AG3 130.94,144.35 v1(130.49,143.89) 130.49,143.89 XU1.AG2 130.94,143.42 v1(130.49,142.97) 130.93,142.53 XU1.AG1 130.94,142.48 130.7,142.24 130.5,142.04 v1(130.48,142.02) 130.03,142.48 XU1.AF1 ; v1(130.49,145.74) 130.94,146.19 XU1.AG5 ; v1(228.85,200.76) 229.34,200.76 P1CB3.2 ; XU1.AV5 141,146.17 v1(140.55,145.72) 140.09,146.19 XU1.AU5 ; v1(159.55,32.2) 159.38,32.04 159.38,31.37 ; SCB118.2 163.32,24.28 v1(163.45,24.16) ; UC965.2 24.03,147.96 v1(24.21,147.78) ; CB4115.2 v1(22.96,225.96) ; v1(128.7,143.88) 128.7,143.95 129.09,144.34 XU1.AE3 ; v1(30,215.52) LCB4.2 ; v1(50.89,130.23) 51.05,130.39 PC640681.2 ; XCB6.2 56.03,34.92 56.16,34.8 XR19.1 ; XU1.AJ24 v1(134.12,166.19) ; D4CB76.2 v1(190.75,223.42) ; J60.33 35.42,122.21 v1(35.48,122.15) ; XU1.AK9 133.68,149.87 v1(133.22,150.33) ; D4CB60.2 190.14,145.95 v1(190.14,145.92) ; v1(104.87,151.19) 105.35,151.67 XU1.A11 ; SCB10.2 157.52,33.2 v1(157.8,33.48) ; v1(21.55,11.98) 21.71,11.81 AC21.2 ; v1(34.25,113.01) 34.12,113.01 33.17,113.97 J60.24 ; RFC29.2 173.82,106.81 D4C2.2 ; D4C8.2 189.74,230.89 v1(189.31,230.45) ; v1(113.11,153.95) XU1.G13 ; SS4.71 210.11,12.34 ; v1(40.88,122.15) 41.06,122.15 41.42,122.52 J60.57 ; XU1.AH8 131.9,148.93 132.14,149.17 v1(132.33,149.36) ; v1(132.77,181.21) XU1.AH40 XU1.AH39 ; XU1.AJ5 132.76,146.19 v1(132.33,145.75) 131.9,146.19 XU1.AH5 ; XU1.D37 111.27,177.2 v1(111.29,177.2) ; v1(106.43,155.17) 106.59,155.33 XU1.A15 ; XU1.AW32 143.36,173.07 v1(143.47,173.19) ; UCC7.2 119.51,42.42 v1(119.51,42.67) ; D4CB2.2 v1(175.26,164.59) ; D4C3.2 v1(173.48,228.69) ; v1(108.53,154.79) 108.91,154.42 XU1.C14 ; XU1.AD4 128.15,145.27 127.28,144.4 XU1.AC3 ; J60.63 v1(42.92,122.17) ; v1(42.75,140.03) 42.62,140.03 42.27,140.39 UC74.2 ; PC5812.2 77.11,207.59 v1(77.01,207.49) ; AC2.2 21.68,20.27 v1(21.62,20.21) ; LCB14.2 30.48,213.49 v1(29.96,214.01) ; SS4.1 227.61,12.22 227.61,12.22 ; v1(196.64,10.28) 196.7,10.22 P118.9 ; J60.51 39.92,124.67 v1(39.52,125.07) ; v1(140.1,141.85) 140.09,141.86 XU1.AU1 ; v1(61.58,8.27) 61.59,8.27 UCB18.2 ; PC231.2 v1(230.17,159.69) ; v1(219.63,12.4) 219.61,12.37 SS4.33 ; O2CB3.2 223.82,41.08 v1(223.83,41.08) ; v1(143.76,174.97) 143.7,174.9 XU1.AW34 XU1.AV34 ; XU1.AJ8 132.81,148.93 v1(133.25,149.37) XU1.AK8 ; 92.84,147.51 94.03,148.69 v1(94.03,148.82) 93.88,148.97 93.88,150.72 v1(94.23,151.08) 94.23,151.82 94.59,152.17 95.86,152.17 v1(96.19,151.84) 96.19,151.84 96.41,152.06 96.41,152.62 96.88,153.09 v1(98.96,153.09) 99.85,153.09 105.33,158.56 108.52,158.56 109,158.09 XU1.C18 ; v1(79.32,229.01) 79.3,228.98 PC5810.2 ; v1(108.36,31.16) 108.35,31.16 108.03,30.84 UCC4.2 ; v1(190.14,143.26) 190.75,142.65 D4CB73.2 ; XU1.AK23 v1(135.08,164.36) ; XU1.AJ1 132.77,141.94 v1(132.67,141.85) ; v1(132.32,144.82) XU1.AJ4 ; XU1.E31 111.74,172.15 v1(111.3,171.72) ; SS4.9 v1(225.61,12.26) ; D4CB72.2 v1(190.78,130.76) ; O2CB5.2 O2CB6.2 225.73,39.6 v1(225.25,40.08) ; v1(172.72,168.35) 172.92,168.35 D4CB78.2 ; XU1.AK5 133.68,146.19 133.5,146.36 133.5,146.88 133.68,147.07 XU1.AK6 133.58,147.1 133.25,147.43 v1(133.25,147.55) 133.5,147.81 133.68,147.99 XU1.AK7 ; XU1.C22 108.77,161.73 v1(108.33,161.29) ; UCB26.2 69.67,8.42 v1(69.49,8.24) ; SS4.51 v1(215.11,12.34) ; PC13.1 v1(55.32,122.89) ; D4CB58.2 v1(190.78,186.06) ; XU1.AV9 140.99,149.84 140.54,150.3 v1(140.54,150.29) ; SS4.3 227.11,12.15 ; XU1.AK40 v1(134.6,181.05) ; XU1.AK16 v1(134.14,158.9) ; XU1.AK17 v1(134.14,159.82) ; SS4.27 221.11,12.37 v1(221.08,12.4) ; M1C35.2 v1(20.7,169.93) ; XU1.AT40 v1(140.09,181.07) ; XU1.AK22 v1(134.14,164.39) ; v1(113.11,147.56) XU1.H7
  TOP w0.356: v1(108.65,142.86) 109,143.2 XU1.C2 ; v1(118.98,141.74) 118.98,141.85 119.05,141.92 XU1.P1 ; v1(107.62,167.67) XU1.B28 ; XU1.H30 v1(113.11,169.5) ; v1(114.94,162.2) 114.94,162.19 XU1.K22 ; XU1.B38 109,178.54 v1(109.47,178.07) 109.89,177.65 XU1.C37 ; XU1.E33 111.29,173.54 v1(111.23,173.54) ; v1(219.07,47.37) 219.07,47.19 218.63,46.75 O2Q6.4 ; v1(113.46,141.91) 113.57,142.02 XU1.H1 ; v1(123.2,173.53) 123.18,173.53 XU1.U33 ; O2Q6.1 220.12,45.45 219.89,45.67 v1(219.32,45.67) ; XU1.H11 113.57,151.67 v1(114.03,152.13) XU1.H12 ; XU1.B30 v1(107.62,169.5) ; v1(109.45,157.54) 109.45,157.56 109,158.01 XU1.C18 ; XU1.K39 115.87,179.91 v1(115.87,179.93) ; v1(123.19,146.63) 123.63,147.07 XU1.W6 XU1.Y5 ; XU1.A24 107.17,163.56 v1(107.63,164.03) 108.08,163.57 XU1.B24 ; v1(114.01,175.38) 114.45,175.82 XU1.H35 ; XU1.G33 113.92,174.35 113.92,174.35 v1(114.02,174.45) ; XU1.N33 v1(119.51,173.53) ; v1(111.65,141.79) 111.74,141.88 XU1.F1 ; XU1.D24 v1(109.43,164.04) 109,163.61 XU1.C24 ; SR7781.2 155.08,12.16 v1(154.87,11.95) ; XU1.L32 v1(117.68,172.62) ; XU1.K1 115.4,142.38 115.4,142.38 115.4,141.91 115.4,141.91 v1(115.4,141.8) ; XU1.T35 122.22,175.39 v1(122.22,175.36) ; XU1.K33 v1(116.77,173.53) ; XU1.A4 106.96,145.07 v1(106.96,144.3) ; XU1.H4 v1(113.11,144.81) XU1.G3 ; XU1.E35 111.33,175.41 v1(111.29,175.41) ; v1(114.94,165.86) 114.94,165.85 XU1.K26 ; XU1.R33 120.91,173.99 v1(121.41,173.49) ; XU1.C33 109.91,173.98 v1(109.47,173.54) ; XU1.J18 v1(114.94,157.62) XU1.K17 ; v1(117.83,155.33) 117.83,155.33 XU1.M15 ; XU1.W3 123.63,144.34 v1(123.19,143.9) ; XU1.E23 v1(111.27,162.2) XU1.F22 ; XU1.J3 114.86,144.73 v1(114.94,144.81) XU1.K4 ; MQ20.1 222.65,109.89 v1(222.48,110.06) ; v1(125.19,143.57) 125.45,143.84 XU1.AA3 ; XU1.D30 v1(109.45,169.5) ; v1(134.16,110.69) 135.28,110.69 135.65,111.06 PQ46.1 ; v1(118.52,149.39) 118.14,149.01 XU1.N8 ; XU1.T39 v1(121.34,179.93) ; v1(119.51,179.93) XU1.P39 ; XU1.J34 v1(114.94,175.36) ; XU1.Y35 125.48,175.82 v1(125.93,175.36) ; XU1.J32 v1(115.85,172.62) ; XU1.M4 117.23,145.25 v1(116.79,144.81) 116.34,144.36 XU1.L3 ; v1(113.11,171.69) 113.57,172.15 XU1.G31 ; v1(117.16,141.73) 117.23,141.8 XU1.M1 ; v1(118.62,175.36) 118.16,175.82 XU1.M35 ; XU1.D7 v1(110.36,147.57) XU1.E6 ; XU1.K35 v1(115.84,176.29) ; XU1.N6 118.14,147.02 v1(117.74,146.62) ; XU1.J20 114.94,159.45 ; 114.94,159.45 XU1.K19 ; 114.94,159.45 v1(114.94,159.44) ; v1(115.85,178.1) XU1.K37 ; v1(120.88,141.88) XU1.T1 ; v1(125.45,149.53) XU1.AA8 ; v1(113.11,164.02) XU1.H24 ; FC8.2 192.44,50.54 v1(192.67,50.76) ; XU1.M27 v1(116.76,165.84) ; v1(122.25,147.47) 122.25,147.47 122.16,147.47 121.8,147.11 XU1.U6 ; XU1.V8 v1(123.15,149.36) ; XU1.M23 v1(116.75,162.17) ; v1(114.94,167.69) 114.94,167.67 XU1.K28 ; XU1.B6 XU1.A7 ; v1(113.11,167.67) XU1.H28 ; v1(113.11,165.85) XU1.H26 ; v1(106.75,27.8) 106.75,27.8 UCR45.2 ; v1(117.7,179.92) 117.7,179.91 XU1.M39 ; v1(124.1,175.36) 123.65,175.82 XU1.V35 ; v1(119.51,147.47) 119.6,147.47 XU1.R6 ; XU1.K14 115.82,154.84 v1(115.82,154.91) 115.41,155.33 XU1.K15 ; v1(15.54,170.95) 15.24,170.65 M1R37.2 ; XU1.W33 v1(125.01,173.52) ; XU1.R8 120.4,149.36 v1(120.4,149.36) ; XU1.N3 v1(118.6,144.82) XU1.P4 ; XU1.M7 XU1.L6 v1(115.85,147.56) XU1.K7 ; XU1.J10 XU1.H9 v1(113.15,149.43) ; XU1.U3 XU1.T4 v1(120.43,144.82) XU1.R3 ; XU1.H21 113.57,160.83 v1(113.12,161.28) 112.67,161.73 XU1.G22 ; XU1.M10 116.78,151.2 v1(116.78,151.2) XU1.L11 ; XU1.M17 v1(117.83,157.16) ; v1(109.45,167.67) XU1.D28 ; v1(111.28,165.85) XU1.F26 ; v1(111.29,177.2) XU1.E37 ; v1(117.7,178.08) 117.71,178.08 XU1.M37 ; XU1.T37 v1(121.34,178.1) ; XU1.K30 114.94,169.5 v1(114.94,169.52) ; XU1.M29 v1(116.77,167.68) ; v1(107.62,165.85) XU1.B26 ; v1(115.88,150.28) XU1.L9 ; v1(114.05,179.91) XU1.H39 ; XU1.C16 v1(108.53,156.71) ; XU1.P35 120.42,175.36 v1(120.42,175.36) ; v1(114.02,178.1) XU1.H37 ; XU1.M21 v1(116.76,160.35) ; v1(114.94,164.03) 114.94,164.02 XU1.K24 ; XU1.L13 116.31,153.5 116.42,153.39 116.42,153.38 v1(116.76,153.03) 117.21,152.59 XU1.M12 ; v1(123.19,179.92) 123.19,179.91 XU1.V39 ; v1(117.32,52.08) 117.58,51.82 PU12.2 ; v1(122.61,141.9) 122.71,142 XU1.V1 ; v1(58.63,8.13) 59.03,8.53 AC193.2 ; XU1.J12 v1(114.94,152.13) ; v1(77.91,10.42) 78.01,10.42 78.54,9.9 AC196.2 ; XU1.P37 v1(119.51,178.1) ; XU1.C35 109.74,175.65 109.74,175.63 v1(109.45,175.34) ; v1(123.18,178.09) XU1.V37 ; v1(112.65,181.38) XU1.F40 ; v1(111.28,167.67) XU1.F28 ; v1(109.45,165.85) XU1.D26 ; XU1.F30 v1(111.28,169.5) ; XU1.M19 v1(117.86,158.99) ; XU1.M25 v1(116.74,163.98) ; XU1.Y37 v1(125,178.1)
  TOP w0.381: PC567.2 114.71,52.98 v1(114.71,51.8) ; v1(109.44,148.41) 109.44,148.48 XU1.C8 ; HR616.2 HR617.2 97.24,121.45 v1(97.61,121.82) ; v1(28.14,43.74) 28.26,43.62 CB2.2 ; PR6603.2 119.82,51.52 119.56,51.78 v1(119.56,52.07) ; v1(110.36,149.3) 110.36,149.38 XU1.E9 XU1.F10 XU1.E11 ; UC969.2 41.03,150.56 v1(40.91,150.69) ; v1(52.17,118.8) 52.02,118.95 M2C47.2 ; v1(231.52,217.7) 230.51,217.7 229.61,216.8 Q35.1 ; XU1.E3 111.32,144.86 v1(111.32,144.86) 111.73,145.27 XU1.F4 ; v1(108.58,145.75) 108.58,145.77 XU1.C5 XU1.B6 ; SCB19.2 v1(185.17,31.98) ; v1(172.19,186.18) 172.04,186.04 D4CB19.2 ; v1(109.45,152.21) 109.44,152.22 109.36,152.22 XU1.C12 ; UC77.2 UC970.2 30.29,149.31 v1(30.43,149.45) ; v1(39.5,232.28) PC640675.2 ; v1(21.56,143.56) 21.72,143.41 22.63,143.41 22.85,143.19 CB4128.2 ; v1(105.07,11.04) 105.07,10.96 105.56,10.46 C5.2 ; SR371.2 v1(187.95,35) ; SCB122.2 v1(186.18,31.98) ; v1(230.15,20.91) 230.59,20.91 230.79,21.12 PQ11.1 ; XU1.G6 v1(113.11,147.56) ; XU1.E19 110.82,159.03 v1(110.36,159.49) ; v1(20.43,153.23) 20.43,153.23 20.43,153.23 20.97,152.69 CB4129.2 ; XU1.D4 109.48,144.84 v1(109.47,144.84) ; v1(112.2,147.56) XU1.F7 ; HR31.2 120.38,153.42 120.95,153.42 ; AC39.2 216.08,21.03 216.53,20.57 v1(216.79,20.57) ; MQ21.4 v1(130.58,110.01) ; XU1.K17 115.39,157.16 114.48,156.25 XU1.J16 114.48,156.16 115.32,155.33 XU1.K15 ; v1(33.25,126.09) 32.99,125.83 M2R39.2 ; v1(38.99,177.43) MQ8.1 ; v1(114.94,147.56) XU1.J6
  TOP w0.406: MQ28.4 206.64,49.13 206.88,48.9 v1(206.88,48.51) ; Q53.1 v1(214.87,139.4) ; MQ26.4 227.98,200.7 228.65,200.03 v1(228.8,200.03) ; v1(230.15,20.91) 229.49,20.26 PQ11.4 ; PC339.2 v1(217.25,144.58) ; MQ19.4 v1(226.77,79.74) ; MQ25.4 v1(229.15,153.62) ; Q5.1 102.95,12.97 v1(102.84,12.86) ; MQ35.4 211.44,50.13 v1(210.97,50.6) ; v1(231.93,215.65) 231.27,215.65 231.12,215.5 Q35.4 ; MQ29.4 138.44,95.11 138.81,94.74 139.57,94.74 139.57,94.74 v1(139.6,94.74) ; v1(136.27,92.96) 136.9,92.96 137.15,93.2 MQ29.1 ; v1(210.49,217.55) 209.95,217.01 MQ24.4 ; MQ20.4 221.35,106.48 v1(221.27,106.4) ; v1(128.68,110.9) 129.09,111.31 MQ21.1 ; MQ28.1 205.34,47.23 205.1,46.99 v1(204.47,46.99) ; v1(218.69,147.45) 218.45,147.45 PR139.2 ; v1(216.83,141.35) 216.17,140.69 Q53.4 ; v1(226.8,80.98) 226.88,80.9 228.42,80.9 228.71,81.18 MQ19.1 ; MQ25.1 227.85,153.27 v1(228.19,153.62) ; SC166.2 227.67,112.59 v1(227.51,112.75) ; v1(208.41,213.61) 208.65,213.85 MQ24.1 ; v1(210.92,51.77) 210.58,51.43 MQ35.1 ; Q5.4 105.42,11.67 105.07,11.32 v1(105.07,11.04) ; FC2.2 130.75,233.92 v1(131.04,233.63)
  TOP w0.432: PR126.2 210.06,155.96 v1(209.85,156.16) 209.7,156.16 209.14,155.6 PC485.2 ; v1(221.79,99.95) 221.31,99.95 221.08,99.72 R69695.2 ; v1(61.93,11.45) 61.56,11.82 60.6,11.82 AC197.2 ; v1(42.72,138.18) 42.48,138.42 UC69.2 ; PC484.2 v1(207.4,144.5)
  TOP w0.457: v1(26.47,167.61) 26.68,167.83 VCB155.2 ; PC640684.2 71.46,189.7 v1(71.3,189.87) ; UC950.2 UR69705.2 31.19,151.37 v1(30.76,150.94) ; v1(67.69,126.62) PR70206.2 ; v1(128.8,91.52) 129.34,92.06 ECC56.2 ; SC171.2 v1(20.28,228.74) ; v1(225.93,199.24) 226.39,199.24 MQ26.1 ; XR14.2 48.98,24.4 SLOT4.A4 ; v1(203.1,28.96) 203.1,28.88 203.28,28.7 C81.2 ; P1CB1.2 v1(228.8,194.18) ; PR175.2 191.15,89.45 v1(190.91,89.69) ; D4CB53.2 v1(190.75,205.41) ; PC640687.2 70.71,171.32 v1(71.07,171.68) ; HC29.2 205.73,52.84 v1(205.74,52.83) ; UCR23.2 v1(122.66,35.97) ; v1(171.79,25.93) 171.82,25.91 SCB35.2 ; AR232.2 18.58,77.25 v1(18.8,77.47) ; HR14.2 HR15.2 98.02,143.64 97.77,143.4 v1(97.77,143.38) ; v1(57,10.26) UCB28.2 ; v1(150.37,35.43) SC80.2 ; Q3.4 97.27,11.67 96.95,11.99 96.95,12.75 v1(96.95,12.75) ; v1(191.57,178.14) D4CB55.2 ; v1(133.41,95.55) 133.41,95.87 132.84,96.43 ECC55.2 ; UCC14.2 108.32,34.71 v1(108.5,34.89) ; AR4.2 21.77,21.21 v1(21.61,21.05) ; v1(40.97,237.36) 40.97,236.97 PC6810.2 ; HC5.2 101.98,121.12 v1(101.98,120.58) ; v1(85.71,226.26) 85.36,226.26 85.06,225.97 PC5829.2 ; SR1.2 142.21,39.83 v1(142.8,39.24) ; PC126.2 v1(214.87,125.53) ; v1(72.07,218.44) PC5813.2 ; SR7717.1 v1(89.26,115.86) ; v1(43.71,223.04) 42.95,222.28 42.95,221.87 41.91,220.83 LC7.2 ; UCC13.2 106.76,32.17 v1(106.66,32.06) ; XR20.2 v1(49.28,47.37) ; RFC114.2 23.98,18.77 v1(23.93,18.82) ; XC95.2 42,24.35 v1(41.78,24.13) ; SC105.2 v1(148.72,38.38) ; v1(100.43,109.68) 100.43,109.45 HR626.2 ; D4CB66.2 v1(172.85,181.48) ; v1(18.81,57.2) 18.81,57.81 AC55.2 ; PC5830.2 v1(71.63,221.74) ; v1(44.96,24.23) 44.96,25.06 XR15.2 ; UR69718.2 v1(223.61,136.4) ; v1(216.79,227.33) 216.79,226.86 PR70223.2 ; PC566.2 v1(120.02,58.1) ; v1(42.29,145.3) UC68.2 ; PR70201.1 61.56,121.09 v1(62.03,121.56) ; v1(71.88,220.98) 72.48,220.98 PR5812.2 ; LR9.2 42.85,220.95 43.74,221.84 v1(43.74,222.1) ; v1(56.35,56.27) 56.43,56.19 XR3.1 ; SC70.2 164.3,27.19 163.86,26.76 163.48,26.76 v1(163.45,26.72) ; SR7658.2 149.87,38.85 v1(149.86,38.86) ; D4CB20.2 190.97,154.57 v1(191.26,154.86) ; v1(191.26,196.06) 190.75,196.57 D4CB50.2 ; RFC121.2 43.14,140.03 v1(42.75,140.03) ; C417.2 162.33,31.95 v1(162.97,32.59) 163.25,32.31 SC141.2 ; C83.2 226.9,26.2 v1(227.03,26.07) ; v1(228.27,31.06) 228.27,31.57 228.24,31.6 O2R2.2 ; v1(187.38,55.98) 187.92,55.98 SCB11.2 ; RFC108.2 190.53,140.23 v1(190.73,140.44) ; v1(57.05,35.51) 56.86,35.32 XR19.1 ; v1(152.88,61.32) 152.74,61.18 SC9.2 ; M1R11.2 28.96,174.75 v1(28.63,175.08) ; Q3.1 95.48,12.97 v1(95.26,12.75) ; PR5830.1 89.69,214.33 v1(89.94,214.58) ; v1(189.87,38.86) 189.73,38.72 SC85.2 SC90.2 ; AC194.2 72.12,9.97 72.63,10.48 v1(72.63,11.22) ; UR69724.2 37.64,201.65 v1(37.52,201.78) ; v1(137.32,61.97) SR758.2 ; v1(18.72,71.75) 18.72,71.13 AC26.2 ; v1(20.68,170.85) 20.66,170.84 M1R36.2 ; v1(118.49,58.12) 118.49,57.2 118.19,56.9 R69694.2 ; v1(185.56,9.55) F3CB1.2 ; C82.2 221.5,44.67 v1(221.39,44.78) ; LCB15.2 v1(28.83,216.99) ; SC7.2 152.13,29.2 151.71,28.78 v1(151.51,28.78) ; SC146.2 147.72,46.48 v1(147.68,46.52) ; v1(44.91,85.01) 44.91,85.52 44.62,85.81 XR11.2 ; SR18.2 168.96,26.48 168.96,26.04 168.94,26.01 v1(168.94,25.97) 169.01,25.9 C414.2 ; O2CB7.2 217.93,21.62 v1(218.45,21.11) 218.71,20.85 SCB70.1 ; SR7690.2 v1(130.48,29.25) 130.57,29.34 SC121.2 ; PR5871.1 72.16,216.2 v1(72.1,216.14) ; PR6609.2 212.36,131.2 v1(212.22,131.34) ; D4CB27.2 v1(172.72,174.12) ; M2C48.2 52.32,118.64 v1(52.17,118.8) ; SC175.2 166.57,32.51 v1(166.24,32.18) ; v1(67.18,119) 67.09,119.09 PC640637.2 ; v1(49.23,121.79) 49.67,121.35 M2C53.2 ; AR247.1 23.69,152.79 v1(23.65,152.83) ; UC78.2 27.94,143.71 v1(27.84,143.81) ; v1(110.69,42.73) 110.84,42.89 UCC10.2 ; v1(75.13,226.39) 74.78,226.03 PR5873.1 ; v1(189.66,36.91) 189.5,36.75 SC86.2 ; LR20.2 v1(23.04,220.51) ; v1(226.19,22.5) 226.19,22.23 225.64,21.68 O2CB2.2 O2CB16.2 ; v1(140.63,40.23) SR160.2 ; AC72.2 v1(40.13,5.46) ; v1(23.88,11.65) RFC113.2 ; v1(13.34,173.1) 13.08,172.85 MR41.2 ; M2C17.2 226.61,20.8 v1(227.08,21.26) ; HC11.2 v1(177.44,29.51) ; PR12.2 217.84,227.62 v1(217.55,227.33) ; v1(56.15,65.05) 56.25,65.15 XC33.2 ; XC128.2 59.36,48.2 v1(59.36,49.83) ; v1(99.42,116.84) 99.76,116.84 HR621.2 ; v1(224.59,117.73) 224.93,117.39 UR6.2 ; SCB75.2 219.38,44.05 v1(219.38,44.4) ; XC35.2 v1(59.41,86.23) ; PC241.2 230.16,183.88 230.15,183.87 v1(230.15,183.85) ; v1(190.14,145.92) 190.14,145.73 RFC105.2 ; O2CB12.2 203.28,27.79 v1(203.03,27.55) ; D4C1.2 v1(208.37,183.42) ; OR44.2 203.75,26.3 203.8,26.35 OR34.1 203.37,26.87 v1(203.14,26.64) ; PC247.2 228.51,163.28 v1(228.12,162.89) ; SCB30.2 172.96,25.93 v1(172.99,25.91) ; v1(191.72,46.56) 191.26,47.02 SCB7.2 ; AC52.2 18.72,74.92 v1(18.72,74.22) ; v1(209.25,230.78) 208.83,230.78 D4R20.2 ; AR231.2 v1(34.8,11.72) ; v1(157.94,174.88) 157.94,174.68 D4CB34.2 ; O2R10.1 227.05,23.44 227.39,23.79 v1(227.39,24.32) 227.34,24.37 O2CB15.2 ; R636.2 226.2,34.52 v1(226.69,34.52) 226.69,35.19 OR59.2 ; v1(125.22,116.76) PR245.2 ; LC4.2 v1(32.89,222.63) ; FC6.2 233.48,226.17 233.48,225.65 233.82,225.31 FC5.2 234.58,225.31 234.87,225.6 v1(234.87,226.21) ; OR6.2 214.83,20.65 214.85,20.66 214.85,20.72 v1(215.21,21.08) 215.16,21.13 SCB119.1 ; v1(29.78,145.47) 29.78,145.53 30.25,146 UC81.2 ; LC12.2 28.51,208.22 v1(28.17,208.56) ; v1(65.66,121.92) 66.08,121.92 PC640644.2 ; AC73.2 20.38,11.96 v1(20.38,12.21) ; v1(72.69,228.24) 72.77,228.17 PC5826.1 ; AD22.2 76,9.74 76.7,10.44 v1(76.74,10.44) ; O2CB10.2 220.24,21.16 220.52,20.88 v1(220.83,20.88) 221.16,21.21 SC52.1 ; PC640661.2 v1(213.59,225.55) ; SR7637.2 130.99,27.1 v1(130.56,27.53) 131.04,28.02 SC149.2 ; SR139.1 v1(148.54,33.27) ; v1(69.91,217.07) 70.02,217.17 PC5825.1 ; v1(210.49,224.97) 210.82,225.3 PR70217.2 ; XR13.1 v1(53.7,12.95) ; v1(67.69,153.64) 68.16,153.64 PC640688.2 ; SC82.2 v1(150.34,34.49) ; v1(118.2,42.74) 118.2,42.37 UCC1.2 ; v1(101.84,119.09) 101.93,119 HC23.2 ; PC5828.2 87.38,225.58 v1(87.45,225.65) ; O2R8.2 218.86,47.59 v1(219.07,47.37) ; v1(168.61,31.17) 168.45,31.01 C416.2 ; SC6.2 v1(154.33,32.63) ; v1(75.87,10.45) 75.2,10.45 74.86,10.12 AC195.2 ; C415.2 170.13,25.82 v1(170.28,25.97) ; v1(38.86,137.62) 39.02,137.78 UR69686.1 39.99,137.78 40.03,137.82 UC82.2 ; XR5.1 55.16,75.91 v1(55.14,75.9) ; v1(156.76,28.07) 157.11,28.42 SC148.2 SR336.2 ; SR7787.2 v1(118.24,6.58) ; v1(48.23,75.9) 48.01,75.9 47.51,76.39 XR10.2 ; v1(32.21,207.37) 32.09,207.37 LC6.2 ; M2C18.2 v1(228.22,20.33) ; v1(71.58,222.55) 71.68,222.66 PR5870.1 ; v1(226.75,186.13) 226.66,186.04 PR194.1 ; v1(28.85,222.48) 29.01,222.63 LC5.2 ; HR36.2 95.32,119.68 HR615.2 95,120.02 v1(95,120.32) ; v1(148.29,36.37) 148.49,36.58 SC83.2 ; HR629.1 v1(188.75,47.08) ; D4CB54.2 190.21,170.01 ; SR60.2 v1(149.88,48.01) SR2.2 ; v1(222.81,118.03) R60381.2 ; v1(172.94,106.97) RFC29.2 ; v1(152.02,63.63) 152.01,63.64 SC8.2 ; HC25.2 132.59,114.07 v1(132.61,114.1) ; v1(25.04,221.23) 24.89,221.08 LC44.2 ; PC209.2 188.93,91.55 v1(188.34,91.55) ; SC170.2 24.82,228.14 v1(24.87,228.09) ; AC24.2 v1(29.72,12.5) ; v1(172.34,164.47) 172.88,163.92 D4CB1.2 ; SR749.2 v1(172.21,30.84) ; PC640672.1 64.59,123.04 v1(64.39,122.83) ; v1(28.93,220.6) LCB11.2 ; v1(134.24,96.77) 134.58,96.43 PC152.2 ; v1(229.26,137.29) CB4122.2 ; 234.19,202.56 PC242.2 234.73,203.06 234.77,203.1 PR138.2 236.03,202.36 236.03,201.94 v1(236.75,201.22) ; v1(145.72,48.04) 145.76,48.01 SR694.2 ; v1(20.17,35.48) 20.17,35.12 AC27.2 ; PR133.2 v1(126.03,100.39) ; R60374.2 v1(223.72,118.03) ; D4CB52.2 190.3,214.08 v1(190.3,213.87) ; PC486.2 v1(218.29,158.62) ; v1(172.89,32.21) 173.1,32.42 SCB31.2 ; v1(166.75,183.13) 166.85,183.13 D4CB68.2 ; O2CB11.2 219.33,21.03 v1(219.32,21.02) ; RFC120.2 39.26,192.25 v1(39.45,192.25) ; D4CB67.2 v1(172.14,153.92) ; SCB121.1 v1(199.17,9.77) ; UCB27.2 v1(54.84,10.19) ; R60373.2 225.29,105.11 v1(225.68,105.5) 225.41,105.77 224.75,105.77 R60385.2 ; UCC2.2 v1(115,42.49) ; v1(102.46,114.38) 103.09,115.01 HR619.2 ; SC167.2 226.52,82.83 v1(226.11,83.24) ; RFC30.2 v1(190.63,110.06) ; v1(152.02,38.35) 152.07,38.4 SR664.1 ; v1(52.17,117.5) 51.66,117.5 51.42,117.74 M2C46.2 ; AC25.2 v1(31.37,12.57) ; PC640685.2 v1(66.04,208.84) ; v1(228.27,105.72) 228.16,105.83 UR69716.2 ; C941402.2 224.07,98.81 v1(224.18,98.81) ; v1(216.79,20.57) 216.99,20.78 SCB68.1 ; AC22.2 v1(24.73,14.86) ; PC121.2 v1(51.85,122.83) ; HC4.2 128.73,118.11 v1(128.91,118.29) ; SR7788.2 125.22,6.16 v1(124.66,5.6) ; UR69725.2 v1(23.06,222.45) ; SC81.2 v1(146.81,35.43) ; HR627.1 v1(187.66,44.07) ; UC79.2 v1(36.73,137.6)
  TOP w0.508: C1.2 215.96,44.95 216.46,44.45 v1(216.89,44.45) ; v1(233.86,148.21) P1C2.2 ; UD8879.1 28.79,200.72 v1(29.01,200.94) ; v1(210.82,153.92) 210.19,153.29 PU80.2 ; PC5822.2 81.57,229.54 v1(81.08,229.54) ; SW2.3 126.78,33.01 v1(126.87,32.92) ; PQ9777.2 205.93,52.64 v1(205.74,52.83) ; AC15.2 25.07,18.69 24.64,19.13 v1(24.64,19.63) ; M2C19.2 221.68,19.01 v1(221.49,18.82) ; v1(18.69,151.08) 18.51,151.27 PC640682.2 17.75,152.77 FC13.2 ; v1(63.75,205.23) 63.85,205.32 PC5916.2 ; D4CB51.2 169.8,159.78 D4CB31.2 D4CB28.2 v1(166.99,159.78) ; v1(38.23,221.55) LC18.2 ; PC640676.2 v1(35.94,229.95) ; AQ11.3 v1(22.82,27.36) ; v1(26.9,11.81) 26.2,11.81 AD9.2 ; SW2.4 126.55,28.86 v1(126.97,28.44) ; v1(50.6,67.35) 50.98,66.97 XR4.2 ; PC5827.2 89.52,219.73 v1(90.02,219.23) ; AD2.2 v1(20.32,33.45) ; SCB9.2 v1(190.48,56.26) ; PQ80.2 v1(216.96,154.52) ; XC92.2 v1(56.79,24.18) ; v1(195.57,48.33) SR545.2 ; SC147.2 166.23,22.9 v1(166.6,22.53) ; v1(130.9,96.47) 130.34,95.91 PC154.2 ; v1(91.08,225.45) 91.35,225.45 91.99,226.09 PC6108.2 ; PU681.8 v1(46.89,229.42) ; PC5817.2 81.84,208.33 v1(81.79,208.28) ; v1(61.93,11.45) 61.93,11.4 61.42,10.9 AD20.2 ; v1(149.95,64.67) Y18.4 ; D4R31.1 206.84,235.24 v1(206.71,235.38) ; AD21.2 71.16,10.04 71.88,10.77 v1(71.88,11.22) ; SC101.2 v1(133.14,60.8) ; v1(196.6,89.28) 196.6,89.53 196.38,89.75 PC212.2 ; v1(107.44,40.63) 107.9,41.1 UCC9.2 ; v1(159.13,176.07) 159.16,176.07 D4CB71.2 ; v1(113.94,51.79) 113.94,51.32 PC568.2 ; v1(128.52,93.22) 128.52,93.53 128.02,94.04 ECQ12.2 ; PU5.2 125.96,96.57 126.22,96.83 126.22,98.17 v1(126.24,98.19) ; J125.24 3.98,172.97 ; J125.24 2.34,174.06 ; J125.24 2.34,171.88 ; v1(29.41,206.81) 29.06,206.45 29.06,206.16 UD8880.2 ; v1(44.04,239.17) 43.56,239.17 43.26,238.86 PC6805.2 ; v1(120.28,30.37) 120.28,30.18 119.67,29.57 SW1.4 ; P_HDDFAN.5 v1(85.67,7.29) ; v1(26.87,26.19) AQ13.3 ; v1(99.44,119.27) 99.21,119.04 HR622.2 ; v1(122.35,30.39) 122.35,30.28 SW1.3 ; J60.76 25.38,122.66 v1(25.22,122.5) ; v1(189.96,227.11) 190.63,227.78 D4C21.2 ; v1(89.9,217.58) 89.5,217.98 PR5834.1 ; v1(191.54,157.63) 191.54,157.35 191.07,156.88 D4CB21.2 ; PQ9787.2 v1(138.46,14.07) ; v1(45.31,133.75) 45.31,137.64 45.92,138.25 UC91.2 ; v1(215.87,226.11) 215.65,225.88 PC640671.2 ; v1(207.42,145.95) 207.65,146.18 PU80.5 ; v1(210.41,220.83) 210.63,220.61 PQ10.2 ; UR69722.2 14.27,138.63 ; UD8881.1 29.43,199.31 v1(29.62,199.31) ; SC103.2 154.14,25.84 v1(154.79,26.49) 155.48,25.8 SC102.2 ; AD23.2 v1(67.22,8.27) ; PRT583.1 64.12,189.17 v1(64.52,188.77) ; D4C4.2 174.74,102.83 v1(175.08,103.17) ; Q9.2 v1(29.29,42.6) ; UU54.2 v1(35.33,162.43) ; D4C23.2 v1(207.14,226.49) ; Y19.2 v1(118.8,44.57) ; PC218.2 188.26,91.48 v1(188.34,91.55) ; Y10.4 33.07,224.07 33.3,224.29 v1(33.3,224.41) ; D4CB37.2 v1(163.96,180.72) ; v1(233.15,201.93) 233.56,201.93 234.19,202.56 ; PC133.2 135.86,108.41 v1(135.81,108.36) ; PC608.2 v1(67.32,169.28) ; D4R35.1 v1(164.59,225.43) ; AD11.2 v1(32.89,12.57) ; Y10.2 v1(29.96,226.69) ; AD10.2 v1(28.7,12.57) ; D4C5.2 v1(172.85,105.99) ; PC6527.2 218.86,228 218.44,227.58 v1(218.44,227.33) ; v1(207.98,226.47) 207.98,226.86 D4C24.2 ; PC273.2 130.94,113.94 v1(130.61,113.94) ; v1(133.41,95.55) 133.41,94.81 133.7,94.52 ECQ13.2 ; UCC8.2 122.22,38.9 v1(122.22,38.51) ; PC640653.2 210.95,224.03 210.44,223.52 v1(210.26,223.52) ; v1(186.21,17.93) 186.21,17.75 185.72,17.27 F3U1.4 ; PC341.2 216.81,137.26 v1(216.94,137.39) ; v1(212.34,7.09) 212.37,7.11 M2C44.2 ; PQ23.2 53.75,121.84 53.39,121.49 v1(52.81,121.49) ; D4CB29.2 190.5,173.19 v1(190.5,172.82) ; PC5815.2 v1(82.93,210.06) ; v1(68.5,125.81) 69.44,124.87 PC640649.2 ; UU51.2 226.77,133.76 v1(227.03,134.01) ; v1(135.64,235.71) FC3.2 ; CR2.2 95.15,9.86 95.53,10.24 v1(96.14,10.24) ; v1(209.6,7.21) M2C54.2 ; UC90.2 30.23,139.29 v1(29.32,138.38) ; v1(39.57,154.34) 39.66,154.44 UC92.2 ; AC188.2 v1(25.22,13.71) ; v1(43.77,224.67) 43.77,224.68 43.18,225.27 PC6808.2 ; v1(40.87,226.54) 40.88,226.53 PC6807.2 ; v1(40.39,199.77) 40.77,199.39 TUU2.2 ; v1(170.18,184.78) 170.6,184.37 PC6523.2 ; AR227.1 v1(15.75,223.47) ; v1(166.85,225.48) 166.97,225.48 D4R32.2 ; v1(129.82,117.98) 129.84,117.96 PC272.2 HC3.2 ; PRT584.1 100.91,227.67 v1(100.79,227.8) ; PR5840.1 v1(89.94,216.15) ; D4CB63.2 160.6,177.37 v1(160.43,177.37) ; PC642.2 v1(47.07,237.48) ; PQ115.2 213.22,152.59 v1(213.56,152.93) ; AC47.2 v1(202.9,35.31) ; v1(25.65,221.67) 25.91,221.41 LC8.2 ; J60.77 v1(47.02,124.54) ; v1(191.86,163.54) 191.66,163.34 PC481.2 ; PR5837.1 v1(86.11,208.76) ; HR618.2 98.3,120.17 v1(98.26,120.21) ; MQ18.2 v1(36.07,206.69) ; v1(165.1,26.72) 165.1,26.7 165.38,26.42 SR7646.1 ; v1(128.5,98.26) 128.36,98.26 127.85,98.77 PC151.2 ; SC72.2 189.46,39.75 v1(189.66,39.95) ; D4CB40.2 v1(162.18,179.58) ; v1(225.52,191.26) 225.39,191.14 PC236.2 ; v1(105.51,31.13) 104.7,30.32 UC2.4 ; UC83.2 38.37,137.12 v1(38.86,137.62) ; v1(210.92,146.02) 211.46,146.56 PU80.8 ; v1(212.22,132.21) 212.37,132.05 PC661.2 ; v1(88.65,99.82) 89.64,98.82 PD3.2 ; D4C22.2 v1(172.34,227.94) ; AC20.2 v1(27.31,12.83) ; PC6116.2 143.67,228.38 v1(143.23,228.38) ; AC130.2 19.43,82.33 v1(19.43,81.79) ; SC168.2 137.32,62.75 v1(137.32,61.97) ; Q4.2 104.49,9.71 103.81,10.39 v1(103.59,10.39) 103.37,10.39 102.9,9.91 CR9.2 ; SCB25.2 163.45,26.12 v1(163.45,26.72) ; P_HDDFAN.1 v1(90.47,8.94) ; M1D1.2 16.32,170.8 16.71,171.2 v1(16.87,171.2) ; v1(203.67,23.66) 203.9,23.66 204.28,23.27 C85.2 ; PR5824.1 84.02,208.74 v1(84.15,208.61) ; PR6809.2 v1(46.88,226.99) ; PC5909.2 v1(65.66,201.75) ; v1(36.04,11.71) 36.61,11.71 AD12.2 ; PU9.13 192.77,89.95 PR168.1 ; v1(41.53,182.07) F3U2.4 ; v1(16.64,223.52) 16.64,222.88 16.13,222.38 AC185.1 ; v1(133.99,100.2) PC150.2 ; UD8878.1 28.74,203.59 v1(29.06,203.28) ; LR24.2 v1(28.93,219.07) ; Y18.2 147.83,61.75 v1(147.19,61.75) ; SCB16.2 v1(201.56,59.54) ; UC641.2 v1(36.96,179.62) ; v1(28.63,170.54) 27.48,169.39 SR629.2 ; v1(190.52,54.37) 189.8,54.37 189.77,54.34 SR712.2 SR711.2 ; v1(190.36,60.2) SCB8.2 ; X1.2 33.79,133.67 v1(34.24,133.22) ; AQ23.3 v1(29.46,15.21) ; PR136.2 v1(37.52,230.99) ; Y19.4 114.62,46.27 v1(114.26,46.62) ; HC24.2 v1(93.27,207.54) ; v1(212.65,45.62) 213.18,45.09 C2.2 ; PC616.2 v1(67.84,151.63) ; PC274.2 v1(122.15,116.94) ; P_HDDFAN.6 v1(91.49,7.29) ; D4CB26.2 v1(165.06,182.33) ; PU80.7 210.19,146.33 v1(209.8,145.95) ; AC71.2 v1(30.23,25.5) ; HR620.2 v1(101.04,115.09) ; v1(85.71,226.26) 85.71,226.69 PR5856.1 ; v1(31.67,137.62) 31.59,137.53 X1.4 ; v1(174.9,31.81) 175.06,31.96 SCB32.2 ; AD8.1 v1(40.58,3.68) ; v1(65.91,213.23) 66.29,213.23 66.91,213.85 PQ2.2 ; RFC15.2 21.79,140.75 UR69720.2 ; UU47.2 v1(20.73,225.12) ; PC640674.2 v1(62.74,126.97) ; PR70296.2 v1(228.68,196.09)
  TOP w0.635: J9.U8 14.67,200.79 ; J9.U8 13.73,201.73 ; J9.U8 15.61,201.73 ; J125.23 3.98,156.47 ; J125.23 2.34,157.56 ; J125.23 2.34,155.38 ; 9.36,234.09 S/PDIF.4 ; S/PDIF.4 11.41,235.2 ; S/PDIF.4 13.45,234.09 ; S/PDIF.4 11.41,232.97 ; J9.3 9.34,209.98 ; J9.3 9.34,213.62 ; J9.3 7.52,211.8 ; J10.5 9.28,189.9 ; J10.5 7.46,191.72 ; J10.5 9.28,193.54 ; 6.71,194.14 J9.8 ; J9.8 6.71,197.77 ; J9.8 4.89,195.96 ; J9.8 8.53,195.96 ; PCE13.2 92.08,147.22 ; PCE13.2 92.08,145.34 ; PCE13.2 91.14,146.28 ; PCE13.2 93.01,146.28 ; J9.2 13.2,198.66 ; J9.2 15.02,200.48 ; J9.2 15.02,196.69 ; 4.89,214.51 J9.7 ; J9.7 6.71,212.69 ; J9.7 8.53,214.51 ; 17.57,195.96 J9.6 ; 7.4,163.02 J125.8 ; 9.28,176.76 J10.6 ; J10.6 9.28,180.4 ; J10.6 7.46,178.58 ; J10.6 11.1,178.58 ; 6.93,156.47 J125.21 ; J9.4 7.52,198.66 ; J9.4 9.34,200.48 ; J9.4 11.16,198.66 ; J9.4 9.34,196.84 ; 11.99,180.71 J10.14 11.05,181.65 ; S/PDIF.3 8.06,220.42 ; S/PDIF.3 8.06,222.27 ; S/PDIF.3 8.98,221.35 ; S/PDIF.3 7.13,221.35 ; 8.64,133.9 J133.5 6.82,135.72 ; PCE12.2 82.96,139.12 ; PCE12.2 84.84,139.12 ; PCE12.2 83.9,140.06 ; PCE12.2 83.9,138.18 ; J9.U4 11.11,201.73 ; J9.U4 12.99,201.73 ; J9.U4 12.05,202.67 ; J9.U4 12.05,200.79 ; 13.14,178.58 J10.4 14.96,176.76 ; 7.4,168.32 J125.16 ; J_TYPEC.5 1.2,152.18 ; J_TYPEC.6 1.2,141.03 ; 7.4,159.02 J125.2
  TOP w0.889: PCE652.2 218.01,165.18
  IN1 w0.102: 173.2,42.82 173.61,42.82 ; 75.54,107.82 75.46,108.2 ; 160.93,41.43 160.88,41.73 ; 173.58,34.14 173.69,33.73 ; 108.12,148.68 108.13,148.22 ; 218.59,99.34 218.34,99.62 ; 132.79,161.19 133.53,161.19 ; 206.5,60.71 206.15,60.76 ; 161.67,40.34 161.98,40.13 ; 223.27,118.54 223.27,118.85 ; 170.54,41.33 170.92,41.43 ; 211.73,55.98 212.17,56.01 ; 126.39,177.37 126.4,176.91 ; 161.44,40.31 161.14,40.06 ; 194.18,38.48 194.56,38.48
  IN1 w0.127: 111.73,165.23 111.73,164.69 ; 110.82,167.06 110.82,166.5 ; 114.48,172.85 114.48,172.36 ; 107.16,167.06 107.16,166.5 ; 113.56,146.82 113.56,146.44 ; 111.71,172.36 111.71,172.87 ; 113.55,145.99 113.55,145.45 ; 115.39,146.94 115.39,146.38 ; 113.56,172.85 113.56,172.42 ; 120.09,146.18 120.7,146.15 ; 111,146.18 111.53,146.18 ; 109.91,177.32 109.91,176.92 ; 117.45,145.29 117.93,145.29 ; 110.82,148.21 110.82,148.72 ; 117.22,145.97 117.22,145.47 ; 114.48,165.21 114.48,164.68 ; 108.99,176.56 108.99,176.02 ; 110.82,174.61 110.82,174.24 ; 113.56,163.32 113.56,162.89 ; 119.94,146.02 119.94,145.41 ; 109.17,147.07 109.7,147.07 ; 113.59,167 113.59,166.52 ; 110.11,176.71 110.59,176.71 ; 110.81,146.81 110.81,146.41 ; 111.73,148.66 111.73,148.21 ; 132.89,159.37 133.5,159.37 ; 110.82,146 110.82,145.52 ; 132.87,153.89 133.48,153.89 ; 110.82,176.5 110.82,176.1 ; 108.99,167.03 108.99,166.5 ; 109,165.13 109,164.69 ; 111.07,148.01 111.53,148.01 ; 107.16,165.13 107.16,164.71 ; 112.65,174.7 112.65,174.17 ; 109.19,146.15 109.68,146.15 ; 122.45,146.18 121.97,146.18 ; 112.65,163.32 112.65,162.84 ; 111.72,174.62 111.72,174.22 ; 110.83,168.78 110.83,168.37 ; 114.48,167 114.48,166.5 ; 109.91,146.38 109.91,146.86 ; 110.85,172.9 110.85,172.34 ; 114.48,168.83 114.48,168.38 ; 113.59,165.2 113.59,164.64 ; 109.19,176.71 109.7,176.71
  IN1 w0.152: 115.39,163.35 115.39,162.86 ; 114.48,146.43 114.48,146.84 ; 116.31,161.59 116.31,161.04 ; 114.73,146.18 115.14,146.18 ; 114.48,163.35 114.48,162.84 ; 116.31,167.03 116.31,166.47 ; 107.16,168.86 107.16,168.33 ; 112.65,145.44 112.65,146.91 ; 132.61,155.71 133.63,155.71 ; 114.48,161.52 114.48,160.99 ; 116.31,168.81 116.31,168.35 ; 108.99,168.33 108.99,168.91 ; 115.39,145.95 115.39,145.49 ; 110.58,177.62 110.1,177.62 ; 116.31,163.35 116.31,162.86 ; 116.32,159.7 116.32,159.17 ; 132.66,158.46 133.68,158.46 ; 113.33,146.18 111.96,146.18 ; 116.31,165.2 116.31,164.69
  IN1 w0.508: E16.10 179.25,5.51 ; E16.10 179.25,3.58 ; E16.10 178.32,4.59 ; E16.10 180.15,4.59 ; 57.71,71.12 57.73,71.09 ; 56.54,72.36 56.54,72.36 ; 55.47,71.12 55.45,71.09 ; P70.1 156.06,238.38
  IN1 w0.635: 16.2,125.65 J133.34 ; J133.34 16.99,125.6 16.33,125.6 ; J133.34 17.04,126.49 ; J133.34 17.04,124.81 ; SLOT1.A75 122.29,82.83 ; SLOT1.A75 121.45,83.67 ; SLOT1.A75 121.45,81.99 ; SLOT1.A75 120.61,82.83 ; CON_XMM2.112 202.52,130.8 ; CON_XMM2.112 201.76,130.03 ; CON_XMM2.112 201.76,131.56 ; SLOT4.A59 106.29,21.87 ; SLOT4.A59 105.47,21.84 105.47,21.06 ; SLOT4.A59 105.45,21.03 ; SLOT4.A59 104.61,21.87 ; SLOT4.A59 105.45,22.71 ; SLOT1.A34 79.61,84.83 ; SLOT1.A34 81.29,84.83 ; SLOT1.A34 80.45,85.67 ; SLOT1.A34 80.45,83.99 ; J10.2 22.1,178.7 ; J10.2 18.82,178.7 ; J10.2 20.46,177.62 ; J10.2 20.46,179.78 ; 6.71,212.69 J9.7 ; J9.7 8.53,214.51 ; J9.7 4.89,214.51 ; CON_XMM2.274 204.79,115.5 ; CON_XMM2.274 205.56,116.26 ; CON_XMM2.274 205.56,114.73 ; CON_XMM2.274 206.32,115.5 ; SLOT4.B43 89.45,18.61 ; SLOT4.B43 88.69,19.37 ; SLOT4.B43 90.21,19.37 ; SLOT4.B43 89.45,20.21 ; J_TYPEC.1 7.2,148.82 ; J_TYPEC.1 7.91,149.9 ; J_TYPEC.1 7.2,150.98 ; SLOT1.A20 65.61,84.83 ; SLOT1.A20 66.45,83.99 ; SLOT1.A20 67.29,84.83 ; SLOT1.A20 66.45,85.67 ; 66.45,43.38 SLOT3.A20 ; SLOT3.A20 67.26,44.19 ; SLOT3.A20 66.45,45 ; SLOT3.A20 65.64,44.19 ; 71.45,79.49 SLOT1.B25 ; SLOT1.B25 70.61,80.33 ; SLOT1.B25 71.45,81.17 ; SLOT1.B25 72.29,80.33 ; J133.44 20.24,126.49 ; J133.44 19.48,125.65 ; J133.44 20.24,124.81 ; J9.U4 12.99,201.73 ; J9.U4 12.05,200.79 ; J9.U4 12.05,202.67 ; J9.U4 11.11,201.73 ; 196.95,228.55 CON_XMM4.147 196.18,229.31 ; PCE18.2 196.54,74.3 ; PCE18.2 194.66,74.3 ; PCE18.2 195.6,73.36 ; PCE18.2 195.6,75.23 ; SLOT2.B13 59.45,60.82 ; SLOT2.B13 60.26,60.01 ; SLOT2.B13 58.64,60.01 ; SLOT2.B13 59.45,59.2 ; 203.19,191.15 CON_XMM2.191 ; CON_XMM2.191 204.72,191.15 ; CON_XMM2.191 203.96,191.91 ; CON_XMM2.191 203.96,190.38 ; 196.18,107.08 CON_XMM4.283 195.42,107.85 ; 7.4,168.32 J125.16 ; 120.31,105.44 PCE14.2 ; PCE14.2 121.25,106.38 ; PCE14.2 120.31,107.31 ; PCE14.2 119.37,106.38 ; 203.96,192.08 CON_XMM2.189 ; CON_XMM2.189 203.96,193.61 ; CON_XMM2.189 204.72,192.85 ; CON_XMM2.189 203.19,192.85 ; SLOT4.A63 109.47,21.9 109.47,22.68 ; SLOT4.A63 109.45,21.03 ; SLOT4.A63 110.29,21.87 ; SLOT4.A63 108.61,21.87 ; SLOT4.A63 109.45,22.71 ; CON_XMM2.182 205.56,198.03 ; CON_XMM2.182 205.56,199.56 ; CON_XMM2.182 206.32,198.8 ; CON_XMM2.182 204.79,198.8 ; J10.6 11.1,178.58 ; J10.6 9.28,180.4 ; J10.6 7.46,178.58 ; J10.6 9.28,176.76 ; 206.32,220.9 CON_XMM2.156 ; CON_XMM2.156 204.79,220.9 ; CON_XMM2.156 205.56,221.66 ; CON_XMM2.156 205.56,220.13 ; SLOT4.B65 111.45,20.21 ; SLOT4.B65 110.61,19.37 ; SLOT4.B65 111.45,18.53 ; SLOT4.B65 112.29,19.37 ; SLOT1.A78 123.61,84.83 ; SLOT1.A78 125.29,84.83 ; SLOT1.A78 124.45,85.67 ; SLOT1.A78 124.45,83.99 ; 67.45,79.49 SLOT1.B21 ; SLOT1.B21 68.29,80.33 ; SLOT1.B21 67.45,81.17 ; SLOT1.B21 66.61,80.33 ; 100.29,19.37 SLOT4.B53 ; SLOT4.B53 99.45,20.21 ; SLOT4.B53 98.61,19.37 ; 200.16,132.58 CON_XMM2.109 ; CON_XMM2.109 200.16,134.11 ; CON_XMM2.109 200.92,133.35 ; SLOT1.B22 68.45,79.17 ; SLOT1.B22 68.45,77.49 ; SLOT1.B22 69.29,78.33 ; SLOT1.B22 67.61,78.33 ; CON_XMM2.33 200.16,202.28 ; CON_XMM2.33 200.16,203.81 ; CON_XMM2.33 200.92,203.05 ; CON_XMM2.26 202.52,209 ; J_TYPEC.6 1.2,141.07 ; J_TYPEC.6 1.2,142.64 ; J_TYPEC.6 2.28,141.86 ; SLOT2.A31 76.64,62.51 ; SLOT2.A31 77.45,61.7 ; SLOT2.A31 78.26,62.51 ; SLOT2.A31 77.45,63.32 ; SLOT1.A12 59.29,84.83 ; SLOT1.A12 58.45,83.99 ; SLOT1.A12 58.45,85.67 ; SLOT4.B25 70.69,19.37 ; SLOT4.B25 71.45,18.61 ; SLOT4.B25 72.21,19.37 ; SLOT4.B25 71.45,20.21 ; CON_XMM2.55 200.16,185.11 ; CON_XMM2.55 200.92,184.35 ; CON_XMM2.55 200.16,183.58 ; SLOT1.B64 109.61,78.33 ; SLOT1.B64 110.45,77.49 ; SLOT1.B64 111.29,78.33 ; SLOT1.B64 110.45,79.17 ; SLOT4.B52 97.61,17.37 ; SLOT4.B52 99.29,17.37 ; SLOT4.B52 98.45,18.21 ; P24.9 237.13,102.98 ; P24.9 238.01,102.09 ; P24.9 237.13,101.2 ; 118.55,18.11 118.55,17.47 SLOT4.B72 ; 204.72,213.25 CON_XMM2.165 ; CON_XMM2.165 203.96,214.01 ; CON_XMM2.165 203.96,212.48 ; CON_XMM2.165 203.19,213.25 ; 205.56,113.03 CON_XMM2.276 ; CON_XMM2.276 204.79,113.8 ; CON_XMM2.276 205.56,114.56 ; CON_XMM2.276 206.32,113.8 ; 21.74,128.31 J133.47 ; J133.47 21.74,129.99 ; J133.47 20.79,129.15 20.78,129.16 ; J133.47 22.58,129.15 ; 59.45,79.49 SLOT1.B13 ; SLOT1.B13 60.29,80.33 ; SLOT1.B13 58.61,80.33 ; SLOT1.B13 59.45,81.17 ; CON_XMM2.193 203.96,190.21 ; CON_XMM2.193 204.72,189.45 ; CON_XMM2.193 203.19,189.45 ; CON_XMM2.193 203.96,188.68 ; CON_XMM2.53 200.16,186.81 ; CON_XMM2.53 200.16,185.28 ; CON_XMM2.53 200.92,186.05 ; SLOT4.A62 107.61,23.87 ; SLOT4.A62 108.45,23.03 ; SLOT4.A62 109.29,23.87 ; SLOT4.A62 108.45,24.71 ; 237.21,218.26 P29.1 ; P29.1 239.34,218.26 ; P29.1 238.27,219.25 ; P29.1 238.27,217.2 ; 206.32,117.2 CON_XMM2.272 ; CON_XMM2.272 205.56,117.96 ; CON_XMM2.272 205.56,116.43 ; CON_XMM2.272 204.79,117.2 ; 14.67,200.79 J9.U8 ; J9.U8 13.73,201.73 ; J9.U8 15.61,201.73 ; J9.U8 14.67,202.67 ; 204.72,226.85 CON_XMM2.149 ; CON_XMM2.149 203.19,226.85 ; CON_XMM2.149 203.96,227.61 ; CON_XMM2.149 203.96,226.08 ; SLOT1.B77 122.61,80.33 ; SLOT1.B77 123.45,79.49 ; SLOT1.B77 123.45,81.17 ; SLOT1.B77 124.29,80.33 ; SLOT1.B44 91.29,78.33 ; SLOT1.B44 89.61,78.33 ; SLOT1.B44 90.45,79.17 ; SLOT1.B44 90.45,77.49 ; CON_XMM2.241 203.96,144.31 ; CON_XMM2.241 204.72,143.55 ; CON_XMM2.241 203.19,143.55 ; CON_XMM2.241 203.96,142.78 ; 8.64,133.78 J133.5 ; J133.5 8.64,137.69 ; J133.5 8.59,135.77 6.95,135.77 ; PCE611.2 99.29,233.55 ; PCE611.2 100.23,234.49 ; PCE611.2 100.23,232.61 ; PCE611.2 101.17,233.55 ; 103.45,79.49 SLOT1.B57 ; SLOT1.B57 104.29,80.33 ; SLOT1.B57 102.61,80.33 ; SLOT1.B57 103.45,81.17 ; SLOT1.A63 110.29,82.83 ; SLOT1.A63 109.45,81.99 ; SLOT1.A63 108.61,82.83 ; SLOT1.A63 109.45,83.67 ; SLOT4.B7 51.45,18.61 ; SLOT4.B7 52.29,19.37 ; SLOT4.B7 50.61,19.37 ; SLOT4.B7 51.45,20.15 ; 202.52,129.09 CON_XMM2.114 201.76,129.86 ; CON_XMM2.42 202.52,195.4 ; CON_XMM2.42 201.76,196.16 ; CON_XMM2.42 201.76,194.63 ; 238.23,48.95 P62.1 ; P62.1 237.38,49.8 ; P62.1 239.08,49.8 ; P62.1 238.23,50.65 ; 15.02,209.98 J9.1 ; J9.1 13.2,211.8 ; J9.1 15.02,213.62 ; J9.1 16.84,211.8 ; CON_XMM2.120 202.52,124 ; 125.45,21.03 SLOT4.A79 ; SLOT4.A79 124.61,21.87 ; SLOT4.A79 125.45,22.71 ; SLOT4.A79 126.29,21.87 ; 124.59,239.37 P461.1 ; P461.1 124.59,237.31 ; P461.1 123.52,238.38 ; P461.1 125.58,238.38 ; SLOT1.B18 65.29,78.33 ; SLOT1.B18 64.45,79.17 ; SLOT1.B18 63.61,78.33 ; SLOT1.B18 64.45,77.49 ; SLOT4.B29 75.45,18.61 ; SLOT4.B29 75.45,20.21 ; SLOT4.B29 74.69,19.37 ; SLOT4.B29 76.21,19.37 ; H22.1 151.32,221.78 ; H22.1 148.8,219.27 ; H22.1 148.8,224.3 ; H22.1 146.29,221.78 ; J133.37 17.7,129.15 ; J133.37 18.54,129.99 ; J133.37 18.54,128.31 ; J133.37 19.3,129.15 ; 56.56,228.12 P3.2 ; P3.2 55.12,229.56 ; P3.2 56.56,230.99 ; P3.2 57.99,229.56 ; J10.3 16.78,191.72 ; J10.3 14.96,193.54 ; J10.3 14.96,189.9 ; CON_XMM2.147 203.19,228.55 ; CON_XMM2.147 203.96,227.78 ; CON_XMM2.147 204.72,228.55 ; CON_XMM2.147 203.96,229.31 ; SLOT1.A37 84.29,82.83 ; SLOT1.A37 83.45,81.99 ; SLOT1.A37 83.45,83.67 ; SLOT1.A37 82.61,82.83 ; PCE6208.2 112.37,207.29 ; PCE6208.2 112.37,205.42 ; PCE6208.2 113.31,206.35 ; PCE6208.2 111.43,206.35 ; J133.27 16.1,129.15 ; J133.27 15.34,128.31 ; J133.27 14.5,129.15 ; J133.27 15.34,129.99 ; P311.5 140.5,4.83 ; P311.5 142.64,4.83 ; P311.5 141.57,3.76 ; P311.5 141.57,5.89 ; CON_XMM2.39 200.16,197.18 ; CON_XMM2.39 200.16,198.71 ; CON_XMM2.39 200.92,197.94 ; CON_XMM2.257 203.96,130.71 ; CON_XMM2.257 203.19,129.95 ; CON_XMM2.257 203.96,129.18 ; CON_XMM2.257 204.72,129.95 ; CON_XMM2.259 203.96,127.48 ; CON_XMM2.259 203.96,129.01 ; CON_XMM2.259 204.72,128.25 ; CON_XMM2.259 203.19,128.25 ; PCE6211.2 83.44,164.24 ; PCE6211.2 84.38,163.3 ; PCE6211.2 82.5,163.3 ; PCE6211.2 83.44,162.36 ; SLOT4.A55 101.45,22.71 ; SLOT4.A55 101.45,21.03 ; SLOT4.A55 100.61,21.87 ; SLOT4.A55 102.29,21.87 ; SLOT4.A55 101.47,21.9 101.47,22.68 ; 122.45,77.49 SLOT1.B76 ; SLOT1.B76 121.61,78.33 ; SLOT1.B76 122.45,79.17 ; SLOT1.B76 123.29,78.33 ; J133.3 14.32,137.46 ; J133.3 16.06,135.72 ; J133.3 12.58,135.72 ; J133.3 14.32,133.91 ; P61.1 239.08,67.58 ; P61.1 238.23,68.43 ; P61.1 238.23,66.73 ; P61.1 237.38,67.58 ; SLOT2.B18 64.45,58.82 ; SLOT2.B18 65.26,58.01 ; SLOT2.B18 63.64,58.01 ; SLOT2.B18 64.45,57.2 ; 119.84,205.42 PCE6209.2 ; PCE6209.2 118.9,206.35 ; PCE6209.2 120.78,206.35 ; PCE6209.2 119.84,207.29 ; P150.12 238.24,126.15 ; P150.12 239.12,127.04 ; P150.12 239.12,125.26 ; P62.4 238.23,46.84 ; P62.4 239.08,45.99 ; P62.4 238.23,45.14 ; P62.4 237.38,45.99 ; 200.92,140.15 CON_XMM2.101 200.16,139.38 ; CON_XMM2.169 203.19,209.85 ; CON_XMM2.169 204.72,209.85 ; CON_XMM2.169 203.96,209.08 ; CON_XMM2.169 203.96,210.61 ; 104.45,23.03 SLOT4.A58 ; SLOT4.A58 104.45,24.71 ; SLOT4.A58 105.29,23.87 ; SLOT4.A58 104.47,23.9 104.47,24.68 ; SLOT4.A58 103.61,23.87 ; SLOT4.A38 84.45,23.11 ; SLOT4.A38 85.21,23.87 ; SLOT4.A38 84.45,24.71 ; SLOT4.A38 83.69,23.87 ; 91.29,17.37 SLOT4.B44 ; SLOT4.B44 90.45,18.21 ; SLOT4.B44 89.61,17.37 ; PCE23.2 40.6,71.12 ; PCE23.2 42.48,71.12 ; PCE23.2 41.54,72.06 ; SLOT4.B72 118.45,18.21 ; SLOT4.B72 117.61,17.37 ; SLOT4.B72 119.29,17.37 ; SLOT4.B72 118.45,16.53 ; 7.4,159.02 J125.2 8.14,158.28 ; SLOT4.A66 112.47,23.9 112.47,24.68 ; SLOT4.A66 113.29,23.87 ; SLOT4.A66 112.45,23.03 ; SLOT4.A66 111.61,23.87 ; SLOT4.A66 112.45,24.71 ; SLOT4.B76 123.29,17.37 ; SLOT4.B76 122.45,16.53 ; SLOT4.B76 122.45,18.21 ; SLOT4.B76 121.61,17.37 ; 90.13,182.32 PCE6201.2 ; PCE6201.2 89.2,183.26 ; PCE6201.2 90.13,184.2 ; PCE6201.2 91.07,183.26 ; SLOT2.A20 66.45,63.7 ; SLOT2.A20 67.26,64.51 ; SLOT2.A20 66.45,65.32 ; SLOT2.A20 65.64,64.51 ; 13.45,234.09 S/PDIF.4 ; S/PDIF.4 11.41,234.9 ; S/PDIF.4 11.41,232.97 ; 238.56,171.67 CON4.18 ; CON4.18 239.92,173.03 ; CON4.18 238.56,174.39 ; CON4.18 237.21,173.03 ; SLOT4.B39 85.45,18.61 ; SLOT4.B39 84.69,19.37 ; SLOT4.B39 85.45,20.21 ; SLOT4.B39 86.21,19.37 ; SLOT1.A42 88.45,85.67 ; SLOT1.A42 89.29,84.83 ; SLOT1.A42 88.45,83.99 ; SLOT1.A42 87.61,84.83 ; 69.49,4.81 P189.8 69.49,6.74 ; SLOT1.B60 106.45,79.17 ; SLOT1.B60 105.61,78.33 ; SLOT1.B60 107.29,78.33 ; SLOT1.B60 106.45,77.49 ; P24.14 239.12,98.98 ; P24.14 239.12,97.2 ; P24.14 238.24,98.09 ; J133.24 13.08,125.65 ; J133.24 13.84,126.49 ; J133.24 13.84,124.81 ; J10.34 18.17,181.65 ; J10.34 17.23,182.59 ; J10.34 16.29,181.65 ; J10.34 17.23,180.71 ; 93.45,79.49 SLOT1.B47 ; SLOT1.B47 94.29,80.33 ; SLOT1.B47 92.61,80.33 ; SLOT1.B47 93.45,81.17 ; SLOT4.A74 121.29,23.87 ; SLOT4.A74 119.61,23.87 ; SLOT4.A74 120.45,23.03 ; SLOT4.A74 120.45,24.71 ; SLOT4.A12 57.61,23.87 ; SLOT4.A12 59.29,23.87 ; SLOT4.A12 58.45,24.63 ; SLOT4.A12 58.45,23.11 ; J9.4 9.34,200.48 ; J9.4 11.16,198.66 ; J9.4 7.52,198.66 ; J9.4 9.34,196.84 ; J_TYPEC.2 7.91,142.96 ; J_TYPEC.2 7.2,141.88 ; J_TYPEC.2 7.2,144.04 ; SLOT3.B13 60.26,39.69 ; SLOT3.B13 59.45,38.88 ; SLOT3.B13 58.64,39.69 ; SLOT3.B13 59.45,40.5 ; CON_CBAT.2 162.25,101.75 ; CON_CBAT.2 163.23,102.73 ; CON_CBAT.2 163.23,100.77 ; SLOT2.B25 71.45,60.82 ; SLOT2.B25 71.45,59.2 ; SLOT2.B25 70.64,60.01 ; SLOT2.B25 72.26,60.01 ; J9.3 9.34,213.62 ; J9.3 11.16,211.8 ; J9.3 9.34,209.98 ; J9.3 7.52,211.8 ; 188.31,226.85 CON_XMM1.149 ; CON_XMM1.149 187.55,227.61 ; CON_XMM1.149 186.79,226.85 ; UCE12.2 226.17,128.27 ; UCE12.2 226.17,130.05 ; UCE12.2 225.28,129.16 ; UCE12.2 227.06,129.16 ; SLOT1.A15 62.29,82.83 ; SLOT1.A15 61.45,81.99 ; SLOT1.A15 60.61,82.83 ; SLOT1.A15 61.45,83.67 ; 104.29,19.37 SLOT4.B57 ; SLOT4.B57 102.61,19.37 ; SLOT4.B57 103.45,20.21 ; 238.23,9.58 P64.4 ; P64.4 237.38,10.43 ; P64.4 238.23,11.28 ; 69.45,81.99 SLOT1.A23 ; SLOT1.A23 70.29,82.83 ; SLOT1.A23 68.61,82.83 ; SLOT1.A23 69.45,83.67 ; SLOT4.A34 80.45,24.71 ; SLOT4.A34 79.69,23.87 ; SLOT4.A34 80.45,23.11 ; SLOT4.A34 81.21,23.87 ; CON_XMM2.283 203.19,107.85 ; CON_XMM2.283 203.96,107.08 ; CON_XMM2.283 204.72,107.85 ; CON_XMM2.283 203.96,108.61 ; 75.45,79.49 SLOT1.B29 ; SLOT1.B29 74.61,80.33 ; SLOT1.B29 76.29,80.33 ; SLOT1.B29 75.45,81.17 ; PCE6206.2 97.43,207.29 ; PCE6206.2 96.49,206.35 ; PCE6206.2 98.37,206.35 ; PCE6206.2 97.43,205.42 ; CON_XMM2.50 202.52,188.59 ; CON_XMM2.50 201.76,187.83 ; CON_XMM2.50 201.76,189.36 ; 92.64,19.4 93.42,19.4 SLOT4.B47 ; SLOT4.B80 126.45,18.21 ; SLOT4.B80 125.61,17.37 ; SLOT4.B80 126.45,16.53 ; SLOT4.B80 127.29,17.37 ; CON_XMM2.246 205.56,140.06 ; CON_XMM2.246 205.56,138.53 ; CON_XMM2.246 204.79,139.3 ; CON_XMM2.246 206.32,139.3 ; TUCE1.2 23.41,159.87 ; TUCE1.2 21.53,159.87 ; TUCE1.2 22.47,158.93 ; TUCE1.2 22.47,160.81 ; PCE6205.2 84.38,179.3 ; PCE6205.2 82.5,179.3 ; PCE6205.2 83.44,180.24 ; PCE6205.2 83.44,178.36 ; CON_XMM2.138 202.52,108.7 ; 58.45,63.7 SLOT2.A12 ; SLOT2.A12 59.26,64.51 ; SLOT2.A12 58.45,65.32 ; CON_XMM2.254 205.56,131.73 ; CON_XMM2.254 206.32,132.5 ; CON_XMM2.254 204.79,132.5 ; CON_XMM2.254 205.56,133.26 ; 237.38,6.62 P64.7 238.23,7.47 ; 202.52,190.3 CON_XMM2.48 201.76,189.53 ; P62.7 238.23,43.03 ; P62.7 239.08,42.18 ; P62.7 237.38,42.18 ; P62.7 238.23,41.33 ; 67.45,38.88 SLOT3.B21 ; SLOT3.B21 67.45,40.5 ; SLOT3.B21 68.26,39.69 ; SLOT3.B21 66.64,39.69 ; H13.1 36.67,92.74 ; H13.1 39.43,89.98 ; H13.1 33.91,89.98 ; H13.1 36.67,87.23 ; SLOT1.B16 62.45,79.17 ; SLOT1.B16 61.61,78.33 ; SLOT1.B16 62.45,77.49 ; SLOT1.B16 63.29,78.33 ; CON_XMM2.94 202.52,146.1 ; CON_XMM2.94 201.76,146.86 ; CON_XMM2.94 201.76,145.33 ; CON_XMM2.94 200.99,146.1 ; P63.7 239.08,24.4 ; P63.7 237.38,24.4 ; P63.7 238.23,25.25 ; P63.7 238.23,23.55 ; CON_XMM2.180 205.56,201.26 ; CON_XMM2.180 205.56,199.73 ; CON_XMM2.180 204.79,200.5 ; CON_XMM2.180 206.32,200.5 ; CON_XMM2.198 205.56,184.43 ; CON_XMM2.198 204.79,185.2 ; CON_XMM2.198 205.56,185.96 ; CON_XMM2.198 206.32,185.2 ; CON_XMM2.105 200.92,136.75 ; CON_XMM2.105 200.16,137.51 ; CON_XMM2.105 200.16,135.98 ; CON_XMM1.4 185.35,228.46 ; CON_XMM1.4 185.35,226.93 ; CON_XMM1.4 186.11,227.69 ; CON_XMM1.4 184.59,227.69 ; 62.45,57.2 SLOT2.B16 ; SLOT2.B16 62.45,58.82 ; SLOT2.B16 63.26,58.01 ; SLOT2.B16 61.64,58.01 ; SLOT1.A45 91.45,83.67 ; SLOT1.A45 92.29,82.83 ; SLOT1.A45 90.61,82.83 ; SLOT1.A45 91.45,81.99 ; 92.45,83.99 SLOT1.A46 ; SLOT1.A46 91.61,84.83 ; SLOT1.A46 93.29,84.83 ; SLOT1.A46 92.45,85.67 ; 84.45,83.99 SLOT1.A38 ; SLOT1.A38 83.61,84.83 ; SLOT1.A38 84.45,85.67 ; SLOT1.A38 85.29,84.83 ; SLOT2.A18 65.26,64.51 ; SLOT2.A18 64.45,63.7 ; SLOT2.A18 64.45,65.32 ; SLOT2.A18 63.64,64.51 ; H20.1 93.09,221.78 ; H20.1 95.6,219.27 ; H20.1 98.12,221.78 ; H20.1 95.6,224.3 ; SLOT4.B16 63.21,17.37 ; SLOT4.B16 62.45,16.61 ; SLOT4.B16 61.52,17.37 ; SLOT4.B16 62.45,18.21 ; 178.34,227.69 CON_XMM3.4 ; CON_XMM3.4 177.58,228.46 ; CON_XMM3.4 177.58,226.93 ; CON_XMM3.4 176.82,227.69 ; 238.56,167.47 CON4.17 ; CON4.17 239.92,168.83 ; CON4.17 238.56,170.19 ; CON4.17 237.21,168.83 ; PCE17.2 211.07,100.31 ; PCE17.2 210.13,101.25 ; PCE17.2 209.19,100.31 ; PCE17.2 210.13,99.37 ; 9.54,171.26 J125.19 10.28,170.52 ; 193.98,107.93 CON_XMM4.138 ; SLOT3.A15 62.26,42.19 ; SLOT3.A15 60.64,42.19 ; SLOT3.A15 61.45,41.38 ; SLOT3.A15 61.45,43 ; SLOT2.A28 74.45,65.32 ; SLOT2.A28 73.64,64.51 ; SLOT2.A28 74.45,63.7 ; SLOT2.A28 75.26,64.51 ; CON_XMM1.2 185.35,230.16 ; CON_XMM1.2 184.59,229.4 ; CON_XMM1.2 186.11,229.4 ; CON_XMM1.2 185.35,228.63 ; SLOT3.B7 51.45,40.5 ; SLOT3.B7 52.26,39.69 ; SLOT3.B7 50.64,39.69 ; SLOT3.B7 51.45,38.88 ; P150.6 238.24,132.15 ; P150.6 239.12,133.04 ; P150.6 239.12,131.26 ; 104.9,205.42 PCE6207.2 ; PCE6207.2 103.96,206.35 ; PCE6207.2 104.9,207.29 ; PCE6207.2 105.84,206.35 ; SLOT2.A23 69.45,63.32 ; SLOT2.A23 70.26,62.51 ; SLOT2.A23 69.45,61.7 ; SLOT2.A23 68.64,62.51 ; SLOT3.B16 61.64,37.69 ; SLOT3.B16 63.26,37.69 ; SLOT3.B16 62.45,38.5 ; SLOT3.B16 62.45,36.88 ; SLOT4.B13 60.11,19.37 60.16,19.42 ; SLOT4.B13 58.69,19.37 ; SLOT4.B13 59.45,18.61 ; SLOT4.B13 59.45,20.21 ; 200.92,182.65 CON_XMM2.57 200.16,183.41 ; CON_XMM2.195 203.96,188.51 ; CON_XMM2.195 204.72,187.75 ; CON_XMM2.195 203.96,186.98 ; CON_XMM2.195 203.19,187.75 ; 71.49,6.74 P189.9 71.49,4.81 ; SLOT4.B47 93.45,20.21 ; SLOT4.B47 93.47,19.4 94.26,19.4 ; CON_XMM2.98 202.52,142.7 ; 8.82,171.88 J125.22 ; J125.22 8.82,174.06 ; J125.22 6.93,172.97 ; J125.22 10.71,172.97 ; 116.45,83.99 SLOT1.A70 ; SLOT1.A70 117.29,84.83 ; SLOT1.A70 116.45,85.67 ; SLOT1.A70 115.61,84.83 ; CON_XMM4.2 194.75,229.4 ; CON_XMM4.2 193.98,230.16 ; CON_XMM4.2 193.22,229.4 ; CON_XMM4.2 193.98,228.63 ; SLOT4.A45 91.45,22.71 ; SLOT4.A45 91.45,21.03 ; SLOT4.A45 92.29,21.87 ; SLOT4.A45 90.53,21.87 ; SLOT2.A1 44.64,62.51 ; SLOT2.A1 45.45,61.7 ; SLOT2.A1 46.26,62.51 ; SLOT2.A1 45.45,63.32 ; SLOT3.A18 63.64,44.19 ; SLOT3.A18 64.45,45 ; SLOT3.A18 64.45,43.38 ; SLOT3.A18 65.26,44.19 ; 206.32,197.1 CON_XMM2.184 ; CON_XMM2.184 205.56,197.86 ; CON_XMM2.184 205.56,196.33 ; CON_XMM2.184 204.79,197.1 ; 50.64,60.01 SLOT2.B7 ; SLOT2.B7 51.45,59.2 ; SLOT2.B7 52.26,60.01 ; SLOT2.B7 51.45,60.82 ; 48.45,77.49 SLOT1.B4 ; SLOT1.B4 47.61,78.33 ; SLOT1.B4 48.45,79.17 ; SLOT1.B4 49.29,78.33 ; SLOT4.B64 111.29,17.37 ; SLOT4.B64 110.45,18.21 ; SLOT4.B64 110.45,16.53 ; 120.45,83.99 SLOT1.A74 ; SLOT1.A74 119.61,84.83 ; SLOT1.A74 121.29,84.83 ; 72.45,77.49 SLOT1.B26 ; SLOT1.B26 72.45,79.17 ; SLOT1.B26 73.29,78.33 ; SLOT1.B26 71.61,78.33 ; 115.45,18.53 SLOT4.B69 ; SLOT4.B69 115.45,20.21 ; SLOT4.B69 116.29,19.37 ; SLOT4.B69 114.61,19.37 ; XCE15.2 55.27,30.61 ; XCE15.2 56.15,29.72 ; XCE15.2 57.04,30.61 ; XCE15.2 56.15,31.5 ; SLOT1.A71 118.29,82.83 ; SLOT1.A71 117.45,81.99 ; SLOT1.A71 116.61,82.83 ; SLOT1.A71 117.45,83.67 ; CON_XMM2.187 203.19,194.55 ; CON_XMM2.187 203.96,195.31 ; CON_XMM2.187 203.96,193.78 ; CON_XMM2.187 204.72,194.55 ; PC640631.2 227.33,170.42 ; PC640631.2 226.44,171.31 ; PC640631.2 225.55,170.42 ; PC640631.2 226.44,169.53 ; 75.45,38.88 SLOT3.B29 ; SLOT3.B29 74.64,39.69 ; SLOT3.B29 75.45,40.5 ; SLOT3.B29 76.26,39.69 ; CON_XMM2.268 205.56,119.83 ; CON_XMM2.268 206.32,120.6 ; CON_XMM2.268 205.56,121.36 ; CON_XMM2.268 204.79,120.6 ; SLOT4.A15 62.21,21.87 ; SLOT4.A15 61.45,21.1 ; SLOT4.A15 60.69,21.87 ; SLOT4.A15 61.45,22.71 ; 120.61,21.87 SLOT4.A75 ; SLOT4.A75 121.45,22.71 ; SLOT4.A75 122.29,21.87 ; SLOT4.A75 121.45,21.03 ; CON_XMM2.167 203.96,212.31 ; CON_XMM2.167 204.72,211.55 ; CON_XMM2.167 203.19,211.55 ; CON_XMM2.167 203.96,210.78 ; SLOT4.A20 66.45,24.63 ; SLOT4.A20 67.21,23.87 ; SLOT4.A20 66.45,23.03 ; SLOT4.A20 65.61,23.87 ; SLOT1.A55 101.45,83.67 ; SLOT1.A55 101.45,81.99 ; SLOT1.A55 102.29,82.83 ; SLOT1.A55 100.61,82.83 ; SLOT1.B61 106.61,80.33 ; SLOT1.B61 107.45,81.17 ; SLOT1.B61 108.29,80.33 ; SLOT1.B61 107.45,79.49 ; P150.7 237.13,129.26 ; P150.7 236.24,130.15 ; P150.7 237.13,131.04 ; P150.7 238.01,130.15 ; 19.39,194.14 J9.6 ; J9.6 21.21,195.96 ; J9.6 19.39,197.77 ; J9.6 17.57,195.96 ; J133.1 21.7,135.72 ; J133.1 19.82,134.68 ; J133.1 17.94,135.72 ; J133.1 19.82,136.76 ; 238.23,62.92 P61.4 ; P61.4 239.08,63.77 ; P61.4 237.38,63.77 ; P61.4 238.23,64.62 ; SLOT1.B43 90.29,80.33 ; SLOT1.B43 89.45,81.17 ; SLOT1.B43 88.61,80.33 ; SLOT1.B43 89.45,79.49 ; CON_XMM3.2 177.58,230.16 ; CON_XMM3.2 176.82,229.4 ; CON_XMM3.2 177.58,228.63 ; CON_XMM3.2 178.34,229.4 ; 9.28,189.9 J10.5 ; J10.5 7.46,191.72 ; J10.5 9.28,193.54 ; J10.5 11.1,191.72 ; SLOT4.B77 124.29,19.37 ; SLOT4.B77 122.61,19.37 ; SLOT4.B77 123.45,20.21 ; SLOT4.B77 123.45,18.53 ; 71.45,38.88 SLOT3.B25 ; SLOT3.B25 70.64,39.69 ; SLOT3.B25 71.45,40.5 ; SLOT3.B25 72.26,39.69 ; PCE6203.2 91.07,167.29 ; PCE6203.2 90.13,166.35 ; PCE6203.2 90.13,168.23 ; PCE6203.2 89.2,167.29 ; 19.39,212.69 J9.5 ; J9.5 19.39,216.32 ; J9.5 17.57,214.51 ; J9.5 21.21,214.51 ; SLOT4.A28 74.45,23.11 ; SLOT4.A28 75.21,23.87 ; SLOT4.A28 73.69,23.87 ; SLOT4.A28 74.45,24.71 ; SLOT1.B56 101.61,78.33 ; SLOT1.B56 103.29,78.33 ; SLOT1.B56 102.45,77.49 ; SLOT1.B56 102.45,79.17 ; SLOT1.A62 107.61,84.83 ; SLOT1.A62 109.29,84.83 ; SLOT1.A62 108.45,83.99 ; SLOT3.A1 46.26,42.19 ; SLOT3.A1 44.64,42.19 ; SLOT3.A1 45.45,43 ; SLOT3.A1 45.45,41.38 ; P70.1 154,238.38 ; P70.1 155.07,239.45 ; P70.1 155.07,237.31 ; SLOT1.A54 101.29,84.83 ; SLOT1.A54 99.61,84.83 ; SLOT1.A54 100.45,83.99 ; SLOT2.A15 60.64,62.51 ; SLOT2.A15 61.45,61.7 ; SLOT2.A15 62.26,62.51 ; SLOT2.A15 61.45,63.32 ; SLOT1.B49 95.45,81.17 ; SLOT1.B49 95.45,79.49 ; SLOT1.B49 94.61,80.33 ; SLOT1.B49 96.29,80.33 ; CON_XMM1.147 186.79,228.55 ; CON_XMM1.147 188.31,228.55 ; CON_XMM1.147 187.55,227.78 ; CON_XMM1.147 187.55,229.31 ; 180.54,226.85 CON_XMM3.149 ; CON_XMM3.149 179.78,227.61 ; CON_XMM3.149 179.02,226.85 ; CON_XMM1.140 184.59,107 ; CON_XMM1.140 186.11,107 ; CON_XMM1.140 185.35,106.23 ; SLOT1.B68 114.45,79.17 ; SLOT1.B68 114.45,77.49 ; SLOT1.B68 115.29,78.33 ; SLOT1.B68 113.61,78.33 ; CON_XMM2.250 205.56,136.66 ; CON_XMM2.250 206.32,135.9 ; CON_XMM2.250 205.56,135.13 ; CON_XMM2.250 204.79,135.9 ; SLOT1.A18 65.29,84.83 ; SLOT1.A18 64.45,85.67 ; SLOT1.A18 64.45,83.99 ; SLOT1.A18 63.61,84.83 ; 206.32,146.1 CON_XMM2.238 ; CON_XMM2.238 205.56,146.86 ; CON_XMM2.238 204.79,146.1 ; CON_XMM2.238 205.56,145.33 ; 202.52,193.7 CON_XMM2.44 201.76,194.46 ; SLOT1.B80 125.61,78.33 ; SLOT1.B80 126.45,79.17 ; SLOT1.B80 126.45,77.49 ; SLOT1.B80 127.29,78.33 ; PCE6212.2 209.58,138.59 ; PCE6212.2 210.52,137.65 ; PCE6212.2 210.52,139.53 ; PCE6212.2 211.46,138.59 ; GPU_PWR.1 56.31,107.23 ; GPU_PWR.1 57.67,105.87 ; GPU_PWR.1 56.31,104.52 ; GPU_PWR.1 54.95,105.87 ; SLOT4.B4 47.61,17.37 ; SLOT4.B4 49.29,17.37 ; SLOT4.B4 48.45,18.13 ; SLOT4.B4 48.45,16.61 ; 96.26,19.4 95.47,19.4 SLOT4.B49 ; 100.45,23.03 SLOT4.A54 ; SLOT4.A54 100.47,23.9 100.47,24.68 ; SLOT4.A54 100.45,24.71 ; SLOT4.A54 99.61,23.87 ; SLOT4.A54 101.29,23.87 ; 68.91,104.52 GPU_PWR.4 ; GPU_PWR.4 70.27,105.87 ; GPU_PWR.4 68.91,107.23 ; GPU_PWR.4 67.55,105.87 ; PCE591.2 50.95,218.24 ; PCE591.2 50.02,217.3 ; PCE591.2 51.89,217.3 ; PCE591.2 50.95,216.36 ; PCE651.2 214.76,211.79 ; PCE651.2 213.82,212.73 ; PCE651.2 213.82,210.85 ; PCE651.2 212.88,211.79 ; SLOT2.A24 70.45,63.7 ; SLOT2.A24 70.45,65.32 ; SLOT2.A24 71.26,64.51 ; SLOT2.A24 69.64,64.51 ; 2.34,155.38 J125.23 ; J125.23 2.34,157.56 ; J125.23 3.98,156.47 ; P63.1 237.38,32.02 ; P63.1 238.23,32.87 ; P63.1 239.08,32.02 ; P63.1 238.23,31.17 ; 87.45,81.99 SLOT1.A41 ; SLOT1.A41 87.45,83.67 ; SLOT1.A41 88.29,82.83 ; SLOT1.A41 86.61,82.83 ; P63.4 237.38,28.21 ; P63.4 238.23,29.06 ; P63.4 239.08,28.21 ; 218.66,122.33 UCE11.2 ; UCE11.2 218.66,124.1 ; UCE11.2 219.55,123.22 ; UCE11.2 217.77,123.22 ; SLOT4.B36 83.29,17.37 ; SLOT4.B36 81.69,17.37 ; SLOT4.B36 82.45,16.53 ; SLOT4.B36 82.45,18.21 ; SLOT1.B39 86.29,80.33 ; SLOT1.B39 85.45,81.17 ; SLOT1.B39 85.45,79.49 ; SLOT1.B39 84.61,80.33 ; CON_XMM2.162 205.56,215.03 ; CON_XMM2.162 205.56,216.56 ; CON_XMM2.162 206.32,215.8 ; CON_XMM2.162 204.79,215.8 ; SLOT4.B35 82.21,19.37 ; SLOT4.B35 81.45,20.21 ; SLOT4.B35 80.69,19.37 ; SLOT4.B35 81.45,18.61 ; SLOT3.B18 65.26,37.69 ; SLOT3.B18 64.45,36.88 ; SLOT3.B18 63.64,37.69 ; SLOT3.B18 64.45,38.5 ; 94.61,21.87 SLOT4.A49 ; SLOT4.A49 96.29,21.87 ; SLOT4.A49 95.45,22.71 ; SLOT3.A23 68.64,42.19 ; SLOT3.A23 70.26,42.19 ; SLOT3.A23 69.45,43 ; SLOT3.A23 69.45,41.38 ; 200.16,120.68 CON_XMM2.123 200.92,121.45 ; CON_XMM3.147 179.78,227.78 ; CON_XMM3.147 180.54,228.55 ; CON_XMM3.147 179.78,229.31 ; CON_XMM3.147 179.02,228.55 ; SLOT4.A24 69.69,23.87 ; SLOT4.A24 70.45,23.03 ; SLOT4.A24 70.45,24.71 ; SLOT4.A24 70.41,23.83 70.41,23.15 ; SLOT4.A24 71.21,23.87 ; SLOT1.A79 125.45,83.67 ; SLOT1.A79 126.29,82.83 ; SLOT1.A79 125.45,81.99 ; SLOT1.A79 124.61,82.83 ; XCE2.2 57.71,71.12 ; XCE2.2 56.54,70.11 ; XCE2.2 55.47,71.12 ; XCE2.2 56.54,72.36 ; P458.1 136.78,239.45 ; P458.1 136.78,237.31 ; P458.1 135.71,238.38 ; P458.1 137.85,238.38 ; 98.45,77.49 SLOT1.B52 ; SLOT1.B52 99.29,78.33 ; SLOT1.B52 98.45,79.17 ; SLOT1.B52 97.61,78.33 ; CON4.19 238.56,178.59 ; CON4.19 238.56,175.87 ; CON4.19 237.21,177.23 ; CON4.19 239.92,177.23 ; SLOT1.B69 115.45,81.17 ; SLOT1.B69 115.45,79.49 ; SLOT1.B69 116.29,80.33 ; SLOT1.B69 114.61,80.33 ; CON_XMM3.140 176.82,107 ; CON_XMM3.140 177.58,106.23 ; CON_XMM3.140 178.34,107 ; SLOT4.A37 82.69,21.87 ; SLOT4.A37 83.45,22.71 ; SLOT4.A37 83.45,21.11 ; SLOT4.A37 84.21,21.87 ; CON_XMM2.6 202.52,226 ; SLOT4.A71 118.29,21.87 ; SLOT4.A71 117.45,22.71 ; SLOT4.A71 117.45,21.03 ; SLOT4.A71 116.61,21.87 ; CON_XMM2.176 204.79,203.9 ; CON_XMM2.176 205.56,204.66 ; CON_XMM2.176 205.56,203.13 ; CON_XMM2.176 206.32,203.9 ; SLOT1.A31 78.29,82.83 ; SLOT1.A31 76.61,82.83 ; SLOT1.A31 77.45,81.99 ; SLOT1.A31 77.45,83.67 ; 200.92,114.65 CON_XMM2.131 200.16,115.41 ; J133.17 12.14,129.99 ; J133.17 12.14,128.31 ; J133.17 12.9,129.15 ; J133.17 11.3,129.15 ; SLOT4.B73 118.61,19.37 ; SLOT4.B73 119.45,20.21 ; SLOT4.B73 119.45,18.53 ; J9.8 8.53,195.96 ; J9.8 6.71,194.14 ; J9.8 4.89,195.96 ; J9.8 6.71,197.77 ; 204.79,222.6 CON_XMM2.154 ; CON_XMM2.154 205.56,223.36 ; CON_XMM2.154 205.56,221.83 ; CON_XMM2.154 206.32,222.6 ; P61.7 238.23,60.81 ; P61.7 237.38,59.96 ; P61.7 238.23,59.11 ; P61.7 239.08,59.96 ; 72.45,36.88 SLOT3.B26 ; SLOT3.B26 72.45,38.5 ; SLOT3.B26 73.26,37.69 ; SLOT3.B26 71.64,37.69 ; CON_XMM2.202 205.56,182.56 ; CON_XMM2.202 206.32,181.8 ; CON_XMM2.202 204.79,181.8 ; CON_XMM2.202 205.56,181.03 ; SLOT1.B53 100.29,80.33 ; SLOT1.B53 99.45,79.49 ; SLOT1.B53 99.45,81.17 ; SLOT1.B53 98.61,80.33 ; PCE12.2 84.84,139.12 ; PCE12.2 83.9,140.06 ; PCE12.2 82.96,139.12 ; PCE12.2 83.9,138.18 ; SLOT4.A23 70.21,21.87 ; SLOT4.A23 68.69,21.87 ; SLOT4.A23 69.45,22.71 ; SLOT4.A23 69.45,21.11 ; CON4.5 234.42,168.83 ; CON4.5 233.06,167.47 ; CON4.5 233.06,170.19 ; CON4.5 231.71,168.83 ; 200.16,137.68 CON_XMM2.103 ; CON_XMM2.103 200.16,139.21 ; CON_XMM2.103 200.92,138.45 ; SLOT1.A59 106.29,82.83 ; SLOT1.A59 104.61,82.83 ; SLOT1.A59 105.45,81.99 ; SLOT1.A59 105.45,83.67 ; SLOT4.B32 78.45,16.61 ; SLOT4.B32 79.17,17.37 ; SLOT4.B32 78.45,18.21 ; SLOT4.B32 77.69,17.37 ; CON4.15 238.56,161.79 ; CON4.15 237.21,160.43 ; CON4.15 239.92,160.43 ; CON4.15 238.56,159.07 ; PCE11.2 48.01,146.2 ; PCE11.2 46.13,146.2 ; PCE11.2 47.07,147.14 ; PCE11.2 47.07,145.26 ; 97.45,21.03 SLOT4.A51 ; SLOT4.A51 96.61,21.87 ; SLOT4.A51 97.45,22.71 ; SLOT4.A51 98.29,21.87 ; 200.92,201.35 CON_XMM2.35 200.16,202.11 ; PCE13.2 92.08,147.22 ; PCE13.2 91.14,146.28 ; PCE13.2 93.01,146.28 ; PCE13.2 92.08,145.34 ; 47.64,64.51 SLOT2.A4 ; SLOT2.A4 48.45,65.32 ; SLOT2.A4 49.26,64.51 ; SLOT2.A4 48.45,63.7 ; SLOT4.A70 117.29,23.87 ; SLOT4.A70 116.45,23.03 ; SLOT4.A70 115.61,23.87 ; SLOT4.A70 116.45,24.71 ; 46.89,175.97 PCE601.2 47.83,176.91 ; SLOT3.A27 72.64,42.19 ; SLOT3.A27 74.26,42.19 ; SLOT3.A27 73.45,41.38 ; SLOT3.A27 73.45,43 ; 96.61,82.83 SLOT1.A51 ; SLOT1.A51 97.45,81.99 ; SLOT1.A51 98.29,82.83 ; SLOT1.A51 97.45,83.67 ; SLOT2.B22 69.26,58.01 ; SLOT2.B22 67.64,58.01 ; SLOT2.B22 68.45,57.2 ; SLOT2.B22 68.45,58.82 ; H21.1 57.4,210.86 ; H21.1 62.43,210.86 ; H21.1 59.92,213.38 ; H21.1 59.92,208.35 ; SLOT1.A24 70.45,85.67 ; SLOT1.A24 71.29,84.83 ; SLOT1.A24 69.61,84.83 ; SLOT1.A24 70.45,83.99 ; 51.44,79.3 51.45,79.31 SLOT1.B7 ; SLOT1.B32 77.61,78.33 ; SLOT1.B32 78.45,77.49 ; SLOT1.B32 78.45,79.17 ; SLOT1.B32 79.29,78.33 ; SLOT4.A18 65.29,23.87 ; SLOT4.A18 63.69,23.87 ; SLOT4.A18 64.45,23.03 ; SLOT4.A18 64.45,24.71 ; CON_XMM2.171 203.19,208.15 ; CON_XMM2.171 204.72,208.15 ; CON_XMM2.171 203.96,208.91 ; CON_XMM2.171 203.96,207.38 ; SLOT3.B32 79.26,37.69 ; SLOT3.B32 78.45,38.5 ; SLOT3.B32 77.64,37.69 ; SLOT3.B32 78.45,36.88 ; 90.13,174.53 PCE6202.2 ; PCE6202.2 91.07,175.47 ; PCE6202.2 89.2,175.47 ; CON_XMM2.173 203.19,206.45 ; CON_XMM2.173 204.72,206.45 ; CON_XMM2.173 203.96,207.21 ; CON_XMM2.173 203.96,205.68 ; SLOT4.B18 64.45,16.61 ; SLOT4.B18 64.45,18.21 ; SLOT4.B18 65.29,17.37 ; SLOT4.B18 63.69,17.37 ; SLOT1.B65 111.45,81.17 ; SLOT1.B65 110.61,80.33 ; SLOT1.B65 111.45,79.49 ; SLOT1.B65 112.29,80.33 ; UCE10.2 35.2,196.73 ; UCE10.2 36.14,197.67 ; UCE10.2 36.14,195.79 ; UCE10.2 37.08,196.73 ; CON_XMM2.248 204.79,137.6 ; CON_XMM2.248 205.56,138.36 ; CON_XMM2.248 206.32,137.6 ; CON_XMM2.248 205.56,136.83 ; SLOT4.B49 95.42,19.4 94.64,19.4 ; SLOT4.B49 95.45,20.21 ; SLOT1.B36 82.45,79.17 ; SLOT1.B36 81.61,78.33 ; SLOT1.B36 83.29,78.33 ; SLOT1.B36 82.45,77.49 ; 206.32,217.5 CON_XMM2.160 ; CON_XMM2.160 205.56,216.73 ; CON_XMM2.160 205.56,218.26 ; CON_XMM2.160 204.79,217.5 ; SLOT4.B40 87.37,17.37 ; SLOT4.B40 86.45,16.53 ; SLOT4.B40 86.45,18.21 ; SLOT4.B68 113.61,17.37 ; SLOT4.B68 115.29,17.37 ; SLOT4.B68 114.45,18.21 ; SLOT4.B68 114.45,16.53 ; CON4.24 239.92,198.23 ; CON4.24 238.56,196.87 ; CON4.24 237.21,198.23 ; 112.61,82.83 SLOT1.A67 ; SLOT1.A67 113.45,83.67 ; SLOT1.A67 113.45,81.99 ; SLOT1.A67 114.29,82.83 ; 74.64,60.01 SLOT2.B29 ; SLOT2.B29 75.45,59.2 ; SLOT2.B29 76.26,60.01 ; SLOT2.B29 75.45,60.82 ; CON_XMM2.20 202.52,214.1 ; CON_XMM2.20 201.76,214.86 ; CON_XMM2.20 201.76,213.33 ; 90.13,158.18 PCE6204.2 ; PCE6204.2 91.07,159.12 ; PCE6204.2 90.13,160.06 ; PCE6204.2 89.2,159.12 ; H14.1 221.13,73.38 ; H14.1 218.36,76.15 ; H14.1 215.59,73.38 ; H14.1 218.36,70.61 ; 47.64,44.19 SLOT3.A4 ; SLOT3.A4 48.45,43.38 ; SLOT3.A4 48.45,45 ; SLOT3.A4 49.26,44.19 ; SLOT2.B21 67.45,59.2 ; SLOT2.B21 67.45,60.82 ; SLOT2.B21 68.26,60.01 ; SLOT2.B21 66.64,60.01 ; 204.72,141.85 CON_XMM2.243 ; CON_XMM2.243 203.19,141.85 ; CON_XMM2.243 203.96,141.08 ; CON_XMM2.243 203.96,142.61 ; J10.4 14.96,180.4 ; J10.4 14.96,176.76 ; J10.4 16.78,178.58 ; 238.01,124.15 P150.13 ; P150.13 237.13,123.26 ; P150.13 236.24,124.15 ; P150.13 237.13,125.04 ; SLOT3.B4 49.26,37.69 ; SLOT3.B4 47.64,37.69 ; SLOT3.B4 48.45,38.5 ; SLOT3.B4 48.45,36.88 ; SLOT1.A58 105.29,84.83 ; SLOT1.A58 104.45,83.99 ; SLOT1.A58 103.61,84.83 ; GPU_PWR.3 66.07,105.87 ; GPU_PWR.3 64.71,104.52 ; GPU_PWR.3 63.35,105.87 ; GPU_PWR.3 64.71,107.23 ; J10.44 18.91,181.65 ; J10.44 20.79,181.65 ; J10.44 19.85,182.59 ; J10.44 19.85,180.71 ; 200.16,117.28 CON_XMM2.127 ; CON_XMM2.127 200.16,118.81 ; CON_XMM2.127 200.92,118.05 ; CON_XMM2.116 202.52,127.4 ; 175.98,107.08 CON_XMM3.139 175.22,107.85 ; 218.01,163.3 PCE652.2 ; PCE652.2 218.01,165.18 ; PCE652.2 218.95,164.24 ; J_TYPEC.5 2.28,151.01 ; J_TYPEC.5 1.2,150.22 ; J_TYPEC.5 1.2,151.79 ; J10.24 14.61,180.71 ; J10.24 15.55,181.65 ; J10.24 14.61,182.59 ; SLOT4.A78 124.45,24.71 ; SLOT4.A78 124.45,23.03 ; SLOT4.A78 125.29,23.87 ; SLOT4.A78 123.61,23.87 ; 179.78,107.08 CON_XMM3.283 ; CON_XMM2.134 202.52,112.1 ; CON_XMM2.134 201.76,111.33 ; CON_XMM2.134 201.76,112.86 ; J133.4 16.06,122.58 ; J133.4 14.32,120.77 ; J133.4 14.32,124.4 ; J133.4 12.5,122.58 ; CON_XMM2.129 200.92,116.35 ; CON_XMM2.129 200.16,115.58 ; CON_XMM2.129 200.16,117.11 ; 15.02,196.84 J9.2 ; J9.2 13.2,198.66 ; J9.2 15.02,200.48 ; J9.2 16.84,198.66 ; 8.06,220.42 S/PDIF.3 ; S/PDIF.3 8.06,222.27 ; S/PDIF.3 8.98,221.35 ; S/PDIF.3 7.13,221.35 ; J125.21 10.71,156.47 ; J125.21 8.82,157.56 ; J125.21 6.93,156.47 ; J125.21 8.82,155.38 ; SLOT2.B32 78.45,58.82 ; SLOT2.B32 79.26,58.01 ; SLOT2.B32 78.45,57.2 ; SLOT2.B32 77.64,58.01 ; SLOT1.B7 50.51,80.33 ; SLOT1.B7 51.45,81.27 51.44,81.28 ; SLOT1.B7 52.41,80.33 ; 73.45,21.03 SLOT4.A27 ; SLOT4.A27 73.45,22.71 ; SLOT4.A27 74.29,21.87 ; SLOT4.A27 72.69,21.87 ; 204.17,4.22 P17.3 ; P17.3 205.23,5.28 ; P17.3 204.17,6.35 ; 237.13,95.2 P24.15 ; P24.15 237.13,96.98 ; P24.15 238.01,96.09 ; XCE17.2 52.3,50.16 ; XCE17.2 53.24,51.1 ; XCE17.2 54.18,50.16 ; XCE17.2 53.24,49.23 ; CON_XMM2.261 203.19,126.55 ; CON_XMM2.261 203.96,127.31 ; CON_XMM2.261 203.96,125.78 ; CON_XMM2.261 204.72,126.55 ; CON_XMM2.158 205.56,218.43 ; CON_XMM2.158 206.32,219.2 ; CON_XMM2.158 204.79,219.2 ; CON_XMM2.158 205.56,219.96 ; SLOT4.A41 87.45,22.71 ; SLOT4.A41 86.69,21.87 ; SLOT4.A41 87.45,21.11 ; SLOT4.A41 88.21,21.87 ; 200.92,199.65 CON_XMM2.37 200.16,200.41 ; 127.36,205.42 PCE6210.2 ; PCE6210.2 127.36,207.29 ; PCE6210.2 126.42,206.35 ; PCE6210.2 128.3,206.35 ; CON_XMM2.28 202.52,207.3 ; 218.36,90.61 H15.1 ; H15.1 218.36,96.15 ; H15.1 215.59,93.38 ; H15.1 221.13,93.38 ; 187.55,107.11 CON_XMM1.283 ; SLOT1.B72 118.45,79.17 ; SLOT1.B72 119.29,78.33 ; SLOT1.B72 117.61,78.33 ; SLOT1.B72 118.45,77.49 ; CON_XMM2.265 203.96,123.91 ; CON_XMM2.265 204.72,123.15 ; CON_XMM2.265 203.19,123.15 ; CON_XMM2.265 203.96,122.38 ; CON_XMM2.263 203.96,125.61 ; CON_XMM2.263 204.72,124.85 ; CON_XMM2.263 203.96,124.08 ; CON_XMM2.263 203.19,124.85 ; SLOT4.A42 88.45,24.71 ; SLOT4.A42 88.45,23.11 ; SLOT4.A42 89.21,23.87 ; SLOT4.A42 87.69,23.87 ; CON_XMM2.279 203.96,112.01 ; CON_XMM2.279 204.72,111.25 ; CON_XMM2.279 203.96,110.48 ; CON_XMM2.279 203.19,111.25 ; SLOT4.A4 49.29,23.87 ; SLOT4.A4 47.61,23.87 ; SLOT4.A4 48.45,24.63 ; SLOT4.A4 48.45,23.11 ; 68.45,36.88 SLOT3.B22 ; SLOT3.B22 67.64,37.69 ; SLOT3.B22 69.26,37.69 ; SLOT3.B22 68.45,38.5 ; SLOT4.B61 107.45,18.53 ; SLOT4.B61 108.29,19.37 ; SLOT4.B61 106.61,19.37 ; SLOT4.B61 107.45,20.21 ; SLOT4.A67 114.29,21.87 ; SLOT4.A67 113.45,21.03 ; SLOT4.A67 112.61,21.87 ; SLOT4.A67 113.45,22.71 ; CON_XMM2.2 201.76,228.63 ; CON_XMM2.2 201.76,230.16 ; CON_XMM2.2 200.99,229.4 ; CON_XMM2.2 202.52,229.4 ; CON_XMM2.281 203.96,108.78 ; CON_XMM2.281 203.19,109.55 ; CON_XMM2.281 204.72,109.55 ; CON_XMM2.281 203.96,110.31 ; SLOT2.B4 48.45,58.82 ; SLOT2.B4 49.26,58.01 ; SLOT2.B4 48.45,57.2 ; SLOT2.B4 47.64,58.01 ; 72.45,57.2 SLOT2.B26 ; SLOT2.B26 71.64,58.01 ; SLOT2.B26 72.45,58.82 ; SLOT2.B26 73.26,58.01 ; J125.24 2.34,174.06 ; J125.24 2.34,171.88 ; J125.24 3.98,172.97 ; CON_XMM2.270 204.79,118.9 ; CON_XMM2.270 206.32,118.9 ; CON_XMM2.270 205.56,119.66 ; CON_XMM2.270 205.56,118.13 ; 19.82,121.54 J133.2 ; J133.2 19.82,123.62 ; J133.2 17.94,122.58 ; J133.2 21.62,122.58 ; J_TYPEC.4 4.4,141.02 ; J_TYPEC.4 3.24,142 ; J_TYPEC.4 4.4,142.95 ; CON_XMM2.24 202.52,210.7 ; 201.76,228.46 CON_XMM2.4 202.52,227.69 ; SLOT3.A12 59.26,44.19 ; SLOT3.A12 58.45,45 ; SLOT3.A12 57.64,44.19 ; SLOT3.A12 58.45,43.38 ; CON_XMM2.107 200.16,135.81 ; CON_XMM2.107 200.16,134.28 ; CON_XMM2.107 200.92,135.05 ; CON_XMM4.139 193.15,107.85 ; CON_XMM4.139 192.38,107.08 ; CON_XMM4.139 191.62,107.85 ; 233.06,175.87 CON4.7 ; CON4.7 234.42,177.23 ; CON4.7 231.71,177.23 ; CON4.7 233.06,178.59 ; SLOT4.B26 72.45,16.61 ; SLOT4.B26 71.69,17.37 ; SLOT4.B26 73.21,17.37 ; SLOT4.B26 72.45,18.21 ; SLOT4.B22 67.69,17.37 ; SLOT4.B22 68.45,16.61 ; SLOT4.B22 69.21,17.37 ; SLOT4.B22 68.45,18.21 ; CON_XMM2.239 203.19,145.25 ; CON_XMM2.239 203.96,144.48 ; CON_XMM2.239 203.96,146.01 ; CON_XMM2.239 204.72,145.25 ; 201.76,111.16 CON_XMM2.136 202.52,110.4 ; SLOT4.A46 93.29,23.87 ; SLOT4.A46 91.61,23.87 ; SLOT4.A46 92.45,24.71 ; 73.45,81.99 SLOT1.A27 ; SLOT1.A27 74.29,82.83 ; SLOT1.A27 72.61,82.83 ; SLOT1.A27 73.45,83.67 ; CON_XMM2.178 205.56,201.43 ; CON_XMM2.178 205.56,202.96 ; CON_XMM2.178 206.32,202.2 ; CON_XMM2.178 204.79,202.2 ; H16.1 221.13,55.38 ; H16.1 218.36,52.61 ; H16.1 215.59,55.38 ; H16.1 218.36,58.15 ; SLOT1.A66 113.29,84.83 ; SLOT1.A66 111.61,84.83 ; SLOT1.A66 112.45,83.99 ; 57.4,132.06 H23.1 59.92,129.55 ; P3.1 56.56,226.79 ; P3.1 56.56,223.92 ; P3.1 57.99,225.36 ; P3.1 55.12,225.36 ; SLOT3.A31 78.26,42.19 ; SLOT3.A31 76.64,42.19 ; SLOT3.A31 77.45,41.38 ; SLOT3.A31 77.45,43 ; 215.93,170.85 PCE653.2 ; PCE653.2 216.87,171.79 ; PCE653.2 215.93,172.73 ; SLOT4.B56 103.29,17.37 ; SLOT4.B56 101.61,17.37 ; SLOT4.B56 102.45,18.21 ; SLOT4.B60 106.45,16.53 ; SLOT4.B60 107.29,17.37 ; SLOT4.B60 105.61,17.37 ; SLOT4.B60 106.45,18.21 ; J10.14 11.99,182.59 ; J10.14 12.93,181.65 ; J10.14 11.05,181.65 ; J10.14 11.99,180.71 ; CON_XMM2.151 203.19,225.15 ; CON_XMM2.151 204.72,225.15 ; CON_XMM2.151 203.96,224.38 ; CON_XMM2.151 203.96,225.91 ; P64.1 238.23,13.39 ; P64.1 237.38,14.24 ; P64.1 239.08,14.24 ; P64.1 238.23,15.09 ; 202.52,212.4 CON_XMM2.22 201.76,213.16 ; SLOT2.A27 73.45,63.32 ; SLOT2.A27 73.45,61.7 ; SLOT2.A27 72.64,62.51 ; SLOT2.A27 74.26,62.51 ; 70.45,43.38 SLOT3.A24 ; SLOT3.A24 69.64,44.19 ; SLOT3.A24 71.26,44.19 ; SLOT3.A24 70.45,45 ; J133.6 8.64,124.4 ; J133.6 10.38,122.58 ; J133.6 8.64,120.77 ; J133.6 6.82,122.58 ; 127.61,23.87 SLOT4.A82 ; SLOT4.A82 128.45,23.03 ; SLOT4.A82 129.29,23.87 ; SLOT4.A82 128.45,24.71 ; SLOT1.A49 96.29,82.83 ; SLOT1.A49 94.61,82.83 ; SLOT1.A49 95.45,83.67 ; SLOT1.A49 95.45,81.99 ; SLOT1.A28 73.61,84.83 ; SLOT1.A28 74.45,85.67 ; SLOT1.A28 75.29,84.83 ; SLOT1.A28 74.45,83.99 ; 206.32,134.2 CON_XMM2.252 ; CON_XMM2.252 204.79,134.2 ; CON_XMM2.252 205.56,133.43 ; CON_XMM2.252 205.56,134.96 ; CON_XMM2.200 205.56,182.73 ; CON_XMM2.200 204.79,183.5 ; CON_XMM2.200 205.56,184.26 ; CON_XMM2.200 206.32,183.5 ; 41.68,29.64 XCE16.2 ; XCE16.2 41.68,31.51 ; XCE16.2 42.62,30.57 ; XCE16.2 40.74,30.57 ; 4.4,149.91 J_TYPEC.3 ; J_TYPEC.3 3.17,150.86 ; J_TYPEC.3 4.4,151.81 ; CON_XMM2.125 200.16,120.51 ; CON_XMM2.125 200.16,118.98 ; CON_XMM2.125 200.92,119.74 ; J10.1 20.46,192.68 ; J10.1 18.82,191.6 ; J10.1 22.1,191.6 ; J10.1 20.46,190.52 ; GPU_PWR.2 59.15,105.87 ; GPU_PWR.2 61.87,105.87 ; GPU_PWR.2 60.51,104.52 ; GPU_PWR.2 60.51,107.23 ; 200.16,203.98 CON_XMM2.31 200.92,204.75 ; P312.4 144.77,8.74 ; P312.4 145.73,7.77 ; P312.4 145.73,9.7 ; SLOT1.B73 119.45,81.17 ; SLOT1.B73 120.29,80.33 ; SLOT1.B73 119.45,79.49 ; SLOT1.B73 118.61,80.33 ; 193.22,227.69 CON_XMM4.4 193.98,228.46 ; SLOT1.A4 48.45,85.67 ; SLOT3.A28 75.26,44.19 ; SLOT3.A28 73.64,44.19 ; SLOT3.A28 74.45,45 ; SLOT3.A28 74.45,43.38 ; 86.45,77.49 SLOT1.B40 ; SLOT1.B40 86.45,79.17 ; SLOT1.B40 85.61,78.33 ; SLOT1.B40 87.29,78.33 ; CON_XMM2.118 202.52,125.7 ; 233.06,159.07 CON4.3 ; CON4.3 233.06,161.79 ; CON4.3 231.71,160.43 ; CON4.3 234.42,160.43 ; SLOT4.B21 67.45,18.61 ; SLOT4.B21 67.45,20.21 ; SLOT4.B21 68.39,19.37 68.4,19.38 ; SLOT4.B21 66.69,19.37 ; SLOT4.A31 78.21,21.87 ; SLOT4.A31 77.45,22.71 ; SLOT4.A31 76.69,21.87 ; SLOT4.A31 77.45,21.11 ; 7.4,163.02 J125.8 ; 201.76,145.16 CON_XMM2.96 202.52,144.4 ; CON_XMM2.46 202.52,192 ; SLOT1.A82 127.61,84.83 ; SLOT1.A82 128.45,85.67 ; SLOT1.A82 128.45,83.99 ; SLOT1.A82 129.29,84.83 ; CON_XMM1.6 185.35,226.76 ; J133.14 10.64,124.81 ; J133.14 10.64,126.49 ; J133.14 9.88,125.65 ; J125.5 10.28,161.22 ; CON_XMM3.6 177.58,226.76 ; SLOT1.B35 81.45,81.17 ; SLOT1.B35 80.61,80.33 ; SLOT1.B35 82.29,80.33 ; SLOT1.B35 81.45,79.49 ; J125.11 10.28,165.22
  BOTTOM w0.102: 136.42,169.72 136.42,170.03 ; 187.38,66.05 187.76,66.05 v1(188.09,66.37) ; 187.38,66.05 187.1,66.33 187.1,67.54 187.43,67.87 v1(188.01,67.87) ; 187.38,66.05 184.34,63 184.01,63 182.88,61.87 v1(182.12,61.87) ; v1(179.25,87.96) 178.87,87.96 177.93,88.9 v1(177.93,89.32) ; 134.59,173.69 134.59,173.35 ; v1(143,113.61) 142.49,113.11 142.49,112.14 v1(142.98,111.66) ; 137.97,148.95 137.64,148.92 ; 134.62,171.86 134.62,171.53 ; v1(147.78,108.33) 147.29,108.81 147.29,109.86 v1(147.73,110.29) 148.87,111.43 v1(148.87,111.76) 148.87,112.06 148.41,112.52 v1(147.32,112.52) ; v1(161.34,71.12) 161.34,71.83 160.76,72.41 v1(160.33,72.41) ; 134.59,147.09 135.2,147.09 ; 134.59,147.09 133.96,147.09 ; 134.59,147.09 134.59,146.41 ; v1(145.8,110.82) 145.41,111.21 145.41,112.26 v1(145.92,112.77) ; v1(226.14,9.35) 225.96,9.17 225.96,8.59 226.24,8.31 227.25,8.31 227.58,8.64 v1(227.58,9.14) ; 132.13,147.12 132.51,147.09 ; 135.53,157.18 135.51,156.84 ; v1(150.98,109.14) 150.5,109.63 150.5,109.93 150.04,110.39 149.65,110.39 v1(149.18,109.91) ; v1(150.98,109.14) 150.44,108.61 v1(149.96,108.61) ; v1(150.98,109.14) 151.21,109.37 151.79,109.37 152.07,109.09 v1(152.07,107.55) ; 134.9,150.75 135.23,150.75 ; v1(230.38,7.26) 230.15,7.49 230.15,8.74 230.56,9.14 v1(230.68,9.14) ; v1(222.91,7.39) 222.48,6.96 221.34,6.96 v1(220.9,7.39) ; 138.25,150.16 138.25,150.47 ; 137.62,149.83 137.95,149.83 ; v1(163.93,56.18) 163.65,56.18 162.86,56.97 161.62,56.97 v1(161.01,56.36) ; v1(163.07,58.29) 163.07,58.96 162.59,59.44 v1(161.85,59.44) ; 137.38,175.09 137.38,175.63 ; 135.51,157.76 135.56,158.14 ; 138.51,169.47 138.89,169.44 ; 129.11,175.49 129.11,175.21 ; v1(65.35,50.93) 64.91,50.49 63.91,50.49 63.58,50.83 63.58,51.38 v1(63.75,51.56) ; 139.45,169.47 139.85,169.42 ; 138.28,147.75 138.28,146.43 ; 137.64,147.12 138.94,147.12 ; v1(151.33,14.48) 151.33,14.71 151.79,15.16 152.96,15.16 153.34,14.78 v1(153.34,14.53) ; v1(232.97,15.39) 232.54,14.96 232.54,13.94 v1(232.99,13.49) ; 136.14,163.02 135.81,163.02 ; 136.14,162.1 135.79,162.1 ; 133.96,172.19 134.29,172.19 ; 137.34,170.05 137.34,169.7 ; 135.51,170.05 135.51,169.7 ; v1(233.17,35.31) 233.63,34.85 233.63,33.73 v1(233.2,33.3) 232.71,32.82 232.71,31.72 232.99,31.45 233.63,31.45 v1(233.73,31.55) ; 134.01,149.83 135.28,149.83 ; 135.2,169.42 134.87,169.42 ; 129.08,176.5 129.08,176.07 ; v1(183.85,80.34) 183.59,80.09 183.59,78.81 183.89,78.51 v1(185.27,78.51) v1(185.95,78.51) ; 130.35,175.82 130.71,175.79 ; 138.56,149.81 138.91,149.81 ; v1(226.26,13.39) 226.26,13.94 225.96,14.25 224.94,14.25 224.71,14.02 v1(224.71,13.31) ; 134.58,175.06 134.58,175.84 ; 134.58,175.84 134.58,176.56 ; 134.58,175.84 135.28,175.84 ; 134.29,173.08 133.96,173.08 ; 137.36,150.47 137.36,150.09 ; 132.18,148.01 132.49,148.01 ; 132.16,174.9 132.56,174.9 ; SLOT2.A24 69.89,65.07 69.89,65.41 68.34,66.97 65.44,66.97 65.08,67.32 65.08,68.35 65.76,69.03 v1(65.76,69.32) 65.58,69.5 63.78,69.5 63.6,69.31 v1(63.6,68.78) 64.21,68.17 64.21,67.14 65.12,66.23 68.01,66.23 68.22,66.01 68.22,65.51 67.94,65.23 67.17,65.23 SLOT2.A20 67.36,63.6 69.36,63.6 69.45,63.52 SLOT2.A23 70.01,61.95 70.01,61.62 70.86,60.77 71.36,60.77 71.45,60.68 SLOT2.B25 72.01,59.45 72.01,59.23 72.45,58.79 SLOT2.B26 73.02,57.44 73.02,57.19 74.6,55.61 115.63,55.61 116.26,56.24 124.48,56.24 129.02,60.77 129.76,60.77 130.44,61.46 v1(130.44,62.08) 130.33,62.19 128.87,62.19 v1(128.37,61.7) 128.37,61.27 124.15,57.05 115.93,57.05 115.21,56.33 75.82,56.33 v1(75.54,56.62) ; v1(141.91,111.43) 142.06,111.58 142.06,112.22 141.8,112.48 140.67,112.48 v1(140.26,112.08) 140.26,111.83 v1(140.67,111.43) ; 134.87,173.05 135.25,173.05 ; 139.17,169.14 139.14,168.83 ; 135.23,158.47 134.85,158.42 ; 137.03,154.79 134.87,154.79 ; 138.23,170.05 138.23,169.72 ; 137.95,148.01 137.59,148.01 ; 131.85,147.4 131.85,147.78 ; v1(34.39,124.79) 34.39,126.03 34.09,126.34 33.5,126.34 v1(33.25,126.09) ; 135.51,155.42 135.51,154.1 ; v1(144.46,113.24) 143.96,112.75 143.96,111.79 v1(144.48,111.28) ; 136.42,155.42 136.42,154.13 ; 137.57,158.39 138.02,158.39 ; 132.13,175.82 132.51,175.82 ; 135.51,151.05 135.51,151.38 ; 137.36,165.15 137.36,165.46 ; 130.02,175.54 130.02,175.16 ; 132.73,148.79 132.73,148.16 ; 136.42,156.82 136.42,157.2 ; 136.73,170.33 137.03,170.33 ; 137.36,162.84 137.39,162.33 ; 136.14,163.93 135.81,163.93 ; 138.3,161.87 138.25,161.47 ; 137.01,159.33 136.7,159.33 ; 134.62,150.47 134.62,149.2 ; 130,146.46 130,146.79 ; 129.69,147.09 129.44,147.09 ; 136.14,157.45 135.79,157.45 ; 131.85,174.6 131.85,174.27 ; 137.64,154.76 138.94,154.76 ; 155.41,98.11 v1(155.78,98.48) 155.51,98.74 155.51,98.77 155.42,98.86 155.42,99.78 161.38,105.73 170.21,105.73 170.69,105.25 170.69,104.65 174.68,100.65 174.87,100.65 196.16,100.65 198.14,98.68 200.35,98.68 201.58,99.9 201.76,99.9 201.76,99.9 203.71,99.9 204.93,98.68 205.94,98.68 210.98,93.64 211.54,93.64 212.28,94.37 212.28,95.11 v1(212.14,95.25) 210.94,95.25 206.14,100.05 204.82,100.05 204.08,100.79 201,100.79 199.89,99.68 198.28,99.68 196.6,101.36 175.23,101.36 171.4,105.19 171.4,105.54 170.5,106.44 161.08,106.44 153.81,99.17 153.81,98.38 154.08,98.11 155.41,98.11 ; 224.83,42.54 224.83,46.57 223.62,47.78 v1(223.62,50.55) 223.89,50.81 223.89,52.13 v1(223.63,52.39) 223.2,52.39 222.17,51.36 222.17,48.21 224.12,46.27 224.12,42.84 222.38,41.1 222.38,35.63 222.2,35.45 222.2,33.94 222.83,33.3 222.83,31.14 224.32,29.66 226.04,29.66 226.42,30.04 v1(226.42,30.51) 225.93,30.99 224.21,30.99 223.55,31.65 223.55,33.9 223.18,34.27 223.18,40.42 v1(223.83,41.08) 223.84,41.08 223.84,41.55 224.83,42.54
  BOTTOM w0.108: 128.96,175.84 128.38,175.84
  BOTTOM w0.127: v1(93.07,74.52) 92.63,74.96 91.54,74.96 v1(91.08,74.5) ; v1(231.95,93.7) 231.95,94.31 231.7,94.56 230.43,94.56 230.02,94.15 v1(230.02,93.73) ; v1(158.88,68.81) 158.4,69.29 157.43,69.29 v1(156.94,68.8) ; v1(80.7,72.54) 80.14,72.54 79.35,73.33 v1(79.35,74.04) ; v1(190.55,62.74) 190.93,62.36 191.97,62.36 192.46,62.84 v1(192.46,63.09) ; v1(82.8,73.3) 83.25,72.85 84.36,72.85 v1(84.73,73.23) ; 137.59,174.9 138.02,174.9 ; v1(115.32,59.06) 114.85,59.53 113.73,59.53 113.32,59.12 v1(113.32,58.86) ; 138.25,155.47 138.25,154.05 ; 137.34,155.09 137.34,155.4 ; v1(143.13,55.5) 143.84,55.5 144.55,54.79 v1(144.55,54.13) ; v1(189.36,63.68) 189.36,63.05 189.07,62.76 187.99,62.76 v1(187.55,63.2) ; 137.39,176.01 137.39,176.54 ; 137.54,175.79 138.07,175.79 ; v1(38.33,140.89) 38.48,140.75 38.48,140.3 39.32,139.46 39.32,138.07 v1(38.86,137.62) 39.37,137.11 39.37,135.72 38.78,135.13 37.16,135.13 36.63,134.59 v1(36.63,133.88) ; 141.27,156.62 141.68,156.62 ; 225.87,68.67 226.43,68.67 227.3,69.55 227.3,70.36 v1(227.13,70.54) 220.7,76.96 213.49,76.96 v1(212.85,77.6) 211.92,77.6 211.23,76.91 211.23,76.17 v1(211.46,75.95) 211.55,76.04 219.46,76.04 224.41,71.1 224.41,70.13 225.87,68.67
  BOTTOM w0.152: 138.26,172.33 138.26,174.84 ; v1(158.43,70.52) 157.91,70 157.02,70 v1(156.52,70.5) ; 137.52,173.08 138.99,173.08 ; 137.49,173.99 139.04,173.99
  BOTTOM w0.203: 144.3,95.4 v1(149.66,90.04) 149.14,89.52 147.84,89.52 142.77,94.59 v1(142.77,96.6) 142.77,97.92 143.14,98.29 143.93,98.29 144.3,97.92 144.3,95.4
  BOTTOM w0.254: v1(211.96,173.61) 214.02,173.61 214.38,173.96 214.38,178.92 215.57,180.11 220.1,180.11 220.54,180.54 220.54,186.94 v1(220.54,190.35) 220.98,190.79 v1(220.98,196.42) v1(220.98,202.67) v1(220.98,205.28) 220.98,209.35 219.19,211.14 v1(219.19,214.5) v1(219.19,221.46) 219.19,223.66 219.89,224.36 220.29,224.36 220.64,224.02 220.64,223.52 220.33,223.22 v1(220.33,222.83) 220.33,221.81 220.19,221.67 220.19,211.38 222.16,209.41 222.16,191.5 222.16,191.5 222.16,190.44 221.27,189.55 221.27,189.38 221.27,180.24 220.33,179.3 215.8,179.3 215.19,178.69 215.19,172.52 PCE653.2 ; PCE6206.2 96.14,207.65 96.14,216.18 92.25,220.07 92.25,224.29 v1(91.08,225.45) v1(88.9,227.63) ; v1(85.09,142.29) 85.09,142.54 92.99,150.44 92.99,151.74 94.28,153.03 v1(94.31,153.03) 94.37,153.09 v1(98.96,153.09) ; v1(82.22,205.87) 84.16,203.92 84.16,201.93 83.81,201.58 83.81,185.18 86.69,182.3 89.17,182.3 PCE6201.2
  BOTTOM w0.508: 178.93,107.85 CON_XMM3.283 180.63,107.85 ; D4CE4.2 168.05,167.89 ; D4CE4.2 167.03,166.87 ; D4CE4.2 167.03,168.92 ; D4CE4.2 166,167.89 ; 151.32,221.78 H22.1 148.8,219.27 ; 176.83,107.85 CON_XMM3.139 175.13,107.85 ; 7.3,211.8 7.33,211.83 ; CON_XMM4.263 196.9,124.85 196.9,124.84 ; CON_XMM2.138 200.88,108.7
  BOTTOM w0.635: 200.16,113.96 CON_XMM2.131 ; CON_XMM2.131 200.92,114.65 ; CON_XMM2.131 200.16,115.33 ; CON_XMM2.198 204.71,185.2 ; CON_XMM2.198 206.41,185.2 ; CON_XMM2.198 205.56,184.43 ; J10.4 13.05,178.58 ; J10.4 16.86,178.58 ; J10.4 14.96,180.49 ; 185.35,225.31 CON_XMM1.6 ; CON_XMM1.6 185.35,226.68 ; CON_XMM1.6 184.5,226 ; CON_XMM1.6 186.11,226 ; 8.54,195.88 6.79,195.88 J9.8 ; CON_XMM1.246 188.3,139.3 ; CON_XMM1.246 189.15,138.53 ; CON_XMM1.246 189.91,139.3 ; CON_XMM1.246 189.15,140.06 ; 203.96,193.86 CON_XMM2.187 ; CON_XMM2.187 203.11,194.55 ; CON_XMM2.187 204.72,194.55 ; CON_XMM2.187 203.96,195.23 ; CON_XMM2.57 201.01,182.65 ; CON_XMM2.57 199.47,182.65 ; CON_XMM2.57 200.16,181.88 ; CON_XMM2.57 200.16,183.33 ; CON_XMM1.252 189.15,134.88 ; CON_XMM1.252 189.15,133.51 ; CON_XMM1.252 188.3,134.2 ; CON_XMM1.252 189.91,134.2 ; CON_XMM1.20 184.5,214.1 ; CON_XMM1.20 186.11,214.1 ; CON_XMM1.20 185.35,213.41 ; CON_XMM1.20 185.35,214.78 ; CON_XMM3.182 182.14,198.8 ; CON_XMM3.182 180.53,198.8 ; CON_XMM3.182 181.38,198.11 ; CON_XMM3.182 181.38,199.48 ; CON_XMM2.195 204.81,187.75 ; CON_XMM2.195 203.11,187.75 ; CON_XMM2.195 203.96,186.98 ; CON_XMM1.116 184.5,127.4 ; CON_XMM1.116 185.35,126.71 ; CON_XMM1.116 186.11,127.4 ; CON_XMM1.116 185.35,128.08 ; 200.16,197.26 CON_XMM2.39 ; CON_XMM2.39 200.92,197.94 ; CON_XMM2.39 200.16,198.63 ; J125.24 2.34,174.15 ; J125.24 4.07,172.97 ; J125.24 2.34,171.66 ; 205.56,119.91 CON_XMM2.268 ; CON_XMM2.268 204.71,120.6 ; CON_XMM2.268 205.56,121.28 ; CON_XMM2.268 206.32,120.6 ; 193.98,145.33 CON_XMM4.94 ; CON_XMM4.94 193.13,146.1 ; CON_XMM4.94 194.84,146.1 ; J10.6 7.37,178.58 ; J10.6 9.28,180.49 ; J10.6 9.28,176.68 ; J10.6 11.18,178.58 ; CON_XMM2.160 204.71,217.5 ; CON_XMM2.160 205.56,218.18 ; CON_XMM2.160 206.32,217.5 ; CON_XMM2.160 205.56,216.81 ; 181.38,196.41 CON_XMM3.184 ; CON_XMM3.184 181.38,197.78 ; CON_XMM3.184 182.14,197.1 ; CON_XMM3.184 180.53,197.1 ; 202.52,129.09 CON_XMM2.114 200.91,129.09 ; CON_XMM3.139 175.98,108.61 ; CON_XMM3.254 180.53,132.5 ; CON_XMM3.254 182.23,132.5 ; CON_XMM3.254 181.38,131.73 ; 192.38,219.28 CON_XMM4.13 ; CON_XMM4.13 193.24,220.05 ; CON_XMM4.13 191.53,220.05 ; CON_XMM3.265 178.93,123.15 ; CON_XMM3.265 179.78,122.38 ; CON_XMM3.265 180.63,123.15 ; CON_XMM2.169 203.96,210.53 ; CON_XMM2.169 203.11,209.85 ; CON_XMM2.169 203.96,209.16 ; CON_XMM2.169 204.72,209.85 ; CON_XMM2.184 205.56,197.78 ; CON_XMM2.184 204.71,197.1 ; CON_XMM2.184 206.32,197.1 ; CON_XMM2.184 205.56,196.41 ; 203.96,141.16 CON_XMM2.243 ; CON_XMM2.243 204.72,141.85 ; CON_XMM2.243 203.96,142.53 ; CON_XMM2.243 203.11,141.85 ; S/PDIF.3 8.06,222.36 ; S/PDIF.3 8.06,220.33 ; S/PDIF.3 9.01,221.35 ; S/PDIF.3 7.04,221.35 ; 202.52,193.7 CON_XMM2.44 200.91,193.7 ; 175.98,197.26 CON_XMM3.39 ; CON_XMM3.39 176.74,197.94 ; CON_XMM3.39 175.13,197.94 ; CON_XMM3.39 175.98,198.63 ; CON_XMM1.2 184.5,229.4 ; CON_XMM1.2 185.35,228.71 ; CON_XMM1.2 185.35,230.08 ; CON_XMM1.2 186.11,229.4 ; CON_XMM3.127 175.13,118.05 ; CON_XMM3.127 175.98,117.36 ; CON_XMM3.127 175.98,118.73 ; CON_XMM3.127 176.74,118.05 ; 175.98,219.28 CON_XMM3.13 ; CON_XMM3.13 176.83,220.05 ; CON_XMM3.13 175.13,220.05 ; CON_XMM3.272 181.38,117.88 ; CON_XMM3.272 182.14,117.2 ; CON_XMM3.272 181.38,116.51 ; CON_XMM3.272 180.53,117.2 ; CON_XMM3.274 180.53,115.5 ; CON_XMM3.274 181.38,116.18 ; CON_XMM3.274 181.38,114.81 ; CON_XMM3.274 182.14,115.5 ; CON_XMM4.134 193.13,112.1 ; CON_XMM4.134 194.84,112.1 ; CON_XMM4.134 193.98,111.33 ; CON_XMM4.96 194.84,144.4 ; CON_XMM4.96 193.98,143.63 ; CON_XMM4.96 193.13,144.4 ; CON_XMM2.33 200.92,203.05 ; CON_XMM2.33 200.16,203.81 ; CON_XMM2.33 200.16,202.28 ; S/PDIF.4 13.54,234.09 ; S/PDIF.4 11.41,232.88 ; S/PDIF.4 11.41,235.29 ; S/PDIF.4 9.27,234.09 ; CON_XMM1.238 188.3,146.1 ; CON_XMM1.238 189.15,146.78 ; CON_XMM1.238 189.15,145.41 ; CON_XMM1.238 189.91,146.1 ; CON_XMM4.202 197.78,181.03 ; CON_XMM4.202 196.93,181.8 ; CON_XMM4.202 198.64,181.8 ; CON_XMM1.107 184.51,135.05 ; CON_XMM1.107 183.75,134.36 ; CON_XMM1.107 183.75,135.73 ; CON_XMM1.107 182.9,135.05 ; 201.76,131.48 CON_XMM2.112 ; CON_XMM2.112 201.76,130.11 ; CON_XMM2.112 202.52,130.8 ; CON_XMM2.112 201.07,130.8 ; 175.98,181.96 CON_XMM3.57 ; CON_XMM3.57 175.13,182.65 ; CON_XMM3.57 176.74,182.65 ; CON_XMM3.57 175.98,183.33 ; CON_XMM3.109 175.13,133.35 ; CON_XMM3.109 175.98,134.03 ; CON_XMM3.109 175.98,132.66 ; CON_XMM3.109 176.74,133.35 ; CON_XMM1.184 189.15,197.78 ; CON_XMM1.184 189.15,196.41 ; CON_XMM1.184 188.3,197.1 ; CON_XMM1.184 189.91,197.1 ; CON_XMM1.37 182.9,199.65 ; CON_XMM1.37 183.75,198.96 ; CON_XMM1.37 184.51,199.65 ; CON_XMM1.37 183.75,200.33 ; CON_XMM4.252 197.78,134.88 ; CON_XMM4.252 197.02,134.2 ; CON_XMM4.252 197.78,133.51 ; CON_XMM1.46 186.11,192 ; CON_XMM1.46 184.5,192 ; CON_XMM1.46 185.35,192.68 ; CON_XMM1.46 185.35,191.31 ; 197.78,220.21 CON_XMM4.156 ; CON_XMM4.156 197.02,220.9 ; CON_XMM4.156 197.78,221.58 ; 185.35,123.23 CON_XMM1.120 ; CON_XMM1.120 186.2,124 ; CON_XMM1.120 184.5,124 ; CON_XMM2.259 203.11,128.25 ; CON_XMM2.259 203.96,127.56 ; CON_XMM2.259 203.96,128.93 ; CON_XMM2.259 204.72,128.25 ; CON_XMM2.246 206.32,139.3 ; CON_XMM2.246 205.56,138.61 ; CON_XMM2.246 205.56,139.98 ; CON_XMM2.246 204.71,139.3 ; 192.38,117.28 CON_XMM4.127 ; CON_XMM4.127 191.53,118.05 ; CON_XMM4.127 193.24,118.05 ; 200.91,142.7 CON_XMM2.98 202.52,142.7 ; 6.74,135.72 J133.5 ; J133.5 8.64,133.76 ; J133.5 8.64,137.63 ; CON_XMM1.180 188.3,200.5 ; CON_XMM1.180 189.91,200.5 ; CON_XMM1.180 189.15,201.18 ; CON_XMM1.180 189.15,199.81 ; CON_XMM1.101 184.51,140.15 ; CON_XMM1.101 183.75,139.46 ; CON_XMM1.101 183.75,140.83 ; CON_XMM1.101 182.9,140.15 ; CON_XMM1.171 188.31,208.15 ; CON_XMM1.171 187.55,207.46 ; CON_XMM1.171 186.7,208.15 ; CON_XMM1.171 187.55,208.83 ; 196.18,141.08 CON_XMM4.243 ; CON_XMM4.243 195.33,141.85 ; CON_XMM4.243 197.04,141.85 ; 185.35,130.11 CON_XMM1.112 ; CON_XMM1.112 184.5,130.8 ; CON_XMM1.112 186.11,130.8 ; CON_XMM1.112 185.35,131.48 ; J133.34 17.04,124.72 ; CON_XMM1.98 184.5,142.7 ; CON_XMM1.98 185.35,143.38 ; CON_XMM1.98 186.11,142.7 ; CON_XMM1.98 185.35,142.01 ; CON_XMM1.22 186.2,212.4 ; CON_XMM1.22 184.5,212.4 ; CON_XMM1.22 185.35,211.63 ; 185.35,128.41 CON_XMM1.114 ; CON_XMM1.114 184.5,129.09 ; CON_XMM1.114 186.11,129.09 ; CON_XMM1.114 185.35,129.78 ; 200.92,216.65 CON_XMM2.17 200.16,217.41 ; CON_XMM3.198 181.38,185.88 ; CON_XMM3.198 180.53,185.2 ; CON_XMM3.198 181.38,184.51 ; CON_XMM3.198 182.14,185.2 ; CON_XMM1.265 188.4,123.15 ; CON_XMM1.265 187.55,122.38 ; CON_XMM1.265 186.7,123.15 ; 192.38,115.58 CON_XMM4.129 ; CON_XMM4.129 193.24,116.35 ; CON_XMM4.129 191.53,116.35 ; CON_XMM3.123 175.98,122.13 ; CON_XMM3.123 176.74,121.45 ; CON_XMM3.123 175.13,121.45 ; CON_XMM3.123 175.98,120.76 ; CON_XMM1.187 186.7,194.55 ; CON_XMM1.187 187.55,195.23 ; CON_XMM1.187 187.55,193.86 ; CON_XMM1.187 188.31,194.55 ; CON_XMM4.98 193.98,141.93 ; CON_XMM4.98 193.98,143.38 ; CON_XMM4.98 194.67,142.7 ; CON_XMM4.98 193.13,142.7 ; CON_XMM4.283 196.18,108.61 ; CON_XMM4.283 197.04,107.85 ; CON_XMM4.283 195.33,107.85 ; 201.76,194.71 CON_XMM2.42 ; CON_XMM2.42 201.76,196.08 ; CON_XMM2.42 202.52,195.4 ; CON_XMM2.42 200.91,195.4 ; 6.71,212.68 J9.7 ; J9.7 6.68,214.53 4.83,214.53 ; J9.7 6.74,214.53 8.59,214.53 ; 18.26,181.65 J10.34 ; J10.34 16.2,181.65 ; J10.34 17.23,180.62 ; J10.34 17.23,182.68 ; CON_XMM1.191 188.31,191.15 ; CON_XMM1.191 186.7,191.15 ; CON_XMM1.191 187.55,191.83 ; CON_XMM1.191 187.55,190.46 ; 202.52,110.4 CON_XMM2.136 200.91,110.4 ; CON_XMM3.238 182.14,146.1 ; CON_XMM3.238 181.38,145.41 ; CON_XMM3.238 180.53,146.1 ; CON_XMM3.238 181.38,146.78 ; CON_XMM1.193 187.55,190.13 ; CON_XMM1.193 188.31,189.45 ; CON_XMM1.193 186.7,189.45 ; CON_XMM1.193 187.55,188.76 ; 203.96,207.46 CON_XMM2.171 ; CON_XMM2.171 204.72,208.15 ; CON_XMM2.171 203.96,208.83 ; CON_XMM2.171 203.11,208.15 ; CON_XMM3.46 178.43,192 ; CON_XMM3.46 177.58,191.23 ; CON_XMM3.46 176.73,192 ; CON_XMM2.2 202.52,229.4 ; CON_XMM2.2 201.76,230.08 ; CON_XMM2.2 201.76,228.71 ; CON_XMM2.2 200.91,229.4 ; 8.82,171.79 J125.22 ; J125.22 10.8,172.97 ; J125.22 6.84,172.97 ; J125.22 8.82,174.15 ; CON_XMM1.276 188.3,113.8 ; CON_XMM1.276 190,113.8 ; CON_XMM1.276 189.15,113.03 ; CON_XMM1.182 189.15,199.48 ; CON_XMM1.182 189.15,198.11 ; CON_XMM1.182 189.91,198.8 ; CON_XMM1.182 188.3,198.8 ; CON_XMM2.9 200.16,224.13 ; CON_XMM2.9 200.92,223.45 ; CON_XMM2.9 200.16,222.76 ; CON_XMM4.55 191.53,184.35 ; CON_XMM4.55 192.38,183.58 ; CON_XMM4.55 193.24,184.35 ; CON_XMM3.120 176.73,124 ; CON_XMM3.120 178.43,124 ; CON_XMM3.120 177.58,123.23 ; CON_XMM3.31 176.74,204.75 ; CON_XMM3.31 175.13,204.75 ; CON_XMM3.31 175.98,204.06 ; CON_XMM3.31 175.98,205.43 ; CON_XMM1.274 190,115.5 ; CON_XMM1.274 189.15,114.73 ; CON_XMM1.274 188.3,115.5 ; CON_XMM3.15 175.13,218.35 ; CON_XMM3.15 176.74,218.35 ; CON_XMM3.15 175.98,219.03 ; CON_XMM3.15 175.98,217.66 ; CON_XMM1.42 185.35,196.08 ; CON_XMM1.42 185.35,194.71 ; CON_XMM1.42 186.11,195.4 ; CON_XMM1.42 184.5,195.4 ; 13.13,191.64 14.88,191.64 J10.3 ; 203.96,122.46 CON_XMM2.265 ; CON_XMM2.265 204.72,123.15 ; CON_XMM2.265 203.96,123.83 ; CON_XMM2.265 203.11,123.15 ; CON_XMM3.261 178.93,126.55 ; CON_XMM3.261 179.78,125.78 ; CON_XMM3.261 180.63,126.55 ; CON_XMM4.2 193.98,230.25 ; CON_XMM4.2 193.98,228.71 ; CON_XMM4.2 193.13,229.4 ; CON_XMM4.2 194.67,229.4 ; 183.75,181.96 CON_XMM1.57 ; CON_XMM1.57 184.51,182.65 ; CON_XMM1.57 183.75,183.33 ; CON_XMM1.57 182.9,182.65 ; CON_XMM3.162 182.14,215.8 ; CON_XMM3.162 181.38,215.11 ; CON_XMM3.162 181.38,216.48 ; CON_XMM3.162 180.53,215.8 ; CON_XMM3.173 178.93,206.45 ; CON_XMM3.173 179.78,207.13 ; CON_XMM3.173 179.78,205.76 ; CON_XMM3.173 180.54,206.45 ; CON_XMM2.252 205.56,134.88 ; CON_XMM2.252 204.71,134.2 ; CON_XMM2.252 205.56,133.51 ; CON_XMM2.252 206.32,134.2 ; 181.38,136.91 CON_XMM3.248 ; CON_XMM3.248 182.14,137.6 ; CON_XMM3.248 181.38,138.28 ; CON_XMM3.248 180.53,137.6 ; CON_XMM4.200 196.93,183.5 ; CON_XMM4.200 197.78,184.18 ; CON_XMM4.200 197.78,182.81 ; CON_XMM4.200 198.55,183.5 ; CON_XMM1.158 189.91,219.2 ; CON_XMM1.158 189.15,218.51 ; CON_XMM1.158 189.15,219.88 ; CON_XMM1.158 188.3,219.2 ; 201.76,145.41 CON_XMM2.94 ; CON_XMM2.94 201.76,146.78 ; CON_XMM2.94 202.52,146.1 ; CON_XMM2.94 200.91,146.1 ; 177.58,192.93 CON_XMM3.44 ; CON_XMM3.44 176.73,193.7 ; CON_XMM3.44 178.43,193.7 ; CON_XMM4.136 193.98,111.16 ; CON_XMM4.136 193.98,109.63 ; CON_XMM4.136 194.84,110.4 ; CON_XMM4.136 193.13,110.4 ; CON_XMM4.151 195.33,225.15 ; CON_XMM4.151 197.04,225.15 ; CON_XMM4.151 196.18,224.38 ; CON_XMM2.151 203.11,225.15 ; CON_XMM2.151 204.72,225.15 ; CON_XMM2.151 203.96,225.83 ; CON_XMM2.151 203.96,224.46 ; 12.42,122.58 J133.4 ; J133.4 14.32,124.49 ; J133.4 14.32,120.68 ; J133.4 16.23,122.58 ; CON_XMM4.42 193.98,194.63 ; CON_XMM4.42 194.84,195.4 ; CON_XMM4.42 193.13,195.4 ; CON_XMM2.156 205.56,221.58 ; CON_XMM2.156 205.56,220.21 ; CON_XMM2.156 204.71,220.9 ; CON_XMM2.156 206.32,220.9 ; 177.58,211.63 CON_XMM3.22 ; CON_XMM3.22 176.73,212.4 ; CON_XMM3.22 178.43,212.4 ; 181.38,218.51 CON_XMM3.158 ; CON_XMM3.158 182.14,219.2 ; CON_XMM3.158 180.53,219.2 ; CON_XMM3.158 181.38,219.88 ; 192.38,198.88 CON_XMM4.37 ; CON_XMM4.37 193.24,199.65 ; CON_XMM4.37 191.53,199.65 ; CON_XMM3.116 177.58,126.63 ; CON_XMM3.116 176.73,127.4 ; CON_XMM3.116 178.43,127.4 ; CON_XMM4.139 193.24,107.85 ; CON_XMM4.139 192.38,108.61 ; CON_XMM4.139 191.53,107.85 ; CON_XMM4.160 198.55,217.5 ; CON_XMM4.160 197.78,216.81 ; CON_XMM4.160 197.78,218.18 ; CON_XMM4.31 193.24,204.75 ; CON_XMM4.31 191.53,204.75 ; CON_XMM4.31 192.38,203.98 ; CON_XMM3.37 175.98,200.33 ; CON_XMM3.37 175.98,198.96 ; CON_XMM3.37 175.13,199.65 ; CON_XMM3.37 176.74,199.65 ; CON_XMM3.241 179.78,144.23 ; CON_XMM3.241 178.93,143.55 ; CON_XMM3.241 180.54,143.55 ; CON_XMM3.241 179.78,142.86 ; CON_XMM1.239 186.7,145.25 ; CON_XMM1.239 187.55,145.93 ; CON_XMM1.239 187.55,144.56 ; CON_XMM1.239 188.31,145.25 ; J9.6 19.29,196.06 17.59,196.06 ; J9.6 19.39,194.05 ; J9.6 19.39,197.86 ; J9.6 19.49,196.06 21.19,196.06 ; 181.38,199.73 CON_XMM3.180 ; CON_XMM3.180 180.53,200.5 ; CON_XMM3.180 182.23,200.5 ; CON_XMM3.138 178.43,108.7 ; CON_XMM3.138 176.73,108.7 ; CON_XMM3.138 177.58,107.93 ; CON_XMM3.17 175.98,217.33 ; CON_XMM3.17 175.98,215.96 ; CON_XMM3.17 175.13,216.65 ; CON_XMM3.17 176.74,216.65 ; 202.44,226 CON_XMM2.6 201.07,226 ; CON_XMM2.4 202.44,227.69 ; CON_XMM2.4 201.76,228.38 ; CON_XMM2.4 201.07,227.69 ; CON_XMM2.37 200.92,199.65 ; CON_XMM2.37 200.16,200.33 ; CON_XMM2.37 200.16,198.96 ; 179.78,224.46 CON_XMM3.151 ; CON_XMM3.151 180.54,225.15 ; CON_XMM3.151 178.93,225.15 ; CON_XMM3.151 179.78,225.83 ; CON_XMM1.9 183.75,224.13 ; CON_XMM1.9 182.9,223.45 ; CON_XMM1.9 184.51,223.45 ; CON_XMM1.9 183.75,222.76 ; CON_XMM1.200 189.15,184.18 ; CON_XMM1.200 189.15,182.81 ; CON_XMM1.200 189.91,183.5 ; CON_XMM1.200 188.3,183.5 ; CON_XMM1.167 188.31,211.55 ; CON_XMM1.167 187.55,210.86 ; CON_XMM1.167 186.7,211.55 ; CON_XMM1.167 187.55,212.23 ; 177.58,187.83 CON_XMM3.50 ; CON_XMM3.50 178.43,188.59 ; CON_XMM3.50 176.73,188.59 ; CON_XMM1.189 188.31,192.85 ; CON_XMM1.189 187.55,193.53 ; CON_XMM1.189 187.55,192.16 ; CON_XMM1.189 186.7,192.85 ; CON_XMM3.96 178.43,144.4 ; CON_XMM3.96 177.58,143.63 ; CON_XMM3.96 176.73,144.4 ; CON_XMM2.13 200.92,220.05 ; CON_XMM2.13 200.16,220.73 ; CON_XMM2.13 200.16,219.36 ; CON_XMM1.123 184.51,121.45 ; CON_XMM1.123 183.75,120.76 ; CON_XMM1.123 182.9,121.45 ; CON_XMM1.123 183.75,122.13 ; 7.31,168.32 J125.16 ; 19.39,212.6 J9.5 ; J9.5 17.48,214.51 ; J9.5 21.29,214.51 ; J9.5 19.39,216.41 ; CON_XMM2.191 203.11,191.15 ; CON_XMM2.191 203.96,191.83 ; CON_XMM2.191 204.72,191.15 ; CON_XMM2.191 203.96,190.46 ; CON_XMM4.33 193.24,203.05 ; CON_XMM4.33 191.53,203.05 ; CON_XMM4.33 192.38,202.28 ; CON_XMM2.20 201.76,214.78 ; CON_XMM2.20 200.91,214.1 ; CON_XMM2.20 202.52,214.1 ; CON_XMM2.20 201.76,213.41 ; CON_XMM3.112 178.43,130.8 ; CON_XMM3.112 176.73,130.8 ; CON_XMM3.112 177.58,130.03 ; CON_XMM1.55 183.75,185.03 ; CON_XMM1.55 184.51,184.35 ; CON_XMM1.55 182.9,184.35 ; CON_XMM1.55 183.75,183.66 ; CON_XMM2.238 205.56,146.78 ; CON_XMM2.238 204.71,146.1 ; CON_XMM2.238 206.32,146.1 ; CON_XMM2.238 205.56,145.41 ; CON_XMM3.149 179.78,227.53 ; CON_XMM3.149 178.93,226.85 ; CON_XMM3.149 180.54,226.85 ; CON_XMM3.149 179.78,226.16 ; CON_XMM3.101 176.74,140.15 ; CON_XMM3.101 175.98,140.83 ; CON_XMM3.101 175.13,140.15 ; CON_XMM3.101 175.98,139.46 ; 181.38,181.11 CON_XMM3.202 ; CON_XMM3.202 182.14,181.8 ; CON_XMM3.202 180.53,181.8 ; CON_XMM3.202 181.38,182.48 ; J10.3 15.04,191.64 16.79,191.64 ; J10.3 14.96,193.63 ; J10.3 14.96,189.82 ; CON_XMM2.147 203.11,228.55 ; CON_XMM2.147 203.96,227.86 ; CON_XMM2.147 204.72,228.55 ; CON_XMM2.147 203.96,229.23 ; CON_XMM4.187 196.18,195.31 ; 6.84,156.47 J125.21 ; 11.1,201.65 11.97,201.65 J9.U4 ; CON_XMM1.165 188.31,213.25 ; CON_XMM1.165 187.55,212.56 ; CON_XMM1.165 186.7,213.25 ; CON_XMM1.165 187.55,213.93 ; CON_XMM2.178 206.32,202.2 ; CON_XMM2.178 204.71,202.2 ; CON_XMM2.178 205.56,201.51 ; CON_XMM2.178 205.56,202.88 ; CON_XMM4.11 193.24,221.75 ; CON_XMM4.11 191.53,221.75 ; CON_XMM4.11 192.38,220.98 ; CON_XMM2.123 200.16,122.13 ; CON_XMM2.123 200.92,121.45 ; CON_XMM2.123 200.16,120.76 ; 196.18,110.31 CON_XMM4.281 197.04,109.55 ; 196.18,210.53 CON_XMM4.169 ; CON_XMM4.169 196.18,209.16 ; CON_XMM4.169 196.87,209.85 ; 175.98,185.36 CON_XMM3.53 ; CON_XMM3.53 175.13,186.05 ; CON_XMM3.53 176.74,186.05 ; CON_XMM3.53 175.98,186.73 ; CON_XMM3.114 178.43,129.09 ; CON_XMM3.114 177.58,128.33 ; CON_XMM3.114 176.73,129.09 ; 197.78,215.03 CON_XMM4.162 ; CON_XMM4.162 196.93,215.8 ; CON_XMM4.162 198.64,215.8 ; 175.98,113.96 CON_XMM3.131 ; CON_XMM3.131 176.74,114.65 ; CON_XMM3.131 175.13,114.65 ; CON_XMM3.131 175.98,115.33 ; 189.15,119.83 CON_XMM1.268 ; CON_XMM1.268 188.3,120.6 ; CON_XMM1.268 190,120.6 ; 192.38,197.18 CON_XMM4.39 ; CON_XMM4.39 191.53,197.94 ; CON_XMM4.39 193.24,197.94 ; 196.18,129.26 CON_XMM4.257 ; CON_XMM4.257 196.18,130.71 ; CON_XMM4.257 196.87,129.95 ; CON_XMM1.243 187.55,142.53 ; CON_XMM1.243 188.31,141.85 ; CON_XMM1.243 186.7,141.85 ; CON_XMM1.243 187.55,141.16 ; 203.96,205.76 CON_XMM2.173 ; CON_XMM2.173 203.96,207.13 ; CON_XMM2.173 203.11,206.45 ; CON_XMM2.173 204.72,206.45 ; CON_XMM1.33 182.9,203.05 ; CON_XMM1.33 184.51,203.05 ; CON_XMM1.33 183.75,203.73 ; CON_XMM1.33 183.75,202.36 ; CON_XMM4.268 198.64,120.6 ; CON_XMM4.268 197.78,119.83 ; CON_XMM4.268 196.93,120.6 ; 193.98,192.93 CON_XMM4.44 ; CON_XMM4.44 193.13,193.7 ; CON_XMM4.44 194.84,193.7 ; 200.91,144.4 CON_XMM2.96 202.52,144.4 ; J10.5 9.36,191.64 11.11,191.64 ; J10.5 9.2,191.64 7.45,191.64 ; J10.5 9.28,193.63 ; J10.5 9.28,189.82 ; 196.93,203.9 CON_XMM4.176 197.78,203.13 ; CON_XMM1.26 185.35,208.23 ; CON_XMM1.26 186.2,209 ; CON_XMM1.26 184.5,209 ; 181.38,203.21 CON_XMM3.176 ; CON_XMM3.176 181.38,204.58 ; CON_XMM3.176 180.53,203.9 ; CON_XMM3.176 182.14,203.9 ; CON_XMM1.156 189.15,221.58 ; CON_XMM1.156 189.15,220.21 ; CON_XMM1.156 188.3,220.9 ; CON_XMM1.156 189.91,220.9 ; CON_XMM3.11 176.83,221.75 ; CON_XMM3.11 175.98,220.98 ; CON_XMM3.11 175.13,221.75 ; CON_XMM3.257 180.54,129.95 ; CON_XMM3.257 179.78,130.63 ; CON_XMM3.257 179.78,129.26 ; CON_XMM3.257 178.93,129.95 ; CON_XMM4.239 196.18,146.01 ; J10.14 10.96,181.65 ; J10.14 11.99,180.49 11.96,180.47 ; J10.14 11.99,182.68 ; J10.14 13.02,181.65 ; CON_XMM3.193 178.93,189.45 ; CON_XMM3.193 180.54,189.45 ; CON_XMM3.193 179.78,190.13 ; CON_XMM3.193 179.78,188.76 ; CON_XMM3.160 180.53,217.5 ; CON_XMM3.160 181.38,216.81 ; CON_XMM3.160 181.38,218.18 ; CON_XMM3.160 182.14,217.5 ; 200.16,186.73 CON_XMM2.53 ; CON_XMM2.53 199.47,186.05 ; CON_XMM2.53 200.16,185.28 ; CON_XMM2.53 201.01,186.05 ; CON_XMM2.127 200.92,118.05 ; CON_XMM2.127 200.16,117.28 ; CON_XMM2.127 200.16,118.81 ; 203.11,107.85 CON_XMM2.283 204.72,107.85 ; 193.98,126.38 CON_XMM4.118 ; CON_XMM4.118 193.98,124.93 ; CON_XMM4.118 194.67,125.7 ; CON_XMM4.118 193.13,125.7 ; 193.98,189.53 CON_XMM4.48 ; CON_XMM4.48 193.13,190.3 ; CON_XMM4.48 194.84,190.3 ; CON_XMM1.118 186.11,125.7 ; CON_XMM1.118 185.35,126.38 ; CON_XMM1.118 185.35,125.01 ; CON_XMM1.118 184.5,125.7 ; 189.15,184.51 CON_XMM1.198 ; CON_XMM1.198 189.91,185.2 ; CON_XMM1.198 189.15,185.88 ; CON_XMM1.198 188.3,185.2 ; CON_XMM3.107 175.98,135.73 ; CON_XMM3.107 176.74,135.05 ; CON_XMM3.107 175.98,134.36 ; CON_XMM3.107 175.13,135.05 ; J9.U8 14.67,200.7 ; J9.U8 14.67,202.76 ; J9.U8 14.75,201.65 15.62,201.65 ; J9.U8 14.59,201.65 13.72,201.65 ; CON_XMM1.261 186.7,126.55 ; CON_XMM1.261 187.55,125.78 ; CON_XMM1.261 188.4,126.55 ; CON_XMM2.272 204.79,117.2 ; CON_XMM4.101 193.24,140.15 ; CON_XMM4.101 192.38,139.38 ; CON_XMM4.101 191.53,140.15 ; J125.23 2.34,155.29 ; J125.23 2.34,157.65 ; J125.23 4.07,156.47 ; 181.38,138.61 CON_XMM3.246 ; CON_XMM3.246 180.53,139.3 ; CON_XMM3.246 182.14,139.3 ; CON_XMM3.246 181.38,139.98 ; 193.98,191.23 CON_XMM4.46 ; CON_XMM4.46 193.13,192 ; CON_XMM4.46 194.84,192 ; 8.64,120.68 J133.6 ; J133.6 6.74,122.58 ; J133.6 8.64,124.49 ; J133.6 10.55,122.58 ; CON_XMM1.53 183.75,186.73 ; CON_XMM1.53 183.75,185.36 ; CON_XMM1.53 184.51,186.05 ; CON_XMM1.53 182.9,186.05 ; CON_XMM1.149 187.55,227.53 ; CON_XMM1.149 188.31,226.85 ; CON_XMM1.149 187.55,226.16 ; CON_XMM1.149 186.7,226.85 ; CON_XMM4.114 193.98,128.33 ; CON_XMM4.114 193.98,129.78 ; CON_XMM4.114 194.67,129.09 ; CON_XMM4.114 193.13,129.09 ; CON_XMM2.182 206.32,198.8 ; CON_XMM2.182 205.56,199.48 ; CON_XMM2.182 204.71,198.8 ; CON_XMM2.182 205.56,198.11 ; CON_XMM3.165 180.54,213.25 ; CON_XMM3.165 178.93,213.25 ; CON_XMM3.165 179.78,213.93 ; CON_XMM3.165 179.78,212.56 ; CON_XMM4.53 191.53,186.05 ; CON_XMM4.53 192.38,185.28 ; CON_XMM4.53 193.24,186.05 ; CON_XMM3.154 181.38,221.83 ; CON_XMM3.154 182.23,222.6 ; CON_XMM3.154 180.53,222.6 ; 205.56,136.91 CON_XMM2.248 ; CON_XMM2.248 204.71,137.6 ; CON_XMM2.248 205.56,138.28 ; CON_XMM2.248 206.32,137.6 ; 185.35,209.93 CON_XMM1.24 ; CON_XMM1.24 186.2,210.7 ; CON_XMM1.24 184.5,210.7 ; CON_XMM3.156 181.38,221.58 ; CON_XMM3.156 181.38,220.21 ; CON_XMM3.156 180.53,220.9 ; CON_XMM3.156 182.14,220.9 ; J133.14 10.64,124.72 ; J133.14 10.64,126.58 ; J133.14 9.71,125.65 ; 192.38,134.28 CON_XMM4.107 ; CON_XMM4.107 191.53,135.05 ; CON_XMM4.107 193.24,135.05 ; CON_XMM3.105 175.13,136.75 ; CON_XMM3.105 175.98,137.43 ; CON_XMM3.105 176.74,136.75 ; CON_XMM3.105 175.98,136.06 ; 196.93,117.2 CON_XMM4.272 ; CON_XMM4.272 197.78,117.88 ; CON_XMM4.272 198.55,117.2 ; CON_XMM4.272 197.78,116.51 ; CON_XMM3.191 180.54,191.15 ; CON_XMM3.191 178.93,191.15 ; CON_XMM3.191 179.78,191.83 ; CON_XMM3.191 179.78,190.46 ; CON_XMM1.250 188.3,135.9 ; CON_XMM1.250 189.91,135.9 ; CON_XMM1.250 189.15,136.58 ; CON_XMM1.250 189.15,135.21 ; 203.96,125.78 CON_XMM2.261 ; CON_XMM2.261 203.11,126.55 ; CON_XMM2.261 204.81,126.55 ; 187.55,129.26 CON_XMM1.257 ; CON_XMM1.257 188.31,129.95 ; CON_XMM1.257 186.7,129.95 ; CON_XMM1.257 187.55,130.63 ; CON_XMM3.2 176.73,229.4 ; CON_XMM3.2 178.43,229.4 ; CON_XMM3.2 177.58,228.63 ; CON_XMM3.26 177.58,208.23 ; CON_XMM3.26 176.73,209 ; CON_XMM3.26 178.43,209 ; CON_XMM1.94 186.11,146.1 ; CON_XMM1.94 185.35,146.78 ; CON_XMM1.94 184.5,146.1 ; CON_XMM1.94 185.35,145.41 ; 177.58,226.93 CON_XMM3.4 ; CON_XMM3.4 176.73,227.69 ; CON_XMM3.4 178.43,227.69 ; CON_XMM4.35 193.24,201.35 ; CON_XMM4.35 191.53,201.35 ; CON_XMM4.35 192.38,200.58 ; CON_XMM2.167 203.96,212.23 ; CON_XMM2.167 203.96,210.86 ; CON_XMM2.167 203.11,211.55 ; CON_XMM2.167 204.72,211.55 ; CON_XMM4.120 193.13,124 ; CON_XMM4.120 193.98,123.23 ; CON_XMM4.120 194.84,124 ; 193.98,209.68 CON_XMM4.26 ; CON_XMM4.26 194.67,209 ; CON_XMM4.26 193.13,209 ; CON_XMM4.26 193.98,208.23 ; CON_XMM1.28 185.35,207.98 ; CON_XMM1.28 185.35,206.61 ; CON_XMM1.28 184.5,207.3 ; CON_XMM1.28 186.11,207.3 ; 18.82,191.6 J10.1 ; J10.1 20.46,190.52 ; J10.1 20.46,192.68 ; CON_XMM1.259 188.31,128.25 ; CON_XMM1.259 186.7,128.25 ; CON_XMM1.259 187.55,128.93 ; CON_XMM1.259 187.55,127.56 ; CON_XMM3.171 178.93,208.15 ; CON_XMM3.171 179.78,208.83 ; CON_XMM3.171 180.54,208.15 ; CON_XMM3.171 179.78,207.46 ; 197.78,135.13 CON_XMM4.250 196.93,135.9 ; CON_XMM4.154 198.55,222.6 ; CON_XMM4.154 197.78,221.91 ; CON_XMM4.154 197.78,223.28 ; CON_XMM1.13 183.75,220.73 ; CON_XMM1.13 183.75,219.36 ; CON_XMM1.13 184.51,220.05 ; CON_XMM1.13 182.9,220.05 ; CON_XMM3.187 178.93,194.55 ; CON_XMM3.187 180.54,194.55 ; CON_XMM3.187 179.78,193.86 ; CON_XMM3.187 179.78,195.23 ; 205.56,182.81 CON_XMM2.200 ; CON_XMM2.200 206.24,183.5 ; CON_XMM2.200 204.79,183.5 ; CON_XMM2.200 205.56,184.18 ; CON_XMM2.180 205.56,201.18 ; CON_XMM2.180 205.56,199.81 ; CON_XMM2.180 204.71,200.5 ; CON_XMM2.180 206.32,200.5 ; 187.55,224.46 CON_XMM1.151 ; CON_XMM1.151 188.31,225.15 ; CON_XMM1.151 186.7,225.15 ; CON_XMM1.151 187.55,225.83 ; 183.75,115.66 CON_XMM1.129 ; CON_XMM1.129 182.9,116.35 ; CON_XMM1.129 184.51,116.35 ; CON_XMM1.129 183.75,117.03 ; CON_XMM2.176 204.71,203.9 ; CON_XMM2.176 205.56,204.58 ; CON_XMM2.176 206.32,203.9 ; CON_XMM2.176 205.56,203.21 ; CON_XMM1.279 188.4,111.25 ; CON_XMM1.279 187.55,110.48 ; CON_XMM1.279 186.7,111.25 ; CON_XMM3.189 180.54,192.85 ; CON_XMM3.189 179.78,193.53 ; CON_XMM3.189 179.78,192.16 ; CON_XMM3.189 178.93,192.85 ; CON_XMM4.105 193.24,136.75 ; CON_XMM4.105 192.38,135.98 ; CON_XMM4.105 191.53,136.75 ; CON_XMM1.96 185.35,145.08 ; CON_XMM1.96 185.35,143.71 ; CON_XMM1.96 186.11,144.4 ; CON_XMM1.96 184.5,144.4 ; CON_XMM3.250 180.53,135.9 ; CON_XMM3.250 182.23,135.9 ; CON_XMM3.250 181.38,135.13 ; 203.96,124.08 CON_XMM2.263 ; CON_XMM2.263 204.81,124.85 ; CON_XMM2.263 203.11,124.85 ; CON_XMM1.50 185.35,189.28 ; CON_XMM1.50 186.11,188.59 ; CON_XMM1.50 185.35,187.91 ; CON_XMM1.50 184.5,188.59 ; CON_XMM1.15 183.75,219.03 ; CON_XMM1.15 182.9,218.35 ; CON_XMM1.15 183.75,217.66 ; CON_XMM1.15 184.51,218.35 ; CON_XMM2.149 203.96,227.53 ; CON_XMM2.149 203.11,226.85 ; CON_XMM2.149 203.96,226.16 ; CON_XMM2.149 204.72,226.85 ; CON_XMM1.202 188.3,181.8 ; CON_XMM1.202 189.15,181.11 ; CON_XMM1.202 189.91,181.8 ; CON_XMM1.202 189.15,182.48 ; CON_XMM1.281 188.4,109.55 ; CON_XMM1.281 186.7,109.55 ; CON_XMM1.281 187.55,108.78 ; CON_XMM1.136 186.2,110.4 ; CON_XMM1.136 185.35,109.63 ; CON_XMM1.136 184.5,110.4 ; CON_XMM3.28 178.43,207.3 ; CON_XMM3.28 176.73,207.3 ; CON_XMM3.28 177.58,206.53 ; CON_XMM3.281 178.93,109.55 ; CON_XMM3.281 180.63,109.55 ; CON_XMM3.281 179.78,108.78 ; 186.7,107.85 CON_XMM1.283 188.31,107.85 ; CON_XMM1.263 188.31,124.85 ; CON_XMM1.263 187.55,125.53 ; CON_XMM1.263 186.7,124.85 ; CON_XMM1.263 187.55,124.16 ; 13,201.65 12.13,201.65 J9.U4 ; CON_XMM4.116 193.98,126.63 ; CON_XMM4.116 193.13,127.4 ; CON_XMM4.116 194.84,127.4 ; 197.78,119.58 CON_XMM4.270 ; CON_XMM4.270 198.47,118.9 ; CON_XMM4.270 196.93,118.9 ; CON_XMM4.270 197.78,118.13 ; CON_XMM3.55 175.13,184.35 ; CON_XMM3.55 176.74,184.35 ; CON_XMM3.55 175.98,185.03 ; CON_XMM3.55 175.98,183.66 ; CON_XMM4.109 193.24,133.35 ; CON_XMM4.109 191.53,133.35 ; CON_XMM4.109 192.38,132.58 ; 175.98,137.76 CON_XMM3.103 ; CON_XMM3.103 175.98,139.13 ; CON_XMM3.103 176.74,138.45 ; CON_XMM3.103 175.13,138.45 ; 4.4,141.02 J_TYPEC.4 ; J_TYPEC.4 3.24,142 ; J_TYPEC.4 4.4,142.98 ; 205.56,131.81 CON_XMM2.254 ; CON_XMM2.254 206.32,132.5 ; CON_XMM2.254 204.71,132.5 ; CON_XMM2.254 205.56,133.18 ; CON_XMM1.44 184.5,193.7 ; CON_XMM1.44 186.11,193.7 ; CON_XMM1.44 185.35,194.38 ; CON_XMM1.44 185.35,193.01 ; 7.31,163.02 J125.8 ; CON_XMM2.125 200.16,118.98 ; CON_XMM2.125 200.16,120.51 ; CON_XMM2.125 200.92,119.74 ; CON_XMM4.165 196.18,214.01 ; CON_XMM4.57 193.24,182.65 ; CON_XMM4.57 192.38,181.88 ; CON_XMM4.57 191.53,182.65 ; CON_XMM3.129 175.13,116.35 ; CON_XMM3.129 175.98,117.03 ; CON_XMM3.129 175.98,115.66 ; CON_XMM3.129 176.74,116.35 ; CON_XMM4.261 196.87,126.55 ; CON_XMM4.261 196.18,125.86 ; CON_XMM4.261 196.18,127.23 ; CON_XMM4.279 196.18,112.01 ; CON_XMM3.94 178.43,146.1 ; CON_XMM3.94 176.73,146.1 ; CON_XMM3.94 177.58,145.33 ; 179.78,110.48 CON_XMM3.279 ; CON_XMM3.279 178.93,111.25 ; CON_XMM3.279 180.63,111.25 ; CON_XMM3.243 180.54,141.85 ; CON_XMM3.243 179.78,142.53 ; CON_XMM3.243 179.78,141.16 ; CON_XMM3.243 178.93,141.85 ; CON_XMM3.276 182.14,113.8 ; CON_XMM3.276 180.53,113.8 ; CON_XMM3.276 181.38,113.11 ; CON_XMM3.276 181.38,114.48 ; 13.11,211.8 J9.1 ; J9.1 15.02,213.71 ; J9.1 16.92,211.8 ; J9.1 15.02,209.9 ; CON_XMM2.107 200.92,135.05 ; CON_XMM2.107 200.16,135.73 ; CON_XMM2.107 200.16,134.36 ; 200.16,219.03 CON_XMM2.15 ; CON_XMM2.15 199.47,218.35 ; CON_XMM2.15 200.16,217.66 ; CON_XMM4.276 198.64,113.8 ; CON_XMM4.276 197.78,113.03 ; CON_XMM4.276 196.93,113.8 ; CON_XMM4.20 193.13,214.1 ; CON_XMM4.20 193.98,213.33 ; CON_XMM4.20 194.84,214.1 ; 189.15,215.11 CON_XMM1.162 ; CON_XMM1.162 189.91,215.8 ; CON_XMM1.162 189.15,216.48 ; CON_XMM1.162 188.3,215.8 ; CON_XMM1.125 182.9,119.74 ; CON_XMM1.125 184.51,119.74 ; CON_XMM1.125 183.75,120.43 ; CON_XMM1.125 183.75,119.06 ; CON_XMM4.182 197.02,198.8 ; CON_XMM4.182 197.78,199.48 ; CON_XMM4.182 197.78,198.11 ; 203.96,108.86 CON_XMM2.281 ; CON_XMM2.281 204.72,109.55 ; CON_XMM2.281 203.11,109.55 ; CON_XMM2.281 203.96,110.23 ; CON_XMM4.265 195.33,123.15 ; CON_XMM4.265 197.04,123.15 ; CON_XMM4.265 196.18,122.38 ; CON_XMM2.270 205.56,119.58 ; CON_XMM2.270 206.32,118.9 ; CON_XMM2.270 205.56,118.21 ; CON_XMM2.270 204.71,118.9 ; 16.85,198.58 15.1,198.58 J9.2 ; CON_XMM2.162 205.56,216.48 ; CON_XMM2.162 205.56,215.11 ; CON_XMM2.162 204.71,215.8 ; CON_XMM2.162 206.32,215.8 ; 201.76,187.83 CON_XMM2.50 ; CON_XMM2.50 202.61,188.59 ; CON_XMM2.50 200.91,188.59 ; 15.02,196.76 J9.2 ; J9.2 15.02,200.57 ; J9.2 14.94,198.58 13.19,198.58 ; 192.38,215.88 CON_XMM4.17 ; CON_XMM4.17 191.53,216.65 ; CON_XMM4.17 193.24,216.65 ; 177.58,141.93 CON_XMM3.98 ; CON_XMM3.98 178.43,142.7 ; CON_XMM3.98 176.73,142.7 ; 181.38,201.43 CON_XMM3.178 ; CON_XMM3.178 180.53,202.2 ; CON_XMM3.178 182.23,202.2 ; CON_XMM3.268 180.53,120.6 ; CON_XMM3.268 182.14,120.6 ; CON_XMM3.268 181.38,121.28 ; CON_XMM3.268 181.38,119.91 ; 183.75,200.66 CON_XMM1.35 ; CON_XMM1.35 182.9,201.35 ; CON_XMM1.35 183.75,202.03 ; CON_XMM1.35 184.51,201.35 ; 187.55,205.76 CON_XMM1.173 ; CON_XMM1.173 186.7,206.45 ; CON_XMM1.173 187.55,207.13 ; CON_XMM1.173 188.31,206.45 ; CON_XMM1.160 188.3,217.5 ; CON_XMM1.160 189.91,217.5 ; CON_XMM1.160 189.15,216.81 ; CON_XMM1.160 189.15,218.18 ; CON_XMM1.4 186.11,227.69 ; CON_XMM1.4 184.5,227.69 ; CON_XMM1.4 185.35,228.38 ; CON_XMM1.4 185.35,227.01 ; CON_XMM2.257 204.72,129.95 ; CON_XMM2.257 203.96,129.26 ; CON_XMM2.257 203.96,130.63 ; CON_XMM2.257 203.11,129.95 ; CON_XMM4.125 191.53,119.74 ; CON_XMM4.125 193.24,119.74 ; CON_XMM4.125 192.38,118.98 ; CON_XMM1.248 189.15,138.28 ; CON_XMM1.248 189.15,136.91 ; CON_XMM1.248 188.3,137.6 ; CON_XMM1.248 189.91,137.6 ; CON_XMM1.138 184.5,108.7 ; CON_XMM1.138 185.35,107.93 ; CON_XMM1.138 186.2,108.7 ; 177.58,124.93 CON_XMM3.118 ; CON_XMM3.118 178.43,125.7 ; CON_XMM3.118 176.73,125.7 ; CON_XMM3.200 182.14,183.5 ; CON_XMM3.200 181.38,182.81 ; CON_XMM3.200 181.38,184.18 ; CON_XMM3.200 180.53,183.5 ; CON_XMM1.134 186.2,112.1 ; CON_XMM1.134 184.5,112.1 ; CON_XMM1.134 185.35,111.33 ; 18.82,178.7 J10.2 20.46,179.78 ; CON_XMM2.189 203.11,192.85 ; CON_XMM2.189 204.72,192.85 ; CON_XMM2.189 203.96,193.53 ; CON_XMM2.189 203.96,192.16 ; CON_XMM4.191 195.33,191.15 ; CON_XMM4.191 196.18,190.38 ; CON_XMM4.191 197.04,191.15 ; CON_XMM2.279 204.72,111.25 ; CON_XMM2.279 203.11,111.25 ; CON_XMM2.279 203.96,111.93 ; CON_XMM2.279 203.96,110.56 ; 197.04,228.55 CON_XMM4.147 196.18,227.78 ; CON_XMM4.24 194.84,210.7 ; CON_XMM4.24 193.13,210.7 ; CON_XMM4.24 193.98,209.93 ; CON_XMM2.134 201.76,112.78 ; CON_XMM2.134 202.52,112.1 ; CON_XMM2.134 201.76,111.41 ; 183.75,136.06 CON_XMM1.105 ; CON_XMM1.105 184.51,136.75 ; CON_XMM1.105 182.9,136.75 ; CON_XMM1.105 183.75,137.43 ; 200.16,117.11 CON_XMM2.129 ; CON_XMM2.129 200.92,116.35 ; CON_XMM2.129 200.16,115.58 ; J10.44 20.88,181.65 ; J10.44 18.82,181.65 ; J10.44 19.85,180.62 ; J10.44 19.85,182.68 ; 192.38,113.88 CON_XMM4.131 ; CON_XMM4.131 191.53,114.65 ; CON_XMM4.131 193.24,114.65 ; CON_XMM1.241 186.7,143.55 ; CON_XMM1.241 188.31,143.55 ; CON_XMM1.241 187.55,144.23 ; CON_XMM1.241 187.55,142.86 ; CON_XMM2.26 202.52,209 ; CON_XMM3.270 182.14,118.9 ; CON_XMM3.270 180.53,118.9 ; CON_XMM3.270 181.38,119.58 ; CON_XMM3.270 181.38,118.21 ; 203.96,144.56 CON_XMM2.239 ; CON_XMM2.239 203.96,145.93 ; CON_XMM2.239 204.72,145.25 ; CON_XMM2.239 203.11,145.25 ; CON_XMM1.17 184.51,216.65 ; CON_XMM1.17 183.75,217.33 ; CON_XMM1.17 182.9,216.65 ; CON_XMM1.17 183.75,215.96 ; 205.56,135.21 CON_XMM2.250 ; CON_XMM2.250 204.71,135.9 ; CON_XMM2.250 206.32,135.9 ; CON_XMM2.250 205.56,136.58 ; 193.98,206.53 CON_XMM4.28 ; CON_XMM4.28 193.13,207.3 ; CON_XMM4.28 194.84,207.3 ; CON_XMM4.274 197.78,116.18 ; CON_XMM4.274 197.02,115.5 ; CON_XMM4.274 197.78,114.81 ; 200.16,204.06 CON_XMM2.31 ; CON_XMM2.31 200.16,205.43 ; CON_XMM2.31 200.92,204.75 ; J9.U4 12.05,200.7 ; J9.U4 12.05,202.76 ; CON_XMM2.158 205.56,219.88 ; CON_XMM2.158 206.32,219.2 ; CON_XMM2.158 205.56,218.51 ; CON_XMM2.158 204.71,219.2 ; 189.15,221.91 CON_XMM1.154 ; CON_XMM1.154 189.91,222.6 ; CON_XMM1.154 188.3,222.6 ; CON_XMM1.154 189.15,223.28 ; CON_XMM4.195 195.33,187.75 ; CON_XMM4.195 197.04,187.75 ; CON_XMM4.195 196.18,186.98 ; CON_XMM4.50 193.13,188.59 ; CON_XMM4.50 194.84,188.59 ; CON_XMM4.50 193.98,187.83 ; CON_XMM4.180 197.02,200.5 ; CON_XMM4.180 197.78,201.18 ; CON_XMM4.180 197.78,199.81 ; CON_XMM3.259 180.54,128.25 ; CON_XMM3.259 179.78,127.56 ; CON_XMM3.259 178.93,128.25 ; CON_XMM3.259 179.78,128.93 ; CON_XMM1.127 183.75,118.73 ; CON_XMM1.127 184.51,118.05 ; CON_XMM1.127 182.9,118.05 ; CON_XMM1.127 183.75,117.36 ; 14.61,182.68 J10.24 ; J10.24 14.61,180.62 ; J10.24 15.64,181.65 ; J10.24 13.58,181.65 ; 197.04,206.45 CON_XMM4.173 ; CON_XMM4.173 195.33,206.45 ; CON_XMM4.173 196.18,205.68 ; 192.38,222.68 CON_XMM4.9 ; CON_XMM4.9 193.24,223.45 ; CON_XMM4.9 191.53,223.45 ; CON_XMM4.138 193.13,108.7 ; CON_XMM4.138 193.98,109.46 ; CON_XMM4.138 194.84,108.7 ; CON_XMM4.138 193.98,107.93 ; CON_XMM2.55 201.01,184.35 ; CON_XMM2.55 199.47,184.35 ; CON_XMM2.55 200.16,185.03 ; CON_XMM2.55 200.16,183.58 ; CON_XMM3.9 175.13,223.45 ; CON_XMM3.9 175.98,222.76 ; CON_XMM3.9 176.74,223.45 ; CON_XMM3.9 175.98,224.13 ; J9.3 9.37,211.83 11.34,211.83 11.37,211.8 ; J9.3 9.34,213.71 ; J9.3 9.34,209.79 ; J9.3 9.31,211.83 7.33,211.83 ; CON_XMM1.195 188.31,187.75 ; CON_XMM1.195 187.55,187.06 ; CON_XMM1.195 187.55,188.43 ; CON_XMM1.195 186.7,187.75 ; CON_XMM4.149 196.18,227.61 ; CON_XMM4.4 193.22,227.69 ; CON_XMM4.4 193.98,227.01 ; CON_XMM4.4 193.98,228.38 ; CON_XMM4.4 194.67,227.69 ; 193.98,211.63 CON_XMM4.22 ; CON_XMM4.22 193.13,212.4 ; CON_XMM4.22 194.84,212.4 ; J125.2 7.22,159.02 ; CON_XMM4.238 196.93,146.1 ; CON_XMM4.238 198.64,146.1 ; CON_XMM4.238 197.78,145.33 ; 203.96,188.68 CON_XMM2.193 ; CON_XMM2.193 204.81,189.45 ; CON_XMM2.193 203.11,189.45 ; CON_XMM1.147 187.55,229.23 ; CON_XMM1.147 188.31,228.55 ; CON_XMM1.147 187.55,227.86 ; CON_XMM1.147 186.7,228.55 ; 200.91,192 CON_XMM2.46 202.52,192 ; CON_XMM1.103 182.9,138.45 ; CON_XMM1.103 183.75,139.13 ; CON_XMM1.103 183.75,137.76 ; CON_XMM1.103 184.51,138.45 ; 205.56,221.91 CON_XMM2.154 ; CON_XMM2.154 205.56,223.28 ; CON_XMM2.154 206.32,222.6 ; CON_XMM2.154 204.71,222.6 ; CON_XMM2.105 200.92,136.75 ; CON_XMM2.105 200.16,136.06 ; CON_XMM2.105 200.16,137.43 ; 192.38,120.68 CON_XMM4.123 ; CON_XMM4.123 193.24,121.45 ; CON_XMM4.123 191.53,121.45 ; CON_XMM4.15 192.38,217.58 ; CON_XMM4.15 193.24,218.35 ; CON_XMM4.15 191.53,218.35 ; CON_XMM2.22 202.61,212.4 ; CON_XMM2.22 201.76,213.16 ; CON_XMM2.22 200.91,212.4 ; 175.98,119.06 CON_XMM3.125 ; CON_XMM3.125 176.74,119.74 ; CON_XMM3.125 175.13,119.74 ; CON_XMM3.125 175.98,120.43 ; CON_XMM1.11 184.51,221.75 ; CON_XMM1.11 183.75,222.43 ; CON_XMM1.11 182.9,221.75 ; CON_XMM1.11 183.75,221.06 ; 185.35,189.61 CON_XMM1.48 ; CON_XMM1.48 184.5,190.3 ; CON_XMM1.48 185.35,190.98 ; CON_XMM1.48 186.11,190.3 ; 179.78,144.56 CON_XMM3.239 ; CON_XMM3.239 179.78,145.93 ; CON_XMM3.239 180.54,145.25 ; CON_XMM3.239 178.93,145.25 ; CON_XMM4.193 197.04,189.45 ; CON_XMM4.193 196.18,190.13 ; CON_XMM4.193 196.18,188.68 ; CON_XMM4.193 195.5,189.45 ; CON_XMM1.39 184.51,197.94 ; CON_XMM1.39 182.9,197.94 ; CON_XMM1.39 183.75,198.63 ; CON_XMM1.39 183.75,197.26 ; 179.78,210.86 CON_XMM3.167 ; CON_XMM3.167 179.78,212.23 ; CON_XMM3.167 178.93,211.55 ; CON_XMM3.167 180.54,211.55 ; 7.91,142.96 J_TYPEC.2 7.2,141.86 ; 177.58,111.33 CON_XMM3.134 ; CON_XMM3.134 176.73,112.1 ; CON_XMM3.134 178.43,112.1 ; 177.58,213.33 CON_XMM3.20 ; CON_XMM3.20 176.73,214.1 ; CON_XMM3.20 178.43,214.1 ; CON_XMM3.263 180.63,124.85 ; CON_XMM3.263 179.78,124.08 ; CON_XMM3.263 178.93,124.85 ; CON_XMM3.48 176.73,190.3 ; CON_XMM3.48 178.43,190.3 ; CON_XMM3.48 177.58,189.53 ; CON_XMM1.176 189.91,203.9 ; CON_XMM1.176 189.15,204.58 ; CON_XMM1.176 188.3,203.9 ; CON_XMM1.176 189.15,203.21 ; CON_XMM2.274 204.79,115.5 ; CON_XMM2.28 202.52,207.3 ; CON_XMM3.35 176.74,201.35 ; CON_XMM3.35 175.13,201.35 ; CON_XMM3.35 175.98,200.66 ; CON_XMM3.35 175.98,202.03 ; CON_XMM1.31 182.9,204.75 ; CON_XMM1.31 184.51,204.75 ; CON_XMM1.31 183.75,205.43 ; CON_XMM1.31 183.75,204.06 ; CON_XMM4.198 198.55,185.2 ; CON_XMM4.198 197.78,185.88 ; CON_XMM4.198 197.78,184.51 ; CON_XMM4.198 196.93,185.2 ; 202.61,127.4 CON_XMM2.116 200.91,127.4 ; CON_XMM4.254 196.93,132.5 ; CON_XMM4.254 198.64,132.5 ; CON_XMM4.254 197.78,131.73 ; CON_XMM2.101 200.16,140.83 ; CON_XMM2.101 200.16,139.46 ; CON_XMM2.101 200.92,140.15 ; CON_XMM4.158 197.78,218.43 ; 4.88,195.88 6.63,195.88 J9.8 ; 183.75,113.88 CON_XMM1.131 ; CON_XMM1.131 182.9,114.65 ; CON_XMM1.131 184.6,114.65 ; 175.98,202.36 CON_XMM3.33 ; CON_XMM3.33 175.13,203.05 ; CON_XMM3.33 176.74,203.05 ; CON_XMM3.33 175.98,203.73 ; J9.4 9.34,200.57 ; J9.4 9.34,196.76 ; J9.4 9.26,198.58 7.51,198.58 ; 179.78,187.06 CON_XMM3.195 ; CON_XMM3.195 178.93,187.75 ; CON_XMM3.195 179.78,188.43 ; CON_XMM3.195 180.54,187.75 ; CON_XMM3.252 180.53,134.2 ; CON_XMM3.252 181.38,133.43 ; CON_XMM3.252 182.23,134.2 ; CON_XMM1.178 188.3,202.2 ; CON_XMM1.178 189.15,202.88 ; CON_XMM1.178 189.91,202.2 ; CON_XMM1.178 189.15,201.51 ; CON_XMM2.276 204.79,113.8 ; 177.58,109.63 CON_XMM3.136 ; CON_XMM3.136 178.43,110.4 ; CON_XMM3.136 176.73,110.4 ; 177.58,209.93 CON_XMM3.24 ; CON_XMM3.24 176.73,210.7 ; CON_XMM3.24 178.43,210.7 ; 203.96,142.86 CON_XMM2.241 ; CON_XMM2.241 203.96,144.23 ; CON_XMM2.241 203.11,143.55 ; CON_XMM2.241 204.72,143.55 ; 202.61,125.7 CON_XMM2.118 ; CON_XMM3.147 179.78,229.23 ; CON_XMM3.147 178.93,228.55 ; CON_XMM3.147 180.54,228.55 ; CON_XMM3.147 179.78,227.86 ; CON_XMM4.112 193.13,130.8 ; CON_XMM4.112 194.84,130.8 ; CON_XMM4.112 193.98,130.03 ; 196.87,208.15 CON_XMM4.171 196.18,208.83 ; CON_XMM1.254 189.91,132.5 ; CON_XMM1.254 189.15,131.81 ; CON_XMM1.254 188.3,132.5 ; CON_XMM1.254 189.15,133.18 ; 189.15,118.13 CON_XMM1.270 ; CON_XMM1.270 188.3,118.9 ; CON_XMM1.270 190,118.9 ; 177.58,225.23 CON_XMM3.6 ; CON_XMM3.6 178.43,226 ; CON_XMM3.6 176.73,226 ; CON_XMM1.272 188.3,117.2 ; CON_XMM1.272 189.15,116.43 ; CON_XMM1.272 190,117.2 ; 20.24,124.72 J133.44 ; CON_XMM1.109 183.75,134.03 ; CON_XMM1.109 183.75,132.66 ; CON_XMM1.109 184.51,133.35 ; CON_XMM1.109 182.9,133.35 ; 196.18,212.23 CON_XMM4.167 196.87,211.55 ; J133.2 19.82,123.71 ; J133.2 19.82,121.45 ; J133.2 17.85,122.58 ; CON_XMM1.140 186.11,107 ; J9.8 6.71,197.86 ; J9.8 6.71,194.05 ; 196.18,144.23 CON_XMM4.241 ; CON_XMM4.241 196.87,143.55 ; CON_XMM4.241 196.18,142.86 ; CON_XMM4.6 194.84,226 ; CON_XMM4.6 193.13,226 ; CON_XMM4.6 193.98,225.23 ; CON_XMM2.11 200.92,221.75 ; CON_XMM2.11 200.16,221.06 ; CON_XMM2.11 200.16,222.43 ; CON_XMM3.283 179.78,108.61 ; 179.78,209.16 CON_XMM3.169 ; CON_XMM3.169 180.54,209.85 ; CON_XMM3.169 178.93,209.85 ; CON_XMM3.169 179.78,210.53 ; 197.78,196.33 CON_XMM4.184 ; CON_XMM4.184 198.64,197.1 ; CON_XMM4.184 196.93,197.1 ; 197.04,128.25 CON_XMM4.259 ; 203.96,212.56 CON_XMM2.165 ; CON_XMM2.165 203.11,213.25 ; CON_XMM2.165 203.96,213.93 ; CON_XMM2.165 204.72,213.25 ; CON_XMM2.35 200.16,202.03 ; CON_XMM2.35 200.16,200.66 ; CON_XMM2.35 200.92,201.35 ; CON_XMM2.103 200.16,139.13 ; CON_XMM2.103 200.92,138.45 ; CON_XMM2.103 200.16,137.76 ; CON_XMM3.140 178.34,107 ; CON_XMM4.103 193.24,138.45 ; CON_XMM4.103 191.53,138.45 ; CON_XMM4.103 192.38,137.68 ; CON_XMM4.178 197.78,202.88 ; CON_XMM4.178 197.02,202.2 ; CON_XMM4.178 197.78,201.51 ; 196.93,137.6 CON_XMM4.248 197.78,136.83 ; CON_XMM1.169 188.31,209.85 ; CON_XMM1.169 186.7,209.85 ; CON_XMM1.169 187.55,210.53 ; CON_XMM1.169 187.55,209.16 ; CON_XMM2.48 201.76,189.53 ; CON_XMM2.48 202.61,190.3 ; CON_XMM2.48 200.91,190.3 ; 197.04,192.85 CON_XMM4.189 195.33,192.85 ; CON_XMM2.109 200.16,134.03 ; CON_XMM2.109 200.16,132.66 ; CON_XMM2.109 200.92,133.35 ; 196.93,139.3 CON_XMM4.246 197.78,138.53 ; CON_XMM3.42 176.73,195.4 ; CON_XMM3.42 177.58,194.63 ; CON_XMM3.42 178.43,195.4 ; J133.24 13.84,124.72 ; 202.61,210.7 CON_XMM2.24 200.91,210.7 ; CON_XMM2.202 204.79,181.8 ; 202.61,124 CON_XMM2.120
  vias: v1(0.83,238.15) v1(0.83,235.61) v1(0.83,233.07) v1(0.83,230.53) v1(0.83,227.99) v1(0.83,225.45) v1(0.83,222.91) v1(0.83,220.37) v1(0.84,193.73) v1(0.84,191.19) v1(0.84,186.11) v1(0.84,183.57) v1(0.84,179.94) v1(0.84,178.49) v1(0.84,175.95) v1(0.84,174.4) v1(0.84,170.87) v1(0.84,168.33) v1(0.84,165.79) v1(0.84,163.25) v1(0.84,160.71) v1(0.84,158.17) v1(0.84,140.39) v1(0.84,137.85) v1(0.84,135.31) v1(0.84,132.77) v1(0.84,130.23) v1(0.84,127.69) v1(0.84,125.15) v1(0.84,122.61) v1(0.84,120.07) v1(0.84,117.53) v1(0.91,188.07) v1(0.86,155.32) v1(0.97,240.69) v1(1.02,196.3) v1(1.14,198.93) v1(2.11,136.58) v1(2.11,134.04) v1(2.11,131.5) v1(2.11,128.96) v1(2.11,126.42) v1(2.11,123.88) v1(2.11,121.34) v1(2.11,118.8) v1(2.31,242.49) v1(3.2,189.36) v1(3.28,171.42) v1(3.26,146.61) v1(3.38,240.72) v1(3.38,238.18) v1(3.38,235.64) v1(3.38,233.1) v1(3.38,230.56) v1(3.38,228.02) v1(3.38,225.48) v1(3.38,222.94) v1(3.38,220.4) v1(3.38,217.86) v1(3.38,215.32) v1(3.38,210.24) v1(3.38,207.7) v1(3.38,205.16) v1(3.38,202.62) v1(3.38,200.08) v1(3.38,192.46) v1(3.38,169.6) v1(3.38,167.06) v1(3.38,164.52) v1(3.38,161.98) v1(3.43,137.74) v1(3.38,135.31) v1(3.38,132.77) v1(3.38,130.23) v1(3.38,127.69) v1(3.38,125.15) v1(3.38,122.61) v1(3.38,120.07) v1(3.38,117.53) v1(3.56,186.59) v1(3.94,178.44) v1(4.09,175.44) v1(4.29,147.17) v1(4.65,243.03) v1(4.62,183.62) v1(4.65,118.8) v1(4.83,181.23) v1(5.03,173.76) v1(5.44,170.74) v1(5.52,120.69) v1(5.71,136.17) v1(5.77,133.53) v1(5.79,130.86) v1(5.77,128.3) v1(5.79,126.52) v1(5.92,231.83) v1(5.92,226.75) v1(5.92,224.21) v1(5.92,211.51) v1(5.92,208.97) v1(5.92,206.43) v1(5.92,203.89) v1(5.92,168.33) v1(5.92,165.79) v1(5.92,163.25) v1(5.89,138.33) v1(5.92,117.53) v1(5.99,191.24) v1(6.02,139.29) v1(6.07,240.69) v1(6.15,238.05) v1(6.12,188.42) v1(6.22,157.15) v1(6.3,135.13) v1(6.48,151.94) v1(7.06,176.38) v1(7.11,117.68) v1(7.19,243.03) v1(7.21,129.67) v1(7.32,132.23) v1(7.26,128.04) v1(7.52,140.21) v1(7.54,139.45) v1(7.59,183.49) v1(7.87,146.13) v1(8.05,146.78) v1(8.05,140.72) v1(8.36,237.54) v1(8.46,240.72) v1(8.46,233.1) v1(8.46,207.7) v1(8.46,205.16) v1(8.46,187.38) v1(8.61,220.09) v1(8.76,130.68) v1(9.45,189.2) v1(9.6,182.14) v1(9.73,243.03) v1(9.86,154.35) v1(10.19,206.32) v1(10.62,176.25) v1(10.67,216.36) v1(10.92,236.74) v1(11,231.83) v1(11,229.29) v1(11.05,225.68) v1(11,221.67) v1(11.05,154.89) v1(11.3,239.62) v1(11.58,198.81) v1(11.73,179.45) v1(12.24,202.92) v1(12.27,243.03) v1(13.49,235.69) v1(13.52,233.15) v1(13.51,176.5) v1(13.72,240.77) v1(13.79,238.66) v1(14.02,149.78) v1(14.45,176.53) v1(14.58,139.32) v1(14.61,138.56) v1(14.81,243.03) v1(14.86,217.42) v1(14.86,151.41) v1(15.29,147.6) v1(15.57,239.65) v1(15.75,234.52) v1(16.26,236.74) v1(16.48,144.32) v1(16.94,143.54) v1(17.12,144.32) v1(17.35,243.03) v1(17.55,228.9) v1(18.19,240.82) v1(18.34,228.9) v1(19.89,243.03) v1(20.35,237.08) v1(20.78,145.64) v1(20.85,239.52) v1(21.18,27.18) v1(22,231.37) v1(22.15,149.25) v1(22.3,219.56) v1(22.33,134.82) v1(22.43,243.03) v1(22.5,202.08) v1(22.71,240.84) v1(22.89,231.78) v1(23.01,140.79) v1(23.04,140.03) v1(23.16,218.34) v1(23.16,217.6) v1(23.16,216.87) v1(23.22,201.14) v1(23.24,133.68) v1(23.42,117.93) v1(23.6,119.08) v1(23.74,202.52) v1(24.33,203.02) v1(24.82,119.08) v1(24.79,104.5) v1(24.79,103.73) v1(24.94,194.49) v1(24.92,117.98) v1(24.97,243.03) v1(25.07,203.02) v1(25.28,205.57) v1(25.68,194.49) v1(26.04,205.58) v1(26.26,114.63) v1(26.54,240.82) v1(26.52,207.67) v1(26.54,113.98) v1(26.77,36.08) v1(27.33,207.77) v1(27.41,237.26) v1(27.38,208.69) v1(27.51,243.03) v1(27.51,113.08) v1(27.93,111.79) v1(28.17,152.44) v1(28.19,108.14) v1(28.27,57.33) v1(28.63,183.13) v1(28.68,181.36) v1(28.75,240.82) v1(28.8,150.71) v1(28.86,108.13) v1(28.85,67.01) v1(30.05,243.03) v1(30.06,112.21) v1(30.25,59.11) v1(30.4,36.3) v1(30.51,175.41) v1(30.55,114.36) v1(31.27,184.78) v1(31.77,183.07) v1(31.9,194.51) v1(32.41,243) v1(32.36,197.82) v1(32.44,196.27) v1(33.24,178.79) v1(33.25,145.8) v1(33.25,144.86) v1(33.25,141.86) v1(33.27,143.36) v1(33.27,73.08) v1(33.35,140.89) v1(33.71,185.56) v1(34.04,180.45) v1(33.99,132.08) v1(34.85,184.89) v1(34.95,0.84) v1(35.13,243.03) v1(35.13,32.1) v1(35.26,140.87) v1(35.74,147.55) v1(35.94,61.51) v1(36.73,140.84) v1(36.8,120.27) v1(36.88,208.56) v1(36.96,147.55) v1(37.34,176.05) v1(37.49,0.84) v1(37.67,243.03) v1(37.8,133.93) v1(37.9,119.02) v1(38.18,129.49) v1(38.43,208.56) v1(38.53,174.57) v1(38.9,212.47) v1(39.07,162.48) v1(39.19,214.12) v1(39.32,213.28) v1(39.34,118.31) v1(39.56,210.42) v1(39.57,133.68) v1(39.83,171.58) v1(39.9,129.95) v1(40.03,243) v1(40.03,0.84) v1(40.11,168.5) v1(40.18,217.86) v1(40.56,170) v1(40.67,128.8) v1(40.71,126.67) v1(40.69,118.31) v1(40.84,7.39) v1(41.05,220.9) v1(40.97,172.85) v1(41.17,220.17) v1(41.2,219.43) v1(41.3,133.96) v1(41.43,232.94) v1(41.43,232.03) v1(41.38,127.86) v1(41.66,224.38) v1(41.66,223.57) v1(41.66,222.83) v1(41.71,217.47) v1(41.84,213.9) v1(41.82,213.1) v1(41.91,216.32) v1(41.88,207.7) v1(41.96,214.63) v1(42.01,208.33) v1(41.96,171.37) v1(41.99,170.05) v1(42.01,166.8) v1(42.09,168.4) v1(42.16,132.84) v1(42.6,129.01) v1(42.57,0.84) v1(42.75,243.03) v1(44.83,120.93) v1(45.11,0.84) v1(45.29,243.03) v1(45.72,122.2) v1(47.65,0.84) v1(47.83,243.03) v1(48.16,117.02) v1(49.48,10.97) v1(50.01,77.33) v1(50.19,0.84) v1(50.29,114.33) v1(50.37,243.03) v1(52.73,0.84) v1(52.91,243.03) v1(52.96,119.84) v1(53.7,10.03) v1(54.33,75.97) v1(54.64,13.18) v1(54.89,201.42) v1(55.27,0.84) v1(55.45,243.03) v1(56.82,78.44) v1(57.81,0.84) v1(57.99,243.03) v1(60.35,0.84) v1(60.53,243.03) v1(61.21,87.63) v1(62.1,55.58) v1(62.13,29.79) v1(62.22,56.86) v1(62.89,0.84) v1(63.02,87.63) v1(63.07,243.03) v1(63.43,216.82) v1(63.82,219.48) v1(63.82,218.66) v1(63.86,220.24) v1(64.49,87.6) v1(65.43,0.84) v1(65.61,243.03) v1(65.68,184.15) v1(66.55,166.12) v1(66.52,87.58) v1(67.69,189.08) v1(67.67,188.34) v1(67.97,119) v1(67.97,0.84) v1(68.15,243.03) v1(68.4,87.71) v1(68.76,118.99) v1(70.33,87.58) v1(70.51,0.84) v1(70.69,243.03) v1(70.97,97.46) v1(71.12,94.31) v1(71.93,123.36) v1(72.47,156.34) v1(72.47,155.57) v1(72.49,87.63) v1(73.08,172.75) v1(73.08,171.98) v1(73.05,0.84) v1(73.23,243.03) v1(73.15,190.96) v1(73.15,190.32) v1(74.6,87.55) v1(75.03,107.26) v1(75.49,98.35) v1(75.59,0.84) v1(75.77,243.03) v1(76.91,109.25) v1(76.87,99.82) v1(77.5,30.28) v1(78.13,0.84) v1(78.31,243.03) v1(78.46,87.58) v1(79.35,138.99) v1(80.01,138.99) v1(79.96,137.46) v1(79.98,136.68) v1(80.24,88.54) v1(80.67,0.84) v1(80.85,243.03) v1(81.17,59.56) v1(82.16,60.22) v1(82.52,87.76) v1(82.76,61.49) v1(83.11,75.87) v1(83.21,0.84) v1(83.39,243.03) v1(83.39,107.82) v1(84.05,59.05) v1(84.41,61.29) v1(84.48,87.71) v1(85.23,59.05) v1(85.29,62.97) v1(85.75,0.84) v1(85.93,243.03) v1(86.29,64.9) v1(86.41,60.71) v1(86.49,87.58) v1(86.64,97.66) v1(87.19,62.69) v1(87.27,13.08) v1(87.35,61.36) v1(87.43,50.01) v1(87.93,13.08) v1(88.09,50.01) v1(88.27,64.92) v1(88.29,0.84) v1(88.47,243.03) v1(88.47,87.53) v1(89,60.42) v1(89.38,50.18) v1(89.95,64.3) v1(90.53,87.91) v1(90.83,0.84) v1(91.01,243.03) v1(90.98,203.78) v1(90.98,60.4) v1(91.04,49.58) v1(91.62,211.84) v1(91.92,64.28) v1(92.43,88.19) v1(93.37,0.84) v1(93.55,243.03) v1(93.73,86.74) v1(94.11,147.7) v1(95.02,85.8) v1(95.1,159.08) v1(95.45,228.52) v1(95.45,226.39) v1(95.71,149.28) v1(95.83,178.51) v1(95.83,175.03) v1(95.83,170.59) v1(95.83,164.41) v1(95.83,159.08) v1(95.91,0.84) v1(96.09,243.03) v1(96.24,150.14) v1(96.24,94.97) v1(96.77,86.51) v1(97.08,145.97) v1(97.71,178.51) v1(97.71,175.03) v1(97.71,170.59) v1(97.71,164.41) v1(97.71,147.68) v1(97.68,96.26) v1(97.94,214.5) v1(97.94,213.74) v1(97.88,92.62) v1(98.25,151.82) v1(98.22,150.11) v1(98.42,85.88) v1(98.45,0.84) v1(98.63,243.03) v1(98.78,95.4) v1(99.19,86.39) v1(99.49,93.42) v1(100.05,83.77) v1(100.66,95.76) v1(100.99,0.84) v1(101.07,85.88) v1(101.07,38.99) v1(101.17,243.03) v1(101.17,224.46) v1(101.29,100.18) v1(101.73,38.99) v1(102.33,124.76) v1(102.61,100.08) v1(102.97,86.4) v1(103.19,106.78) v1(103.16,105.53) v1(103.35,130.58) v1(103.53,0.84) v1(103.71,243.03) v1(103.78,43.67) v1(104.09,103.78) v1(104.09,102.59) v1(104.37,86.21) v1(104.57,92.56) v1(104.86,128.86) v1(105.2,96.2) v1(105.87,93.45) v1(106.07,0.84) v1(106.25,243.03) v1(106.32,85.93) v1(106.73,97.43) v1(106.93,92.63) v1(107.44,99.03) v1(108.05,93.9) v1(108.43,85.98) v1(108.61,0.84) v1(108.79,243.03) v1(108.89,92.71) v1(108.97,99.85) v1(109.45,15.09) v1(109.73,61.12) v1(110.08,92.61) v1(110.21,86.36) v1(110.74,94.64) v1(110.97,86.46) v1(111.15,0.84) v1(111.33,243.03) v1(111.28,60.39) v1(111.54,61.55) v1(111.91,94.64) v1(112.14,236.7) v1(112.12,86.49) v1(112.83,236.7) v1(112.93,86.46) v1(113.17,94.01) v1(113.26,60.63) v1(113.54,236.7) v1(113.69,0.84) v1(113.76,64.3) v1(113.87,243.03) v1(114.15,235.92) v1(114.29,94.03) v1(114.5,86.13) v1(114.63,236.7) v1(115.11,96.49) v1(115.29,64.57) v1(115.62,237.13) v1(116.21,95.35) v1(116.23,0.84) v1(116.31,63.4) v1(116.41,243.03) v1(116.46,86) v1(117.46,94.67) v1(117.68,63.17) v1(118.32,63.88) v1(118.49,85.93) v1(118.57,94.67) v1(118.67,171.2) v1(118.77,0.84) v1(118.95,243.03) v1(119.63,155.32) v1(119.66,161.93) v1(119.66,160.55) v1(119.68,93.14) v1(119.94,63.91) v1(120.14,171.32) v1(120.14,170.69) v1(120.14,169.34) v1(120.14,168.71) v1(120.14,168.07) v1(120.29,161.93) v1(120.29,160.55) v1(120.27,155.32) v1(120.5,86.18) v1(120.72,62.89) v1(120.9,93.17) v1(120.98,153.8) v1(121.18,161.93) v1(121.18,160.55) v1(121.16,155.32) v1(121.34,96.24) v1(121.31,0.84) v1(121.49,243.03) v1(121.47,171.45) v1(121.47,170.81) v1(121.47,169.65) v1(121.47,169.01) v1(121.48,167.36) v1(121.48,166.73) v1(121.62,153.8) v1(121.82,161.93) v1(121.82,160.55) v1(122.07,155.4) v1(122.15,136.37) v1(122.25,153.8) v1(122.33,86.18) v1(122.29,63.84) v1(122.53,121.39) v1(122.56,165.1) v1(122.73,155.37) v1(122.89,153.8) v1(123.19,165.1) v1(123.22,96.29) v1(123.32,154.61) v1(123.37,155.37) v1(123.83,165.1) v1(123.83,161.93) v1(123.83,160.53) v1(123.85,0.84) v1(124.03,243.03) v1(124.36,86.31) v1(124.46,161.93) v1(124.46,160.53) v1(124.64,193.29) v1(124.66,190.68) v1(124.66,188.09) v1(124.66,185.5) v1(124.87,165.1) v1(125.09,161.93) v1(125.09,160.53) v1(125.53,195.73) v1(125.47,171.27) v1(125.47,170.64) v1(125.47,170) v1(125.47,168.66) v1(125.47,168.02) v1(125.5,165.1) v1(126.14,165.1) v1(126.11,161.93) v1(126.11,160.53) v1(126.36,86.23) v1(126.39,0.84) v1(126.57,243.03) v1(126.75,161.93) v1(126.75,160.53) v1(126.79,171.3) v1(126.79,170.66) v1(126.79,170.03) v1(126.79,168.68) v1(126.79,168.05) v1(127.18,165.1) v1(127.22,42.14) v1(127.38,197.61) v1(127.38,161.93) v1(127.38,160.53) v1(127.53,108.84) v1(127.53,108.1) v1(127.74,175.36) v1(127.81,165.1) v1(128.19,153.15) v1(128.19,152.52) v1(128.19,151.88) v1(128.27,155.91) v1(128.27,155.27) v1(128.27,154.64) v1(128.45,165.1) v1(128.63,174.46) v1(128.68,179.96) v1(128.65,179.02) v1(128.65,178.1) v1(128.65,177.16) v1(128.68,173.52) v1(128.68,10.68) v1(128.93,0.84) v1(129.11,243.03) v1(129.24,199.44) v1(129.39,165.1) v1(129.54,161.93) v1(129.54,160.53) v1(129.46,136.96) v1(129.6,174.44) v1(129.57,173.53) v1(129.62,153.8) v1(129.62,153.16) v1(129.82,134.26) v1(130.02,165.1) v1(130.18,161.93) v1(130.18,160.53) v1(130.25,153.8) v1(130.25,153.16) v1(130.48,174.45) v1(130.48,173.5) v1(130.52,108.78) v1(130.81,161.93) v1(130.81,160.53) v1(130.96,166.52) v1(131.14,201.37) v1(131.38,178.09) v1(131.4,173.53) v1(131.42,167.13) v1(131.47,0.84) v1(131.65,243.03) v1(131.72,132.36) v1(132.08,167.08) v1(132.21,172.14) v1(132.18,171.4) v1(132.32,177.18) v1(132.31,173.53) v1(132.28,169.54) v1(132.28,168.91) v1(132.28,168.28) v1(132.38,99.87) v1(132.44,99.01) v1(132.91,88.09) v1(132.93,17.04) v1(133.22,178.11) v1(133.22,177.19) v1(133.25,176.32) v1(133.22,175.44) v1(133.18,174.41) v1(133.25,173.56) v1(133.24,172.64) v1(133.24,170.78) v1(133.6,130.45) v1(133.65,203.91) v1(134.01,0.84) v1(134.15,169.89) v1(134.14,167.14) v1(134.12,162.51) v1(134.14,161.6) v1(134.13,155.25) v1(134.19,243.03) v1(134.18,170.81) v1(134.15,160.72) v1(134.16,157.96) v1(134.15,156.14) v1(135.01,177.18) v1(135.02,162.54) v1(135.06,170.79) v1(135.08,156.16) v1(135.46,205.79) v1(135.48,128.57) v1(135.95,168.05) v1(135.97,172.62) v1(135.97,170.79) v1(135.95,168.99) v1(135.96,165.29) v1(135.99,160.75) v1(136.01,156.2) v1(135.99,153.41) v1(136.43,181.05) v1(136.55,0.84) v1(136.73,243.03) v1(136.8,171.71) v1(136.83,45.29) v1(136.88,178.1) v1(136.88,177.22) v1(136.89,174.44) v1(136.92,173.54) v1(136.93,172.66) v1(136.88,169) v1(136.88,164.38) v1(136.9,157.96) v1(136.86,153.37) v1(137.34,207.59) v1(137.31,126.64) v1(137.71,170.79) v1(137.73,49.78) v1(137.79,169.01) v1(137.81,166.2) v1(138.16,54.99) v1(138.71,176.27) v1(138.73,153.45) v1(138.76,170.75) v1(139.09,0.84) v1(139.17,209.42) v1(139.17,124.79) v1(139.2,53.86) v1(139.27,243.03) v1(139.32,48.81) v1(139.57,237.57) v1(139.63,173.49) v1(139.65,172.63) v1(139.64,167.08) v1(139.61,163.43) v1(139.64,161.64) v1(139.59,158.01) v1(139.62,155.2) v1(139.64,153.45) v1(139.69,178.09) v1(140.03,22.1) v1(140.2,49.83) v1(140.39,237.59) v1(140.53,173.54) v1(140.52,169) v1(140.54,157.02) v1(140.57,169.85) v1(140.55,167.08) v1(140.97,211.3) v1(141.05,122.91) v1(141.04,48.11) v1(141.33,237.62) v1(141.44,169.9) v1(141.45,167.09) v1(141.45,175.31) v1(141.47,171.7) v1(141.63,0.84) v1(141.81,243.03) v1(141.87,48.77) v1(142.09,237.59) v1(142.77,213.06) v1(142.95,121.01) v1(143.69,49.19) v1(144.17,0.84) v1(144.35,243.03) v1(144.48,171.29) v1(144.63,214.93) v1(144.83,119.13) v1(145.47,14.78) v1(146.2,216.64) v1(146.74,117.25) v1(146.71,0.84) v1(146.89,243.03) v1(147.7,218.24) v1(148.62,115.37) v1(149.25,0.84) v1(149.43,243.03) v1(149.5,57.18) v1(150.47,113.51) v1(151.46,57.15) v1(151.62,86.01) v1(151.63,21.36) v1(151.79,0.84) v1(151.97,243.03) v1(152.35,111.63) v1(152.54,84.15) v1(152.86,221.92) v1(153.31,171.73) v1(153.42,223.57) v1(154.23,109.75) v1(154.33,0.84) v1(154.51,243.03) v1(155.09,41.31) v1(155.68,174.04) v1(155.68,50.04) v1(155.8,223.64) v1(156.06,107.87) v1(156.87,0.84) v1(157.05,243.03) v1(158.27,63.3) v1(158.42,223.62) v1(158.69,107.53) v1(159.25,5.12) v1(159.41,0.84) v1(159.46,40.4) v1(159.59,243.03) v1(159.61,62) v1(160.38,63.27) v1(161.01,58.8) v1(161.04,44.96) v1(161.09,223.65) v1(161.16,60.86) v1(161.33,107.53) v1(161.59,55.22) v1(161.67,50.62) v1(161.67,46.08) v1(161.95,0.84) v1(162.13,243.03) v1(162.13,53.11) v1(162.46,55.32) v1(162.76,21.71) v1(162.92,53.14) v1(163.07,51.87) v1(163.27,55.32) v1(163.68,223.65) v1(163.78,54.23) v1(163.78,50.99) v1(163.79,50.36) v1(163.86,51.84) v1(163.91,48.11) v1(163.98,107.53) v1(163.98,55.32) v1(164.19,59) v1(164.49,54.23) v1(164.49,0.84) v1(164.59,51.84) v1(164.57,50.37) v1(164.62,47.09) v1(164.67,243.03) v1(164.72,72.98) v1(164.72,55.32) v1(164.67,46.2) v1(164.78,45.03) v1(165.1,60.96) v1(165.14,59.99) v1(165.3,54.23) v1(165.28,50.95) v1(165.3,49.3) v1(165.43,71.22) v1(165.4,58.09) v1(165.79,50.57) v1(165.99,29.06) v1(166.07,223.6) v1(166.24,47.04) v1(166.34,56.59) v1(166.65,107.54) v1(166.62,52.96) v1(166.59,48.13) v1(166.67,54.25) v1(167.03,0.84) v1(167.13,47.02) v1(167.21,243.03) v1(167.23,58.09) v1(167.23,53.24) v1(167.24,48.1) v1(167.16,43.89) v1(167.3,49.47) v1(168.02,70.03) v1(167.97,47.04) v1(168.08,224.53) v1(168.21,59.47) v1(168.2,41.48) v1(168.4,103.66) v1(168.4,58.01) v1(168.38,55.42) v1(168.58,43.1) v1(168.68,70.99) v1(168.68,46.94) v1(168.9,72.74) v1(168.88,51.84) v1(168.88,49.52) v1(168.88,48.73) v1(169.16,68.5) v1(169.29,107.54) v1(169.47,73.81) v1(169.65,60.95) v1(169.57,58.45) v1(169.65,56.03) v1(169.62,55.3) v1(169.65,51.05) v1(169.65,49.52) v1(169.65,48.73) v1(169.56,46.33) v1(169.6,45.36) v1(169.57,0.84) v1(169.75,243.03) v1(169.65,52.6) v1(169.65,51.84) v1(169.76,71.88) v1(170.43,51.84) v1(170.43,51.06) v1(170.71,55.33) v1(170.7,46.2) v1(170.79,58.55) v1(170.76,56.6) v1(170.79,16.61) v1(170.89,43.08) v1(171.04,71.72) v1(171.04,56.03) v1(171.25,226.9) v1(171.42,73.61) v1(171.95,107.53) v1(171.91,60.96) v1(172.03,46.89) v1(172.09,58.19) v1(172.06,56.03) v1(172.06,55.35) v1(172.09,46.08) v1(172.11,0.84) v1(172.29,243.03) v1(172.26,227.08) v1(172.75,50.28) v1(172.75,48.73) v1(172.75,47.96) v1(172.85,46.96) v1(172.88,71.83) v1(172.95,15.98) v1(173,100.28) v1(173.15,46.25) v1(173.23,45.21) v1(173.3,58.42) v1(173.28,56.08) v1(173.25,55.27) v1(173.33,43.99) v1(173.53,52.6) v1(173.53,50.28) v1(173.53,49.51) v1(173.52,48.73) v1(173.53,47.96) v1(173.58,46.96) v1(173.93,22.71) v1(174.07,227.81) v1(174.12,100.28) v1(174.09,72.31) v1(174.33,51.88) v1(174.45,50.83) v1(174.37,43.31) v1(174.46,58.22) v1(174.47,55.91) v1(174.47,55.14) v1(174.52,46.96) v1(174.61,229.63) v1(174.65,0.84) v1(174.83,243.03) v1(174.75,49.39) v1(174.8,48.29) v1(175,52.96) v1(175.06,50.6) v1(175.3,55.89) v1(175.31,44.75) v1(175.36,57.51) v1(175.54,73.46) v1(175.54,48.46) v1(175.54,46.18) v1(175.64,52.96) v1(175.62,49.43) v1(175.77,50.55) v1(176.15,45.19) v1(176.33,90.91) v1(176.28,56.08) v1(176.4,58.22) v1(176.43,56.72) v1(176.56,60.96) v1(176.81,73.96) v1(176.96,54.28) v1(177.04,52.96) v1(177.22,44.09) v1(177.19,0.84) v1(177.37,243.03) v1(177.39,43) v1(177.6,58.32) v1(177.75,57.09) v1(177.67,54.31) v1(178.13,74.78) v1(178.23,76.78) v1(178.31,9.68) v1(178.46,43.03) v1(178.64,58.75) v1(178.66,41.55) v1(179.65,58.72) v1(179.73,0.84) v1(179.83,16.64) v1(179.91,243.03) v1(179.96,68.35) v1(180.02,61.46) v1(180,57.46) v1(180.21,88.24) v1(180.52,86.64) v1(180.64,58.72) v1(180.61,42.57) v1(181.69,70.41) v1(181.94,66.81) v1(182.19,63.65) v1(182.22,61.24) v1(182.27,0.84) v1(182.45,243.03) v1(182.47,39.22) v1(182.73,78.97) v1(183.26,71.25) v1(183.87,67.03) v1(183.97,64.11) v1(184.3,60.02) v1(184.81,0.84) v1(184.99,243.03) v1(185.93,70.26) v1(185.9,69.09) v1(187.43,41.05) v1(187.35,0.84) v1(187.53,243.03) v1(189.36,100) v1(189.43,94.41) v1(189.89,0.84) v1(190.07,243.03) v1(190.12,166.7) v1(190.09,100) v1(190.14,64.85) v1(190.14,64.11) v1(190.73,41.05) v1(190.83,100) v1(191.36,167.06) v1(191.57,100) v1(192.18,14.76) v1(192.3,100) v1(192.43,0.84) v1(192.61,243.03) v1(192.63,63.88) v1(192.66,64.62) v1(194.39,64.97) v1(194.72,65.63) v1(194.97,0.84) v1(195.15,243.03) v1(195.12,64.97) v1(195.45,65.63) v1(197.51,0.84) v1(197.69,243.03) v1(198.48,59.88) v1(198.55,53.29) v1(199.24,59.87) v1(199.32,96.86) v1(199.64,95.12) v1(199.64,94.49) v1(199.64,92.58) v1(199.64,91.95) v1(199.64,91.31) v1(200.06,96.83) v1(200.05,0.84) v1(200.23,243.03) v1(202.49,17.04) v1(202.62,13.69) v1(202.59,0.84) v1(202.69,85.34) v1(202.67,83.74) v1(202.77,243.03) v1(203.07,62.99) v1(203.33,85.34) v1(203.3,83.74) v1(203.28,13.69) v1(203.61,81.99) v1(203.84,62.99) v1(203.94,83.74) v1(203.96,85.34) v1(204.04,82.58) v1(204.29,18.19) v1(204.47,81.99) v1(204.72,62.99) v1(205.13,0.84) v1(205.31,243.03) v1(205.28,12.95) v1(206.15,12.95) v1(206.6,156.9) v1(206.6,18.11) v1(206.68,157.71) v1(206.73,101.32) v1(207.29,167.23) v1(207.29,166.47) v1(207.34,150.52) v1(207.34,149.73) v1(207.39,165.74) v1(207.67,0.84) v1(207.85,243.03) v1(208.03,166.5) v1(208.15,165.74) v1(208.42,85.33) v1(208.42,13.04) v1(208.53,112.78) v1(208.53,112.01) v1(208.53,111.25) v1(208.53,110.49) v1(208.53,109.73) v1(208.61,173.61) v1(208.58,102.82) v1(208.71,107.19) v1(208.94,176.53) v1(208.91,175.79) v1(208.94,175.03) v1(208.94,58.95) v1(208.97,179.5) v1(208.99,178.74) v1(209.09,12.97) v1(209.4,173.61) v1(209.37,106.45) v1(209.68,144.45) v1(209.75,36.17) v1(209.89,143.58) v1(209.88,126.49) v1(209.88,125.73) v1(209.88,124.97) v1(209.93,12.97) v1(209.98,166.29) v1(209.98,165.66) v1(210.21,0.84) v1(210.39,243.03) v1(210.44,173.61) v1(210.44,157.76) v1(210.57,47.42) v1(210.67,159.69) v1(210.72,46.74) v1(210.95,166.27) v1(211.2,173.61) v1(211.43,159.69) v1(211.38,158.93) v1(211.58,166.27) v1(211.73,150.57) v1(211.73,149.78) v1(211.79,165.07) v1(211.94,5.41) v1(211.96,28.17) v1(212.06,159.28) v1(212.83,159.28) v1(212.75,0.84) v1(212.93,243.03) v1(213.23,111.79) v1(213.23,111.15) v1(213.23,110.52) v1(213.41,158.65) v1(213.79,5.41) v1(213.87,36.22) v1(214.15,159.03) v1(214.3,156.26) v1(214.3,155.45) v1(214.81,111.89) v1(215.04,6.88) v1(215.29,0.84) v1(215.47,243.03) v1(216.76,6.99) v1(217.17,217.91) v1(217.2,217.14) v1(217.7,165.76) v1(217.83,0.84) v1(218.01,243.03) v1(218.14,6.78) v1(218.5,165.72) v1(219.23,188.72) v1(220.04,227.1) v1(219.96,7.34) v1(220.37,0.84) v1(220.55,243.03) v1(221.28,112.6) v1(221.62,113.92) v1(221.64,113.23) v1(221.69,117.65) v1(221.87,112.17) v1(222.91,0.84) v1(223.09,243.03) v1(223.6,101.85) v1(223.56,14.14) v1(224.05,21.01) v1(224.23,166.55) v1(224.21,163.22) v1(224.21,162.48) v1(224.16,137.29) v1(224.43,116.51) v1(224.46,160.93) v1(224.49,160.07) v1(224.49,159.13) v1(224.89,21) v1(225.02,14.76) v1(225.3,195.35) v1(225.3,194.69) v1(225.45,0.84) v1(225.63,243.03) v1(226.87,28.28) v1(227.99,0.84) v1(228.17,243.03) v1(228.27,14.1) v1(228.3,13.28) v1(228.55,151.08) v1(228.55,150.34) v1(228.63,63.91) v1(228.8,204.55) v1(228.88,120.02) v1(229.24,122.84) v1(229.26,85.24) v1(229.36,85.88) v1(229.48,120.92) v1(229.49,62.23) v1(229.67,185.5) v1(229.72,88.52) v1(229.82,164.9) v1(229.82,164.16) v1(229.87,132.03) v1(229.92,90.46) v1(230.02,96.16) v1(230,60.25) v1(230.12,118.72) v1(230.19,124.23) v1(230.53,0.84) v1(230.63,115.24) v1(230.56,104.47) v1(230.63,60.25) v1(230.71,243.03) v1(230.76,65.49) v1(231.27,115.24) v1(231.27,114.6) v1(231.44,129.87) v1(231.45,131.07) v1(231.68,122.52) v1(231.67,91.74) v1(231.75,124.19) v1(231.8,95.63) v1(232.08,58.27) v1(232.21,108.81) v1(232.22,108.18) v1(232.18,107.54) v1(232.54,53.54) v1(232.64,223.16) v1(232.59,93.13) v1(233.12,55.04) v1(233.07,0.84) v1(233.25,243.03) v1(233.17,129.84) v1(233.32,223.16) v1(233.27,58.17) v1(233.68,122.25) v1(233.86,222.58) v1(233.86,221.92) v1(234.98,206.43) v1(234.98,205.69) v1(235.38,243) v1(235.61,0.84) v1(235.72,15.28) v1(236.04,14.4) v1(236.55,89.51) v1(236.57,67.7) v1(236.96,216.31) v1(238.07,12.34) v1(238.06,8.78) v1(238.15,0.84) v1(238.27,30.1) v1(238.46,47.89) v1(238.71,115.37) v1(238.71,114.73) v1(239.42,243.03) v1(240.66,0.97) v1(240.87,242.82) v1(242.65,2.57) v1(242.7,241.17) v1(243,239.5) v1(243.03,235.51) v1(243.03,233.6) v1(243.03,231.06) v1(243.03,228.52) v1(243.03,225.98) v1(243.03,223.44) v1(243.03,220.9) v1(243.03,218.36) v1(243.03,215.82) v1(243.03,213.28) v1(243.03,210.74) v1(243.03,208.2) v1(243.03,205.66) v1(243.03,203.12) v1(243.03,200.58) v1(243.03,198.04) v1(243.03,195.5) v1(243.03,192.96) v1(243.03,190.42) v1(243.03,187.88) v1(243.03,185.34) v1(243.03,182.8) v1(243.03,180.26) v1(243.03,177.72) v1(243.03,175.18) v1(243.03,172.64) v1(243.03,170.1) v1(243.03,167.56) v1(243.03,165.02) v1(243.03,162.48) v1(243.03,159.94) v1(243.03,157.4) v1(243.03,154.86) v1(243.03,152.32) v1(243.03,149.78) v1(243.03,147.24) v1(243.03,144.7) v1(243.03,142.16) v1(243.03,139.62) v1(243.03,137.08) v1(243.03,134.54) v1(243.03,132) v1(243.03,129.46) v1(243.03,126.92) v1(243.03,124.38) v1(243.03,121.84) v1(243.03,119.3) v1(243.03,116.76) v1(243.03,114.22) v1(243.03,111.68) v1(243.03,109.14) v1(243.03,106.6) v1(243.03,104.06) v1(243.03,101.52) v1(243.03,98.98) v1(243.03,96.44) v1(243.03,93.9) v1(243.03,91.36) v1(243.03,88.82) v1(243.03,86.28) v1(243.03,83.74) v1(243,82.27) v1(243,77.72) v1(243.03,76.12) v1(243.03,73.58) v1(243.03,71.04) v1(243.03,68.5) v1(243.03,65.96) v1(243.03,63.42) v1(243.03,60.88) v1(243.03,58.34) v1(243.03,55.8) v1(243.03,53.26) v1(243.03,50.72) v1(243.03,48.18) v1(243.03,45.64) v1(243.03,43.1) v1(243.03,40.56) v1(243.03,38.02) v1(243.03,35.48) v1(243.03,32.94) v1(243.03,30.4) v1(243.03,27.86) v1(243.03,25.32) v1(243.03,22.78) v1(243.03,20.24) v1(243.03,17.7) v1(243.03,15.16) v1(243.03,12.62) v1(243.03,10.08) v1(243.03,7.54) v1(243.03,5) v3(20.75,121.21) v3(47.45,178.23) v3(47.6,185.47) v3(47.6,184.58) v3(47.6,183.69) v3(47.71,174.16) v3(48.01,193.45) v3(48.01,192.53) v3(48.44,199.77) v3(48.44,198.86) v3(48.46,191.41) v3(48.46,190.53) v3(48.46,173.43) v3(49.15,164.87) v3(49.17,172.25) v3(49.17,166.6) v3(49.77,152.2) v3(49.77,151.28) v3(49.97,159.41) v3(49.97,158.5) v3(49.97,157.58) v3(54.84,156.54) v3(54.79,138.86) v3(54.94,191.74) v3(54.89,155.52) v3(55.02,174.09) v3(55.02,173.18) v3(55.14,137.95) v3(55.7,190.78) v3(55.7,138.86) v3(55.8,156.49) v3(55.8,155.52) v3(55.85,191.74) v3(55.93,174.09) v3(55.93,173.18) v3(56.06,137.95) v3(56.62,190.78) v3(56.72,156.49) v3(56.72,155.52) v3(56.67,138.86) v3(56.77,191.74) v3(56.85,174.09) v3(56.85,173.18) v3(56.97,137.95) v3(57.58,190.78) v3(57.63,156.49) v3(57.63,155.52) v3(57.58,138.86) v3(57.73,191.74) v3(57.78,174.12) v3(57.78,173.2) v3(57.89,137.95) v3(58.47,190.78) v3(60.83,190.91) v3(60.78,156.64) v3(60.78,155.73) v3(60.88,191.8) v3(60.91,174.07) v3(60.91,173.15) v3(60.93,138.89) v3(60.88,137.97) v3(61.7,156.64) v3(61.7,155.73) v3(61.85,191.8) v3(61.8,190.91) v3(61.82,174.07) v3(61.82,173.15) v3(61.85,138.86) v3(61.8,137.95) v3(62.64,156.62) v3(62.64,155.7) v3(62.71,190.91) v3(62.74,174.07) v3(62.74,173.15) v3(62.76,191.8) v3(62.76,138.86) v3(62.76,137.97) v3(63.63,190.91) v3(63.6,156.64) v3(63.6,155.73) v3(63.68,191.8) v3(63.68,174.09) v3(63.68,173.18) v3(63.68,138.86) v3(63.68,137.95) v3(64.06,172.14) v3(64.41,189.97) v3(64.64,127.76) v3(65.84,205.21) v3(65.96,148.87) v3(67.03,134.42) v3(67.56,135.89) v3(68.22,205.13) v3(68.96,138.18) v3(68.96,137.29) v3(69.37,169.06) v3(69.52,186.51) v3(70.08,152.12) v3(70.36,137.54) v3(71.25,137.54) v3(71.68,169.21) v3(71.86,186.46) v3(72.14,138.43) v3(72.21,139.37) v3(72.62,152.12) v3(73.03,138.43) v3(73.91,138.43) v3(73.91,137.54) v3(74.8,138.43) v3(74.8,137.54) v3(100.3,202.55) v3(100.3,199.14) v3(104.65,227.84) v3(104.65,226.95) v3(105.54,227.84) v3(105.54,226.95) v3(106.43,227.84) v3(106.43,226.95) v3(107.31,227.84) v3(107.31,226.95) v3(108.05,202.55) v3(108.05,199.14) v3(109.35,227.84) v3(109.6,226.82) v3(110.36,227.84) v3(110.62,226.82) v3(111.38,227.84) v3(111.63,226.82) v3(112.39,227.84) v3(112.65,226.82) v3(115.54,202.55) v3(115.54,199.14) v3(119.43,233.98) v3(120.41,100.1) v3(120.45,97.31) v3(120.8,99.19) v3(120.87,98.3) v3(121.44,233.96) v3(121.39,97.26) v3(121.74,99.29) v3(122.78,202.55) v3(122.78,199.14) v3(125.35,226.95) v3(125.86,227.84) v3(126.24,226.95) v3(126.75,227.84) v3(127.13,226.95) v3(127.64,227.84) v3(128.14,226.95) v3(128.52,227.84) v3(130.73,226.87) v3(130.73,209.63) v3(130.71,208.74) v3(131.01,227.76) v3(131.62,226.87) v3(131.9,227.76) v3(132.51,226.87) v3(132.79,227.76) v3(133.4,226.87) v3(133.68,227.76) v3(139.88,234.31) v3(140.82,234.34) v3(146.56,228.6) v3(148.87,228.6) v3(209.8,196.8) v3(209.8,195.71) v3(209.8,194.82) v3(209.8,193.93) v3(209.8,193.04) v3(209.93,191.74) v3(209.93,190.83) v3(209.93,189.89) v3(209.96,189) v3(210.71,206.76) v3(210.71,205.85) v3(210.71,204.88) v3(210.71,203.97) v3(210.71,202.98) v3(210.71,202.09) v3(210.77,197.71) v3(210.77,196.82) v3(210.77,195.94) v3(210.77,195.05) v3(210.82,191.9) v3(210.82,190.93) v3(210.82,189.99) v3(210.85,189.05) v4(141.76,180.7) v5(11.49,171.79) v5(11.49,170.98) v5(11.49,170.16) v5(11.49,169.35) v5(11.49,168.54) v5(11.49,167.72) v5(11.49,166.91) v5(11.49,166.1) v5(11.49,165.29) v5(11.49,164.47) v5(11.49,163.66) v5(11.49,162.85) v5(11.49,162.03) v5(11.49,161.22) v5(11.49,160.41) v5(11.49,159.6) v5(11.49,158.78) v5(12.31,171.79) v5(12.31,170.98) v5(12.31,170.16) v5(12.31,169.35) v5(12.31,168.54) v5(12.31,167.72) v5(12.31,166.91) v5(12.31,166.1) v5(12.31,165.29) v5(12.31,164.47) v5(12.31,163.66) v5(12.31,162.85) v5(12.31,162.03) v5(12.31,161.22) v5(12.31,160.41) v5(12.31,159.6) v5(12.31,158.78) v5(13.12,171.79) v5(13.12,170.98) v5(13.12,170.16) v5(13.12,169.35) v5(13.12,168.54) v5(13.12,167.72) v5(13.12,166.91) v5(13.12,166.1) v5(13.12,165.29) v5(13.12,164.47) v5(13.12,163.66) v5(13.12,162.85) v5(13.12,162.03) v5(13.12,161.22) v5(13.12,160.41) v5(13.12,159.6) v5(13.12,158.78) v5(55.27,4.08) v5(55.27,3.27) v5(55.27,2.46) v5(56.08,4.08) v5(56.08,3.27) v5(56.08,2.46) v5(56.9,4.08) v5(56.9,3.27) v5(56.9,2.46) v5(57.71,4.08) v5(57.71,3.27) v5(57.71,2.46) v5(58.52,4.08) v5(58.52,3.27) v5(58.52,2.46) v5(59.33,4.08) v5(59.33,3.27) v5(59.33,2.46) v5(60.15,4.08) v5(60.15,3.27) v5(60.15,2.46) v5(60.96,4.08) v5(60.96,3.27) v5(60.96,2.46) v5(61.77,4.08) v5(61.77,3.27) v5(61.77,2.46) v5(62.59,4.08) v5(62.59,3.27) v5(62.59,2.46) v5(63.4,4.08) v5(63.4,3.27) v5(63.4,2.46) v5(64.21,4.08) v5(64.21,3.27) v5(64.21,2.46) v5(65.02,4.08) v5(65.02,3.27) v5(65.02,2.46) v5(65.84,4.08) v5(65.84,3.27) v5(65.84,2.46) v5(66.65,4.08) v5(66.65,3.27) v5(66.65,2.46) v5(67.46,4.08) v5(67.46,3.27) v5(67.46,2.46) v5(68.28,4.08) v5(68.28,3.27) v5(68.28,2.46) v5(69.09,4.08) v5(69.09,3.27) v5(69.09,2.46) v5(69.9,4.08) v5(69.9,3.27) v5(69.9,2.46) v5(70.71,4.08) v5(70.71,3.27) v5(70.71,2.46) v5(71.53,4.08) v5(71.53,3.27) v5(71.53,2.46) v5(72.34,4.08) v5(72.34,3.27) v5(72.34,2.46) v5(73.15,4.08) v5(73.15,3.27) v5(73.15,2.46) v5(73.96,4.08) v5(73.96,3.27) v5(73.96,2.46) v5(74.78,4.08) v5(74.78,3.27) v5(74.78,2.46) v5(75.59,4.08) v5(75.59,3.27) v5(75.59,2.46)
