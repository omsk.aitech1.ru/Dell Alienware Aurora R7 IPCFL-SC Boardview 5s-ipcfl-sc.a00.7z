# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_DQ24: length 94.8
  TOP w0.102: CON_XMM2.36 202.03,200.22 202.03,199.9 201.93,199.8 201.14,199.8 201.04,199.9 201.04,200.2 200.94,200.3 199.31,200.3 198.93,199.92 v1(198.55,199.92) 198.2,199.92 198.12,199.84 197.37,199.84 196.52,200.33 195.05,200.33 194.88,200.5 CON_XMM4.36
  TOP w0.159: XU1.AL29 v1(135.06,169.87)
  IN1 w0.102: v1(135.06,169.87) 135.48,170.29 135.48,170.97 136.69,172.19 139.81,172.19 141.03,173.41 141.03,176.08 143.29,178.35 143.78,178.35 144.3,178.87 144.3,179.35
  IN1 w0.14: v1(198.55,199.92) 198.45,199.82 197.51,199.82 197.24,200.09 197.24,200.09 196.66,200.67 195.29,200.67 194.44,199.82 193.5,199.82 192.65,200.67 191.5,200.67 191.36,200.53 191.36,200.1 191.19,199.92 190.68,199.92 190.53,200.08 190.53,200.28 190.42,200.38 190.14,200.38 189.59,199.82 188.64,199.82 187.79,200.67 186.7,200.67 185.85,199.82 184.94,199.82 184.09,200.67 182.92,200.67 182.07,199.82 180.85,199.82 180.19,200.48 179.1,200.48 178.23,199.62 177.27,199.62 176.4,198.75 175.51,198.75 167.48,190.72 157.24,190.72 151.28,184.76 151.01,184.76 150.49,185.27 150.22,185.27 150.03,185.08 150.03,184.81 150.55,184.3 150.55,184.03 150.36,183.84 150.09,183.84 149.77,184.16 149.31,184.16 148.97,183.82 148.97,183.46 148.08,182.58 147.52,182.58 144.3,179.35
M_CHB_DQ25: length 94.2
  TOP w0.102: CON_XMM4.38 195.66,198.63 196.51,198.63 197.36,198.14 198.47,198.14 v1(198.6,198.27) 199.97,198.6 200.37,198.6 201.49,198.15 202.03,198.15 202.31,198.42 202.31,198.65 202.17,198.8 CON_XMM2.38
  TOP w0.159: XU1.AM29 136.87,170.78 v1(136.87,170.79)
  IN1 w0.102: 142.28,176.32 142.28,175.24 141.54,174.49 141.54,173.34 139.98,171.79 137.77,171.79 137.04,171.06 137.04,170.96 v1(136.87,170.79)
  IN1 w0.14: 142.28,176.32 143.24,177.28 145.59,177.28 151.45,183.13 151.72,183.13 151.93,182.92 152.2,182.92 152.39,183.11 152.39,183.38 152.17,183.59 152.17,183.86 152.36,184.05 152.63,184.05 152.84,183.84 153.11,183.84 153.3,184.03 153.3,184.29 153.09,184.51 153.09,184.77 153.28,184.96 153.55,184.96 153.76,184.75 154.03,184.75 154.22,184.94 154.22,185.21 154.01,185.42 154.01,185.69 154.2,185.88 154.47,185.88 154.68,185.67 154.95,185.67 155.14,185.86 155.14,186.13 154.92,186.34 154.92,186.61 155.11,186.8 155.38,186.8 155.59,186.58 155.86,186.58 156.05,186.77 156.05,187.04 155.84,187.25 155.84,187.52 156.03,187.71 156.3,187.71 156.51,187.5 156.78,187.5 156.97,187.69 156.97,187.96 156.76,188.17 156.76,188.44 157.76,189.45 170.12,189.45 175.23,194.56 175.23,195.07 175.59,195.43 176.25,195.43 177.09,196.27 178.05,196.27 178.99,197.21 180.16,197.21 180.52,196.85 180.52,196.51 180.86,196.16 181.71,196.16 182.75,197.21 184.1,197.21 185.09,196.22 186.16,196.22 187.1,197.15 187.91,197.15 188.85,196.22 190.42,196.22 190.55,196.34 190.55,196.98 190.68,197.1 192.76,197.1 193.5,197.84 194.44,197.84 195.48,198.88 196.52,198.88 197.28,198.12 198.45,198.12 v1(198.6,198.27)
M_CHB_DQ26: length 92.1
  TOP w0.102: CON_XMM4.43 193.39,194.55 193.55,194.39 194.41,194.39 194.56,194.54 194.56,194.89 194.89,195.22 195.15,195.22 195.41,194.96 195.41,194.02 v1(195.55,193.88) 196.75,193.88 197.42,194.55 CON_XMM2.43
  TOP w0.159: XU1.AP29 v1(138.69,169.9)
  IN1 w0.102: 143.72,173.92 143.28,173.92 143.05,173.68 143.05,172.67 141.65,171.27 141.08,171.27 140.58,170.76 139.55,170.76 v1(138.69,169.9)
  IN1 w0.14: v1(195.55,193.88) 194.49,192.81 193.62,192.81 192.68,191.87 191.9,191.87 191.19,191.16 188.8,191.16 188.06,191.9 187.12,191.9 186.55,191.33 184.72,191.33 184.15,191.9 183.21,191.9 182.58,191.26 180.8,191.26 180.19,191.87 179.35,191.87 178.61,191.13 177.22,191.13 176.38,190.3 175.46,190.3 172.47,187.3 165.21,187.3 165.02,187.11 165.02,186.44 164.83,186.25 164.56,186.25 164.37,186.44 164.37,187.11 164.18,187.3 163.92,187.3 163.73,187.11 163.73,186.44 163.54,186.25 163.27,186.25 163.08,186.44 163.08,187.11 162.89,187.3 162.62,187.3 162.43,187.11 162.43,186.44 162.24,186.25 161.97,186.25 161.78,186.44 161.78,187.11 161.59,187.3 160.73,187.3 151.57,178.14 151.3,178.14 151.01,178.43 150.74,178.43 150.55,178.24 150.55,177.97 150.84,177.68 150.84,177.41 150.65,177.22 150.39,177.22 150.1,177.51 149.83,177.51 149.64,177.32 149.64,177.06 149.93,176.77 149.93,176.5 149.74,176.31 149.47,176.31 149.15,176.62 148.86,176.62 148.67,176.43 148.67,176.19 149.01,175.85 149.01,175.58 148.82,175.39 148.55,175.39 148.3,175.64 147.98,175.64 147.78,175.44 147.78,175.25 148.13,174.9 148.13,174.7 147.35,173.92 146.91,173.92 146.69,174.15 146.69,174.9 146.53,175.06 146.02,175.06 145.9,174.93 145.9,174.14 145.67,173.92 145.31,173.92 145.08,174.14 145.08,174.62 144.91,174.8 144.5,174.8 144.25,174.55 144.25,174.09 144.07,173.92 143.72,173.92
M_CHB_DQ27: length 91.4
  TOP w0.102: CON_XMM4.45 192.38,193.22 192.53,193.37 193.19,193.37 193.32,193.24 193.32,192.94 193.41,192.85 194.27,192.85 194.44,193.01 195,193.01 195.2,192.81 195.2,192.62 v1(195.72,192.1) 196.49,192.1 197.24,192.85 CON_XMM2.45
  TOP w0.159: XU1.AR29 139.17,170.04 139.34,169.87 v1(139.7,169.87)
  IN1 w0.102: v1(139.7,169.87) 139.7,170.2 139.8,170.31 140.85,170.31 141.19,170.64 141.76,170.64 143.15,172.03 144.53,172.03
  IN1 w0.14: v1(195.72,192.1) 195.4,191.78 195.4,188.26 194.94,187.81 193.62,187.81 193.02,188.41 191.84,188.41 191.16,187.73 188.82,187.73 188.14,188.41 186.94,188.41 186.46,187.93 184.79,187.93 184.31,188.41 183.1,188.41 182.62,187.93 181.1,187.93 180.59,188.44 179.43,188.44 178.71,187.73 177.32,187.73 176.45,186.87 175.67,186.87 173.75,184.95 173.3,184.95 173.11,185.14 173.11,185.64 173,185.75 172.62,185.75 172.47,185.6 172.47,185.14 172.28,184.95 172.01,184.95 171.82,185.14 171.82,185.84 171.63,186.03 171.36,186.03 171.17,185.84 171.17,185.14 170.98,184.95 170.71,184.95 170.52,185.14 170.52,185.84 170.33,186.03 170.06,186.03 169.87,185.84 169.87,185.14 169.68,184.95 160.17,184.95 159.82,184.59 159.82,184.3 159.28,183.77 159,183.77 158.72,183.5 158.72,183.16 158.98,182.91 158.98,182.65 158.62,182.29 158.35,182.29 158.06,182.57 157.8,182.57 157.61,182.38 157.61,182.11 157.89,181.83 157.89,181.56 157.7,181.37 157.43,181.37 157.15,181.65 156.88,181.65 156.69,181.46 156.69,181.2 156.97,180.91 156.97,180.64 156.78,180.45 156.51,180.45 156.23,180.74 155.96,180.74 155.77,180.55 155.77,180.28 156.06,180 156.06,179.73 155.87,179.54 155.6,179.54 155.32,179.82 155.05,179.82 154.86,179.63 154.86,179.36 155.14,179.08 155.14,178.81 154.95,178.62 154.68,178.62 154.4,178.9 154.13,178.9 148.23,173.01 148.23,172.72 148.46,172.49 148.46,172.29 148.2,172.03 146.73,172.03 146.02,171.32 145.24,171.32 144.53,172.03
M_CHB_DQ28: length 94.2
  TOP w0.102: CON_XMM2.183 203.41,197.94 203.23,197.76 201.53,197.76 200.34,197.29 199.77,197.29 v1(199.31,197.66) 199.21,197.56 198.48,197.56 198.27,197.76 197.49,197.76 196.98,197.26 195.96,197.26 195.68,197.54 195.68,197.84 195.79,197.94 CON_XMM4.183
  TOP w0.159: v1(135.97,169.87) XU1.AM28
  IN1 w0.102: v1(135.97,169.87) 136.27,169.87 136.72,170.32 137.03,170.32 137.3,170.59 137.3,170.97 137.9,171.57 140.06,171.57 141.79,173.31 141.79,174.44 143.92,176.56
  IN1 w0.14: 143.92,176.56 144.16,176.81 146.99,176.81 147.14,176.96 147.14,177.92 147.33,178.11 147.6,178.11 147.81,177.9 148.08,177.9 148.27,178.09 148.27,178.36 148.06,178.57 148.06,178.84 148.25,179.03 148.51,179.03 148.73,178.82 149,178.82 149.19,179.01 149.19,179.28 148.97,179.49 148.97,179.76 149.16,179.95 149.43,179.95 149.64,179.74 149.91,179.74 150.1,179.93 150.1,180.19 149.89,180.41 149.89,180.67 150.08,180.86 150.35,180.86 150.56,180.65 150.83,180.65 151.02,180.84 151.02,181.11 150.93,181.2 150.93,181.46 151.12,181.65 151.39,181.65 151.48,181.57 151.74,181.57 158.99,188.81 170.9,188.81 175.77,193.68 176.25,193.68 177.11,194.54 178.41,194.54 179.25,195.38 180.14,195.38 180.97,194.54 182.07,194.54 182.96,195.43 184,195.43 184.81,194.61 186.13,194.61 186.94,195.43 187.91,195.43 188.72,194.61 190.86,194.61 191.67,195.43 192.71,195.43 193.5,196.22 194.74,196.22 195.58,197.05 196.44,197.05 197.15,197.76 198.17,197.76 199.26,196.67 199.44,196.67 199.67,196.9 199.67,197.13 199.31,197.49 v1(199.31,197.66)
M_CHB_DQ29: length 95.5
  TOP w0.102: CON_XMM2.181 202.46,199.47 201.29,199.47 200.35,198.99 199.5,198.99 v1(199.32,199.17) 198.36,199.17 198.07,199.47 197.1,199.47 197,199.36 197,199.11 196.85,198.96 195.88,198.96 195.78,199.06 195.78,199.24 CON_XMM4.181
  TOP w0.159: v1(135.06,168.96) XU1.AL28
  IN1 w0.102: v1(135.06,168.96) XU1.AL28 135.51,170.01 135.81,170.31 136.08,170.31 136.4,170.63 136.4,171.07 136.6,171.27 136.97,171.27 137.68,171.99 139.9,171.99 141.28,173.37 141.28,174.54 141.89,175.15 141.89,176.43 143.21,177.75
  IN1 w0.14: v1(199.32,199.17) 199.01,198.86 198.83,198.86 198.68,199.01 198.68,199.24 198.45,199.46 197.32,199.46 196.48,200.31 195.71,200.31 194.86,199.46 193.54,199.46 192.91,198.83 191.87,198.83 191.01,197.97 188.72,197.97 187.96,198.73 186.99,198.73 186.21,197.94 184.94,197.94 184.12,198.75 183.08,198.75 182.45,198.12 180.72,198.12 180.16,198.68 179.12,198.68 178.33,197.89 177.14,197.89 176.33,197.08 175.74,197.08 168.75,190.08 157.5,190.08 148.54,181.13 148.28,181.13 147.96,181.44 147.69,181.44 147.5,181.25 147.5,180.99 147.82,180.67 147.82,180.4 147.63,180.21 147.36,180.21 147.04,180.53 146.77,180.53 146.58,180.34 146.58,180.07 146.9,179.75 146.9,179.48 146.71,179.29 146.44,179.29 146.12,179.61 145.86,179.61 145.52,179.27 145.52,178.33 144.93,177.75 143.21,177.75
M_CHB_DQ30: length 91.6
  TOP w0.102: CON_XMM2.190 203.15,192 202.97,191.82 202.97,191.21 202.79,191.03 202.34,191.03 202.23,191.13 v1(201.52,191.13) 201.25,191.13 200.94,191.45 200.94,191.9 200.71,192.13 199.82,192.13 199.24,191.54 198.96,191.54 198.5,192 CON_XMM4.190
  TOP w0.159: XU1.AR28 139.59,169 v1(139.6,169)
  IN1 w0.102: 143.18,171.65 141.95,170.42 141.34,170.42 141,170.09 141,169.69 140.74,169.43 140.04,169.43 139.61,169 v1(139.6,169)
  IN1 w0.14: v1(201.52,191.13) 200.96,191.13 200.82,190.99 200.82,188.73 200.58,188.49 199.31,188.49 198.58,187.76 197.46,187.76 196.62,186.92 195.5,186.92 194.81,186.23 193.43,186.23 192.94,186.71 190.24,186.71 189.76,186.23 188.7,186.23 188.22,186.71 186.84,186.71 186.36,186.23 184.79,186.23 184.31,186.71 182.77,186.71 182.29,186.23 180.85,186.23 180.37,186.71 179.14,186.71 178.51,186.08 177.29,186.08 176.43,185.22 175.16,185.22 174.25,184.31 161.54,184.31 154.52,177.3 154.25,177.3 154.07,177.48 153.81,177.48 153.62,177.29 153.62,177.02 153.8,176.84 153.8,176.57 153.61,176.38 153.34,176.38 153.06,176.66 152.79,176.66 152.6,176.47 152.6,176.2 152.88,175.92 152.88,175.65 152.69,175.46 152.42,175.46 152.14,175.75 151.87,175.75 151.68,175.56 151.68,175.29 151.96,175.01 151.96,174.74 151.77,174.55 151.51,174.55 151.22,174.83 150.95,174.83 150.76,174.64 150.76,174.37 151.05,174.09 151.05,173.82 150.86,173.63 150.59,173.63 150.31,173.91 150.04,173.91 149.85,173.72 149.85,173.46 150.13,173.17 150.13,172.9 149.94,172.71 149.67,172.71 149.39,173 149.12,173 148.93,172.81 148.93,172.54 149.21,172.26 149.21,171.99 148.73,171.5 146.99,171.5 146.34,170.85 144.3,170.85 143.5,171.65 143.18,171.65
M_CHB_DQ31: length 92.7
  TOP w0.102: CON_XMM4.188 198.73,193.7 198.81,193.62 200.74,193.62 200.99,193.37 200.99,193.27 201.37,192.89 v1(202.23,192.89) 202.54,192.89 202.69,193.04 202.69,193.78 202.87,193.95 203.3,193.95 203.71,193.55 204.01,193.55 204.67,194.21 205.04,194.21 CON_XMM2.188
  TOP w0.159: v1(138.7,169) 138.67,169 XU1.AP28
  IN1 w0.102: 143.86,172.59 143.25,172.59 141.63,170.96 141.13,170.96 140.69,170.53 139.71,170.53 139.17,169.99 139.17,169.48 v1(138.7,169)
  IN1 w0.14: 143.86,172.59 144.34,172.59 144.96,173.2 145.64,173.2 146.26,172.59 146.92,172.59 159.91,185.58 165.87,185.58 166.12,185.83 166.12,186.46 166.32,186.66 166.87,186.66 167.06,186.47 167.06,185.77 167.25,185.58 167.52,185.58 167.71,185.77 167.71,186.47 167.9,186.66 168.17,186.66 168.36,186.47 168.36,185.77 168.55,185.58 168.82,185.58 169.01,185.77 169.01,186.47 169.19,186.66 173.51,186.66 175.41,188.57 176.33,188.57 177.24,189.48 178.87,189.48 179.5,190.11 180.62,190.11 181.1,189.63 182.54,189.63 183.03,190.11 184.33,190.11 184.82,189.63 186.38,189.63 186.86,190.11 188.09,190.11 188.65,189.56 191.13,189.56 191.69,190.11 192.68,190.11 193.57,191.01 194.21,191.01 194.94,191.74 194.94,192.55 195.91,193.51 196.46,193.51 196.85,193.12 196.85,193.12 197.16,192.81 198.22,192.81 198.6,193.19 198.88,193.19 199.1,192.98 199.1,192.8 198.68,192.38 198.68,192.15 198.85,191.98 200.46,191.98 201.37,192.89 v1(202.23,192.89)
M_CHB_DQ32: length 84.6
  TOP w0.102: CON_XMM4.97 192.78,143.15 193.42,143.15 193.8,143.54 194.23,143.54 194.6,143.9 194.91,143.9 195.07,143.74 195.07,143.54 194.69,143.15 194.69,143 194.82,142.88 v1(195.4,142.88) 196.41,142.88 197.94,143.55 CON_XMM2.97
  TOP w0.159: XU1.AR12 v1(138.71,154.33)
  IN1 w0.102: v1(138.71,154.33) 138.94,154.1 140.25,154.1 140.81,153.54 141.02,153.54 141.77,152.79 142.53,152.79 143.41,151.92
  IN1 w0.14: 143.41,151.92 143.87,151.92 146.08,149.71 154.15,149.71 163.5,140.36 168.02,140.36 168.23,140.57 168.23,141.52 168.42,141.71 168.69,141.71 168.88,141.52 168.88,140.45 169.07,140.26 169.34,140.26 169.53,140.45 169.53,141.52 169.72,141.71 169.98,141.71 170.17,141.52 170.17,140.45 170.36,140.26 170.63,140.26 170.82,140.45 170.82,141.52 171.01,141.71 171.28,141.71 171.47,141.52 171.47,140.54 171.7,140.31 172.24,140.31 172.39,140.46 172.39,140.72 172.49,140.82 172.87,140.82 173.02,140.67 173.02,140.46 173.18,140.31 173.94,140.31 174.77,139.48 176.45,139.48 177.3,138.63 177.95,138.63 178.8,139.48 180.25,139.48 181.1,138.63 181.68,138.63 182.53,139.48 184.22,139.48 185.04,138.66 185.07,138.63 185.8,138.63 186.65,139.48 187.83,139.48 188.22,139.87 188.22,139.87 188.67,140.33 189.65,140.33 190.5,141.18 192.66,141.18 192.73,141.25 193.51,142.03 194.43,142.03 195.28,142.88 v1(195.4,142.88)
M_CHB_DQ33: length 84
  TOP w0.102: CON_XMM2.242 203.12,142.7 202.97,142.54 202.97,142.06 202.77,141.86 v1(201.52,141.86) 201.18,141.86 200.81,142.23 200.81,142.65 200.69,142.77 199.8,142.77 199.42,142.39 198.91,142.39 198.6,142.7 CON_XMM4.242
  TOP w0.159: XU1.AP12 v1(137.81,154.34)
  IN1 w0.102: 143.48,151.38 142.33,152.54 141.62,152.54 140.92,153.24 140.6,153.24 139.97,153.87 138.06,153.87 137.81,154.11 v1(137.81,154.34)
  IN1 w0.14: 143.48,151.38 143.55,151.38 145.86,149.07 153.89,149.07 163.33,139.62 173.63,139.62 174.12,139.14 176.23,139.14 177.07,138.3 178.23,138.3 179.48,139.12 180.11,139.12 180.92,138.3 182.4,138.3 183.21,139.12 184.03,139.12 184.88,138.27 186,138.27 187.1,139.12 188.02,139.12 188.87,139.97 190.96,139.97 191.81,140.82 192.86,140.82 193.71,141.67 194.93,141.67 195.78,142.52 196.51,142.52 197.37,141.89 198.11,141.89 199.77,142.54 200.5,142.54 201.18,141.86 v1(201.52,141.86)
M_CHB_DQ34: length 88.7
  TOP w0.102: CON_XMM2.102 201.76,138.71 201.66,138.61 201.07,138.61 200.94,138.73 200.94,139.14 200.79,139.3 199.98,139.3 199.31,138.63 v1(198.5,138.63) 197.49,138.63 196.31,139.3 CON_XMM4.102
  TOP w0.159: v1(135.97,155.24) XU1.AM13
  IN1 w0.102: v1(135.97,155.24) 136.4,154.81 136.4,154.17 136.73,153.84 136.99,153.84 137.41,153.42 137.41,152.88 138.43,151.87 139.97,151.87 140.44,151.4 141.51,151.4 142.6,150.31 142.6,150.06 143.76,148.89
  IN1 w0.14: v1(198.5,138.63) 197.48,138.63 196.63,139.48 195.28,139.48 194.44,138.63 193.55,138.63 192.7,137.78 192.66,137.78 192.66,137.78 190.18,137.78 190.01,137.6 190.01,137.42 190.19,137.25 190.19,137.06 190.06,136.93 188.67,136.93 188.22,136.47 188.22,136.47 187.83,136.08 186.68,136.08 185.83,135.23 185.07,135.23 184.22,136.08 184.03,136.08 184.03,136.08 183.47,136.08 183.47,136.08 182.69,136.08 181.84,135.23 181.1,135.23 180.71,135.62 180.71,135.62 180.25,136.08 178.9,136.08 178.05,135.23 177.3,135.23 176.91,135.62 176.91,135.62 176.45,136.08 175.38,136.08 174.73,136.73 173.96,136.73 172.87,137.82 162.97,137.82 153.77,147.01 153.07,147.01 152.88,147.2 152.88,147.34 152.69,147.53 152.43,147.53 152.24,147.34 152.24,147.2 152.05,147.01 151.78,147.01 151.59,147.2 151.59,147.34 151.4,147.53 151.13,147.53 150.94,147.34 150.94,147.2 150.75,147.01 150.48,147.01 150.29,147.2 150.29,147.34 150.1,147.53 149.84,147.53 149.65,147.34 149.65,147.2 149.46,147.01 149.19,147.01 149,147.2 149,147.34 148.81,147.53 148.54,147.53 148.35,147.34 148.35,147.2 148.16,147.01 147.89,147.01 147.7,147.2 147.7,147.34 147.51,147.53 147.25,147.53 147.06,147.34 147.06,147.2 146.87,147.01 145.65,147.01 143.76,148.89
M_CHB_DQ35: length 89.8
  TOP w0.102: CON_XMM4.104 196.23,137.6 197.4,136.93 v1(198.51,136.93) 199.36,136.93 199.83,137.4 200.7,137.4 201.19,136.91 201.93,136.91 202.08,137.06 202.08,137.27 CON_XMM2.104
  TOP w0.159: XU1.AL13 v1(135.06,155.24)
  IN1 w0.102: v1(135.06,155.24) 135.51,154.79 135.51,153.29 137.42,151.38 139.8,151.38 140.23,150.94 141.4,150.94 141.96,150.38 141.96,149.54 143.08,148.42 143.08,148.21 143.07,148.2 143.07,147.83 143.08,147.82 143.08,147.79 143.34,147.52
  IN1 w0.14: v1(198.51,136.93) 197.49,136.93 196.64,137.78 195.21,137.78 194.36,136.93 193.51,136.93 193.05,136.47 193.05,136.47 192.66,136.08 190.95,136.08 190.1,135.23 188.68,135.23 187.83,134.38 186.58,134.38 185.73,133.53 185.07,133.53 184.22,134.38 183.47,134.38 183.47,134.38 182.64,134.38 181.79,133.53 181.1,133.53 180.25,134.38 180.06,134.38 180.05,134.38 179.5,134.38 179.5,134.38 178.93,134.38 178.08,133.53 177.3,133.53 176.55,134.28 175.42,134.28 174.65,135.05 173.78,135.05 172.69,136.14 172.31,136.14 171.91,135.74 169.37,135.74 169.11,135.99 169.11,136.35 168.91,136.55 162.44,136.55 153.25,145.74 145.12,145.74 144.7,146.16 144.7,146.35 144.92,146.57 144.92,146.78 144.79,146.91 144.59,146.91 144.36,146.67 144.16,146.67 144.01,146.82 144.01,146.93 144.17,147.09 144.17,147.29 143.96,147.5 143.74,147.5 143.6,147.36 143.51,147.36 143.34,147.52
M_CHB_DQ36: length 85.9
  TOP w0.102: CON_XMM4.95 192.38,144.7 192.51,144.58 193.17,144.58 193.27,144.68 193.27,145.11 193.42,145.26 195.22,145.26 195.5,144.98 v1(195.5,144.58) 196.35,144.58 197.82,145.25 CON_XMM2.95
  TOP w0.159: v1(138.68,155.21) 138.68,155.21 XU1.AR13
  IN1 w0.102: v1(138.68,155.21) 138.91,154.98 139.23,154.98 139.69,154.52 140.45,154.52 140.8,154.17 142.1,154.17 143.59,152.68
  IN1 w0.14: v1(195.5,144.58) 194.65,143.73 193.52,143.73 192.67,142.88 191.9,142.88 191.59,143.18 190.75,143.18 190.38,142.8 190.38,142.27 190.14,142.03 188.68,142.03 187.83,141.18 186.42,141.18 186.26,141.02 186.26,140.51 186.07,140.33 185.07,140.33 184.22,141.18 182.71,141.18 182.52,141 182.52,140.49 182.37,140.33 181.1,140.33 181.1,140.33 181.08,140.33 180.23,141.18 178.69,141.18 178.54,141.02 178.54,140.51 178.38,140.36 178.34,140.33 177.3,140.33 176.45,141.18 174.98,141.18 174.12,142.04 174.12,142.24 174.5,142.62 174.5,142.85 173.94,143.41 173.61,143.41 173.18,142.98 169.24,142.98 169.06,143.15 169.06,143.66 168.88,143.84 168.61,143.84 168.4,143.64 168.4,143.13 168.25,142.98 167.95,142.98 167.76,143.17 167.76,143.65 167.57,143.84 167.3,143.84 167.11,143.65 167.11,143.17 166.92,142.98 166.65,142.98 166.46,143.17 166.46,143.65 166.27,143.84 166,143.84 165.81,143.65 165.81,143.17 165.62,142.98 165.35,142.98 165.17,143.17 165.17,143.65 164.98,143.84 164.71,143.84 164.52,143.65 164.52,143.17 164.33,142.98 164.06,142.98 163.87,143.17 163.87,143.65 163.68,143.84 163.41,143.84 163.22,143.65 163.22,143.17 163.03,142.98 162.71,142.98 162.53,143.15 162.53,143.59 162.32,143.8 161.86,143.8 154.68,150.98 146.61,150.98 144.9,152.68 143.59,152.68
M_CHB_DQ37: length 87
  TOP w0.102: CON_XMM4.240 198.47,144.4 198.88,144.81 199.36,144.81 199.77,144.4 200.77,144.4 200.89,144.27 200.89,143.86 201.19,143.56 v1(201.52,143.56) 202.69,143.56 202.87,143.74 202.87,144.22 203.04,144.4 CON_XMM2.240
  TOP w0.159: XU1.AP13 137.8,155.24 v1(137.8,155.24)
  IN1 w0.102: v1(137.8,155.24) 138.26,154.78 138.89,154.78 139.35,154.31 140.34,154.31 140.71,153.95 141.83,153.95 143.48,152.3
  IN1 w0.14: 143.48,152.3 144.39,152.3 146.34,150.34 154.41,150.34 162.41,142.34 164.16,142.34 164.35,142.15 164.35,141.83 164.54,141.64 164.81,141.64 165,141.83 165,142.15 165.19,142.34 165.45,142.34 165.64,142.15 165.64,141.77 165.83,141.58 166.1,141.58 166.15,141.63 166.29,141.77 166.29,142.15 166.48,142.34 166.75,142.34 166.94,142.15 166.94,141.77 167.1,141.6 167.42,141.6 167.59,141.77 167.59,142.15 167.78,142.34 172.82,142.34 174.35,140.82 176.25,140.82 177.1,139.97 178.27,139.97 179.37,140.82 180.06,140.82 180.91,139.97 182.42,139.97 183.52,140.82 184.03,140.82 184.88,139.97 186.22,139.97 187.32,140.82 188.02,140.82 188.87,141.67 190.19,141.67 190.3,141.77 190.3,141.78 191.03,142.52 192.86,142.52 193.7,143.36 194.8,143.36 195.91,144.22 196.46,144.22 197.29,143.39 198.69,143.39 199.51,144.21 200.53,144.21 201.19,143.56 v1(201.52,143.56)
M_CHB_DQ38: length 88.4
  TOP w0.102: CON_XMM2.247 202.66,138.45 202.51,138.3 201.52,138.3 200.51,137.79 v1(199.45,137.79) 199.45,137.55 199.19,137.29 199.01,137.29 197.99,138.3 197.23,138.3 197.13,138.2 197.13,137.95 197,137.82 196.81,137.82 CON_XMM4.247
  TOP w0.159: XU1.AM12 v1(135.97,154.33)
  IN1 w0.102: 143.76,148.41 142.28,149.9 142.28,150.34 141.45,151.17 140.34,151.17 139.85,151.65 137.8,151.65 136.43,153.03 136.43,153.64 135.97,154.09 v1(135.97,154.33)
  IN1 w0.14: 143.76,148.41 145.16,147.02 145.16,146.6 145.38,146.38 153.51,146.38 162.7,137.19 169.58,137.19 169.77,137 169.77,136.56 169.96,136.37 170.23,136.37 170.42,136.56 170.42,137 170.61,137.19 170.88,137.19 171.07,137 171.07,136.56 171.26,136.37 171.53,136.37 171.72,136.56 171.72,136.92 171.98,137.19 172.54,137.19 174.01,135.72 176.26,135.72 177.11,134.87 178.38,134.87 179.48,135.72 180.06,135.72 180.91,134.87 182.27,134.87 183.4,135.72 184.03,135.72 184.88,134.87 186.13,134.87 187.23,135.72 188.02,135.72 188.6,136.3 188.61,136.3 188.87,136.57 189.62,136.57 189.78,136.41 190.51,136.41 191.12,137.01 191.7,137.01 192.1,137.42 192.86,137.42 193.32,137.87 193.32,137.87 193.71,138.26 193.71,138.27 194.76,138.27 195.86,139.12 196.48,139.12 197.33,138.27 198.16,138.27 198.63,137.79 v1(199.45,137.79)
M_CHB_DQ39: length 89.6
  TOP w0.102: CON_XMM2.249 202.86,136.75 202.72,136.6 201.52,136.6 200.51,136.09 v1(199.46,136.09) 199.18,135.81 198.81,135.81 198.07,136.55 197.15,136.55 197.03,136.42 197.03,136.17 196.9,136.04 196.31,136.04 196.18,136.17 CON_XMM4.249
  TOP w0.159: XU1.AL12 v1(135.06,154.33)
  IN1 w0.102: 143.76,146.5 142.82,147.44 142.82,148.21 141.01,150.03 141.01,150.43 140.72,150.71 140.11,150.71 139.7,151.12 137.29,151.12 135.06,153.35 v1(135.06,154.33)
  IN1 w0.14: v1(199.46,136.09) 198.57,136.09 198.1,136.57 197.33,136.57 196.48,137.42 195.9,137.42 194.6,136.57 193.71,136.57 192.86,135.72 192.27,135.72 191.95,135.6 190.26,134.87 190.15,134.87 189.39,134.87 189.21,134.87 188.87,134.87 188.69,134.68 188.02,134.02 187.24,134.02 186.1,133.17 184.88,133.17 184.03,134.02 183.41,134.02 182.26,133.17 180.9,133.17 180.06,134.02 179.4,134.02 178.37,133.17 177.11,133.17 176.26,134.02 173.96,134.02 173.77,134.21 172.97,134.21 172.78,134.02 171.85,134.02 171.66,134.21 171.66,134.91 171.47,135.1 171.2,135.1 171.02,134.91 171.02,134.21 170.83,134.02 170.19,134.02 168.29,135.92 162.18,135.92 152.98,145.11 145.16,145.11 143.76,146.5
M_CHB_DQ40: length 90.8
  TOP w0.102: CON_XMM2.251 203.3,135.05 203.14,134.89 201.35,134.89 200.36,134.39 199.48,134.39 v1(199.31,134.56) 198.08,134.85 197.2,134.85 196.75,134.39 195.86,134.39 195.66,134.6 195.66,134.9 195.8,135.05 CON_XMM4.251
  TOP w0.159: XU1.AP10 v1(137.8,150.3)
  IN1 w0.102: v1(137.8,150.3) 138.28,149.82 139.74,149.82 142.32,147.24 142.32,146.1 143.76,144.65
  IN1 w0.14: 143.76,144.65 143.76,144.43 144.43,143.76 149.12,143.76 149.74,143.15 150.18,143.15 150.39,143.36 150.39,143.61 150.55,143.76 151.08,143.76 151.23,143.61 151.23,143.36 151.43,143.15 151.71,143.15 151.97,143.41 151.97,143.61 152.12,143.76 152.53,143.76 162.16,134.14 162.48,134.14 162.99,134.65 163.3,134.65 163.5,134.44 163.5,134.09 163.02,133.6 163.02,133.3 163.55,132.77 163.98,132.77 164.19,132.97 164.19,134.47 164.36,134.65 164.67,134.65 164.87,134.44 164.87,132.91 165.05,132.74 174.42,132.74 174.97,132.19 175.37,132.19 175.5,132.32 176.26,132.32 177.11,131.47 178.46,131.47 179.31,132.32 180.1,132.32 180.95,131.47 182.28,131.47 183.25,132.32 184.04,132.32 184.89,131.47 186.33,131.47 187.18,132.32 188.02,132.32 188.87,133.17 189.62,133.17 189.96,132.82 190.72,132.82 191.92,134.02 192.9,134.02 193.39,133.53 194.26,133.53 194.27,133.53 194.47,133.53 195.32,134.38 197.02,134.38 197.51,134.87 198.15,134.87 198.46,134.56 v1(199.31,134.56)
M_CHB_DQ41: length 90
  TOP w0.102: CON_XMM4.106 195.24,135.9 195.4,135.74 196.75,135.74 197.26,135.22 v1(198.58,135.22) 199.31,135.22 199.83,135.74 200.61,135.74 201.17,135.18 202.06,135.18 202.18,135.31 202.18,135.47 CON_XMM2.106
  TOP w0.159: XU1.AR10 v1(138.71,150.3)
  IN1 w0.102: 143.74,145.2 142.57,146.37 142.57,147.62 140.07,150.12 140.07,150.43 139.75,150.75 139.16,150.75 v1(138.71,150.3)
  IN1 w0.14: 143.74,145.2 143.89,145.2 144.67,144.42 152.77,144.42 161.91,135.28 165.32,135.28 165.51,135.09 165.51,133.59 165.7,133.4 165.97,133.4 166.16,133.59 166.16,135.09 166.35,135.28 166.7,135.28 166.87,135.12 166.87,133.59 167.06,133.4 167.32,133.4 167.51,133.59 167.51,135.12 167.68,135.28 168.03,135.28 168.2,135.11 168.2,133.78 168.61,133.38 174.83,133.38 175.52,132.68 176.45,132.68 177.3,131.83 178.11,131.83 178.96,132.68 180.2,132.68 181.05,131.83 181.65,131.83 181.66,131.83 181.9,131.83 182.74,132.68 184.22,132.68 185.07,131.83 185.73,131.83 186.58,132.68 187.83,132.68 188.68,133.53 190.69,133.53 191.54,134.38 192.66,134.38 192.66,134.38 192.75,134.38 193.4,135.03 194.67,135.03 195.5,135.86 196.67,135.86 197.31,135.22 v1(198.58,135.22)
M_CHB_DQ42: length 87.6
  TOP w0.102: CON_XMM2.113 197.43,129.95 196.76,129.27 v1(195.45,129.27) 194.88,129.84 193.22,129.84 193.12,129.95 193.12,130.68 192.94,130.86 192.53,130.86 192.38,130.71 CON_XMM4.113
  TOP w0.159: XU1.AR7 v1(138.71,147.56)
  IN1 w0.102: v1(138.71,147.56) 139.22,147.05 139.22,146.46 140.18,145.49 140.18,145.49 140.39,145.28 140.39,143.46 143.13,140.71
  IN1 w0.14: v1(195.45,129.27) 195.29,129.27 194.44,128.43 193.71,128.43 192.85,129.28 190.47,129.28 189.62,128.43 188.67,128.43 188.22,127.97 188.22,127.97 187.83,127.58 186.66,127.58 185.81,126.73 185.06,126.73 184.21,127.58 182.85,127.58 181.88,126.73 181.07,126.73 180.22,127.58 178.89,127.58 178.04,126.73 177.3,126.73 176.45,127.58 175.44,127.58 174.68,128.35 174.34,128.35 174.15,128.16 174.15,127.57 173.96,127.38 173.69,127.38 173.5,127.57 173.5,128.16 173.31,128.35 173.05,128.35 172.86,128.16 172.86,127.57 172.67,127.38 172.4,127.38 172.21,127.57 172.21,128.16 172.02,128.35 171.75,128.35 171.56,128.16 171.56,127.57 171.37,127.38 171.1,127.38 170.91,127.57 170.91,128.16 170.72,128.35 170.45,128.35 170.26,128.16 170.26,127.57 170.08,127.38 169.81,127.38 169.62,127.57 169.62,128.2 169.47,128.35 169.01,128.35 168.86,128.19 168.86,127.79 168.68,127.61 168.33,127.61 168.2,127.74 168.2,128.19 168.05,128.35 163.93,128.35 152.17,140.11 143.74,140.11 143.13,140.71
M_CHB_DQ43: length 88.9
  TOP w0.102: CON_XMM2.115 197.41,128.25 196.74,127.58 v1(195.52,127.58) 195.22,127.87 195.22,128.3 195.02,128.5 194.64,128.5 194.39,128.25 193.37,128.25 193.22,128.4 193.22,128.78 193.09,128.91 192.56,128.91 192.38,128.73 CON_XMM4.115
  TOP w0.159: v1(137.8,147.56) XU1.AP7
  IN1 w0.102: v1(137.8,147.56) 138.26,147.1 138.26,146.48 138.56,146.18 138.84,146.18 139.19,145.83 139.19,143.53 142.57,140.15
  IN1 w0.14: v1(195.52,127.58) 194.41,126.73 193.71,126.73 192.85,127.58 190.5,127.58 189.64,126.72 188.67,126.72 187.83,125.88 186.86,125.88 185.77,125.03 185.63,125.03 185.63,125.03 185.07,125.03 185.07,125.03 185.06,125.03 184.21,125.88 182.94,125.88 181.83,125.03 181.1,125.03 180.71,125.42 180.71,125.42 180.26,125.88 179.04,125.88 178.07,125.03 177.3,125.03 176.91,125.42 176.91,125.42 176.46,125.88 175.49,125.88 175.35,126.02 167.3,126.02 166.27,127.05 163.43,127.05 151.65,138.83 150.62,138.83 150.47,138.68 150.47,138.16 150.32,138.01 150.01,138.01 149.89,138.14 149.89,138.66 149.71,138.83 149.35,138.83 149.16,138.64 149.16,138.14 148.97,137.95 148.7,137.95 148.51,138.14 148.51,138.64 148.32,138.83 148.05,138.83 147.86,138.64 147.86,138.11 147.67,137.92 147.4,137.92 147.22,138.11 147.22,138.64 147.03,138.83 146.76,138.83 146.57,138.64 146.57,138.11 146.38,137.92 146.11,137.92 145.92,138.11 145.92,138.64 145.73,138.83 145.46,138.83 145.27,138.64 145.27,138.11 145.08,137.92 144.81,137.92 144.62,138.11 144.62,138.64 144.43,138.83 143.89,138.83 142.57,140.15
M_CHB_DQ44: length 89
  TOP w0.102: CON_XMM2.108 202.2,134.2 202.31,134.09 202.31,133.81 202.01,133.5 201.09,133.5 200.58,134.01 199.85,134.01 199.62,133.78 v1(198.65,133.78) 198.41,133.54 197.46,133.54 196.64,134.01 195.12,134.01 194.94,134.2 CON_XMM4.108
  TOP w0.159: v1(138.74,149.39) 138.71,149.39 XU1.AR9
  IN1 w0.102: 143.76,143.7 143.76,144.04 142.06,145.75 142.06,146.74 139.91,148.89 139.24,148.89 v1(138.74,149.39)
  IN1 w0.14: 143.76,143.7 143.76,143.51 144.14,143.13 148.77,143.13 149.49,142.41 152.99,142.41 163.29,132.11 164.79,132.11 164.98,131.92 164.98,130.95 165.17,130.76 165.43,130.76 165.62,130.95 165.62,131.92 165.81,132.11 166.08,132.11 166.27,131.92 166.27,130.95 166.46,130.76 166.73,130.76 166.92,130.95 166.92,131.92 167.11,132.11 167.38,132.11 167.57,131.92 167.57,131.09 167.77,130.89 168.1,130.89 168.21,131 168.21,131.92 168.4,132.11 174.27,132.11 175.4,130.98 176.45,130.98 176.91,130.52 176.91,130.52 177.3,130.13 177.94,130.13 179.04,130.98 180.25,130.98 181.09,130.13 181.1,130.13 181.87,130.13 182.98,130.98 184.23,130.98 184.68,130.52 184.68,130.52 185.07,130.13 185.88,130.13 186.85,130.98 187.83,130.98 188.68,131.83 189.71,131.83 190.07,132.18 191.05,132.18 191.54,132.68 192.66,132.68 193.79,133.17 194.84,133.17 195.69,134.02 196.62,134.02 197.11,133.53 198.4,133.53 v1(198.65,133.78)
M_CHB_DQ45: length 90.4
  TOP w0.102: CON_XMM2.253 202.88,133.35 202.46,133.17 201.47,133.17 200.52,132.7 199.75,132.7 v1(199.19,133.05) 199.03,133.2 197.15,133.2 196.39,132.44 195.76,132.44 195.63,132.56 195.63,132.79 CON_XMM4.253
  TOP w0.159: XU1.AP9 136.91,150.28 v1(136.91,150.28)
  IN1 w0.102: v1(136.91,150.28) 137.16,150.28 137.6,149.85 137.93,149.85 138.26,149.53 138.26,149.26 140.44,147.07 140.76,147.07 141.78,146.05 141.78,144.55
  IN1 w0.14: 141.78,144.55 143.84,142.49 148.51,142.49 149.22,141.78 152.72,141.78 164.63,129.87 169.09,129.87 169.28,130.06 169.28,130.57 169.47,130.76 169.73,130.76 169.92,130.57 169.92,130.06 170.11,129.87 170.38,129.87 170.57,130.06 170.57,130.57 170.76,130.76 171.03,130.76 171.22,130.57 171.22,130.06 171.41,129.87 171.68,129.87 171.87,130.06 171.87,130.5 172.06,130.69 172.33,130.69 172.52,130.5 172.52,130.06 172.71,129.87 174.7,129.87 175.45,130.62 176.26,130.62 177.11,129.77 178.48,129.77 179.33,130.62 180.06,130.62 180.9,129.77 182.31,129.77 183.42,130.62 184.04,130.62 184.89,129.77 186.04,129.77 187.14,130.62 188.02,130.62 188.87,131.47 189.74,131.47 189.89,131.32 190.93,131.32 191.93,132.32 192.85,132.32 193.57,131.6 194.51,131.6 195.4,132.49 196.55,132.49 197.23,133.17 199.07,133.17 v1(199.19,133.05)
M_CHB_DQ46: length 86.6
  TOP w0.102: CON_XMM2.258 202.96,129.09 202.69,128.83 202.69,128.55 202.39,128.25 v1(201.21,128.25) 200.96,128.49 200.96,128.96 200.83,129.09 199.73,129.09 199.36,128.73 199.09,128.73 198.98,128.83 198.98,129.29 198.88,129.39 198.65,129.39 198.36,129.09 CON_XMM4.258
  TOP w0.159: XU1.AR6 138.69,146.67 v1(138.71,146.67)
  IN1 w0.102: 142.99,140.4 140.18,143.2 140.18,145.2 v1(138.71,146.67)
  IN1 w0.14: 142.99,140.4 143.92,139.46 151.91,139.46 163.69,127.69 166.62,127.69 167.56,126.75 174.69,126.75 175.16,127.22 176.26,127.22 177.11,126.37 178.36,126.37 179.21,127.22 180.06,127.22 180.91,126.37 182.42,126.37 183.27,127.22 184.03,127.22 184.88,126.37 186.24,126.37 187.09,127.22 188.02,127.22 188.87,128.07 189.84,128.07 191.73,128.92 192.66,128.92 193.51,128.07 194.87,128.07 195.72,128.92 196.53,128.92 197.18,128.27 198.3,128.27 199.67,129.06 200.4,129.06 v1(201.21,128.25)
M_CHB_DQ47: length 88
  TOP w0.102: CON_XMM4.260 198.59,127.4 198.75,127.23 198.75,127.08 198.86,126.97 199.21,126.97 199.62,127.38 200.84,127.38 200.94,127.28 200.94,126.67 201.07,126.54 v1(201.5,126.54) 202.26,126.54 202.39,126.42 202.69,126.42 202.9,126.62 202.9,127.18 203.11,127.4 CON_XMM2.260
  TOP w0.159: v1(137.82,146.67) 137.77,146.67 XU1.AP6
  IN1 w0.102: 142,139.83 140.52,141.3 140.05,141.3 139.68,141.67 139.68,142.64 138.91,143.41 138.91,144.91 138.11,145.71 138.11,146.11 137.82,146.4 v1(137.82,146.67)
  IN1 w0.14: v1(201.5,126.54) 201.26,126.54 200.54,127.26 199.62,127.26 198.09,126.59 197.46,126.59 196.53,127.22 195.87,127.22 194.4,126.37 193.51,126.37 192.66,127.22 191.9,127.22 190.22,126.5 189.9,126.37 188.87,126.37 188.02,125.52 187.16,125.52 186.05,124.67 184.89,124.67 184.04,125.52 183.41,125.52 181.82,124.67 180.91,124.67 180.06,125.52 179.34,125.52 177.97,124.67 177.11,124.67 176.26,125.52 175.48,125.52 175.35,125.39 166.66,125.39 163.89,126.42 163.17,126.42 152.3,137.29 144.54,137.29 142,139.83
M_CHB_DQ48: length 103.3
  TOP w0.102: CON_XMM4.117 192.38,126.95 192.53,127.1 193.01,127.1 193.14,126.97 193.14,126.49 193.22,126.42 194.36,126.42 194.72,126.77 195.28,126.77 195.48,126.57 v1(195.48,125.93) 195.55,125.86 196.57,125.86 197.26,126.55 CON_XMM2.117
  TOP w0.159: XU1.AM10 v1(135.97,151.22)
  IN1 w0.102: 141.1,139.83 139.9,141.02 139.68,141.02 139.34,141.35 139.34,142.57 138.63,143.28 138.63,144.9 137.79,145.74 137.79,146.09 137.34,146.54 137.34,149.55 137.07,149.82 136.69,149.82 136.45,150.06 136.45,150.73 v1(135.97,151.22)
  IN1 w0.14: 141.1,139.83 144.31,136.62 150.09,136.62 152,136.62 152.45,136.17 152.45,135.9 152.03,135.48 152.03,135.22 152.22,135.03 152.49,135.03 152.91,135.44 153.18,135.44 153.37,135.25 153.37,134.99 152.95,134.57 152.95,134.3 153.14,134.11 153.41,134.11 153.82,134.53 154.09,134.53 154.28,134.34 154.28,134.07 153.87,133.65 153.87,133.38 154.06,133.19 154.32,133.19 154.74,133.61 155.01,133.61 155.2,133.42 155.2,133.15 154.78,132.74 154.78,132.47 154.97,132.28 155.24,132.28 155.66,132.69 155.93,132.69 156.17,132.45 156.17,132.27 155.78,131.88 155.78,131.65 155.96,131.47 156.29,131.47 156.54,131.72 156.9,131.72 159.89,128.74 159.89,122.07 161.73,120.22 164.32,120.22 168.41,124.31 175.41,124.31 175.54,124.18 176.44,124.18 177.29,123.33 177.99,123.33 178.96,124.18 180.25,124.18 181.1,123.33 181.81,123.33 183.01,124.18 184.22,124.18 185.06,123.33 185.07,123.33 185.07,123.33 185.74,123.33 186.59,124.18 187.83,124.18 188.22,124.57 188.22,124.57 188.67,125.03 189.72,125.03 190.57,125.88 192.84,125.88 193.7,125.03 194.35,125.03 195.26,125.93 v1(195.48,125.93)
M_CHB_DQ49: length 104.3
  TOP w0.102: CON_XMM4.262 200.42,125.7 201.35,124.76 201.75,124.76 201.83,124.84 v1(202.23,124.84) 202.51,124.84 202.67,124.99 202.67,125.63 202.84,125.81 204.44,125.81 204.57,125.68 204.57,125.27 204.72,125.12 204.98,125.12 CON_XMM2.262
  TOP w0.159: v1(135.06,151.22) XU1.AL10
  IN1 w0.102: v1(135.06,151.22) 135.51,150.77 135.51,150.17 136.29,149.39 136.29,147.59 137.08,146.8 137.08,146.47 137.57,145.99 137.57,145.68 138.3,144.94 138.3,143.55
  IN1 w0.14: v1(202.23,124.84) 201.26,124.84 200.48,125.62 199.21,125.62 198.48,124.9 197.15,124.9 196.53,125.51 195.74,125.51 194.64,124.67 193.51,124.67 192.66,125.52 192.11,125.52 191.84,125.25 190.99,125.25 190.41,124.67 188.87,124.67 188.02,123.82 187.25,123.82 186.15,122.97 184.89,122.97 184.04,123.82 183.41,123.82 182.3,122.97 180.91,122.97 180.06,123.82 179.44,123.82 178.34,122.97 177.11,122.97 176.26,123.82 175.53,123.82 175.38,123.67 168.67,123.67 164.59,119.58 161.47,119.58 159.25,121.8 159.25,128.47 157.19,130.53 156.62,130.53 156.44,130.35 155.98,130.35 150.35,135.98 144.04,135.98 138.92,141.11 138.92,142.43 138.3,143.05 138.3,143.55
M_CHB_DQ50: length 101.7
  TOP w0.102: CON_XMM4.124 196.25,120.6 197.54,119.86 198.07,119.86 v1(198.66,119.76) 199.14,119.76 199.87,120.5 200.51,120.5 201.14,119.86 202.03,119.86 202.16,119.99 202.16,120.19 CON_XMM2.124
  TOP w0.159: v1(135.02,147.56) 135.06,147.56 XU1.AM7
  IN1 w0.102: v1(135.02,147.56) 135.02,147.24 135.46,146.8 135.46,146.25 135.69,146.02 135.69,144.51 136.04,144.15
  IN1 w0.14: 136.04,144.15 136.04,139.98 142.88,133.14 147.17,133.14 147.71,132.6 147.71,132.33 147.32,131.94 147.32,131.67 147.51,131.48 147.78,131.48 148.17,131.87 148.43,131.87 148.62,131.68 148.62,131.42 148.24,131.03 148.24,130.76 148.43,130.57 148.69,130.57 149.08,130.96 149.35,130.96 156.42,123.89 156.42,120.63 160.47,116.58 165.66,116.58 169.03,119.96 174.96,119.96 175.06,119.85 175.06,119.2 175.18,119.08 176.46,119.08 176.91,118.62 176.91,118.62 177.3,118.23 178.1,118.23 178.95,119.08 180.25,119.08 181.1,118.23 181.75,118.23 182.6,119.08 184.2,119.08 185.05,118.23 185.63,118.23 185.63,118.23 185.85,118.23 186.69,119.08 187.83,119.08 188.22,119.47 188.22,119.47 188.25,119.51 188.25,119.71 188.47,119.93 189.5,119.93 190.02,120.45 191.1,120.45 191.43,120.78 192.85,120.78 193.69,119.93 194.38,119.93 195.22,120.78 196.65,120.78 197.51,119.91 198.51,119.91 v1(198.66,119.76)
M_CHB_DQ51: length 103
  TOP w0.102: CON_XMM4.126 194.59,118.9 194.79,118.69 196.59,118.69 197.39,118.23 v1(198.68,118.23) 199.26,118.23 199.77,118.75 200.94,118.75 201.5,118.19 202.16,118.19 202.23,118.26 202.23,118.42 CON_XMM2.126
  TOP w0.159: XU1.AL7 134.18,147.6 v1(134.18,147.52)
  IN1 w0.102: v1(134.18,147.52) 134.59,147.11 134.59,145.45 135.03,145.02 135.03,143.94
  IN1 w0.14: v1(198.68,118.23) 198.66,118.21 197.51,118.21 196.65,119.08 195.2,119.08 194.36,118.23 193.69,118.23 192.85,119.08 190.46,119.08 189.61,118.23 188.68,118.23 187.83,117.38 186.51,117.38 185.66,116.53 185.07,116.53 184.22,117.37 182.65,117.37 181.81,116.53 181.1,116.53 180.25,117.38 178.87,117.38 178.02,116.53 177.3,116.53 176.91,116.92 176.91,116.93 176.46,117.38 175.48,117.38 175.04,117.82 168.77,117.82 166.27,115.31 159.94,115.31 155.14,120.11 155.14,123.37 153.52,124.99 153.3,124.99 152.81,124.51 152.63,124.51 152.36,124.78 152.36,124.97 152.78,125.39 152.78,125.66 152.59,125.85 152.3,125.85 151.92,125.47 151.66,125.47 151.47,125.66 151.47,125.93 151.89,126.36 151.89,126.62 151.7,126.81 151.43,126.81 151.01,126.39 150.74,126.39 145.28,131.85 142.37,131.85 137.01,137.21 137.01,137.39 136.98,137.41 136.98,137.42 135.28,139.13 135.28,143.69 135.03,143.94
M_CHB_DQ52: length 102.8
  TOP w0.102: CON_XMM2.119 197.36,124.85 196.67,124.15 195.58,124.15 v1(195.5,124.23) 195.33,124.05 194.97,124.05 194.79,124.23 194.79,124.74 194.59,124.94 193.65,124.94 193.4,124.69 193.4,124.43 193.09,124.13 192.56,124.13 192.38,124.3 CON_XMM4.119
  TOP w0.159: v1(135.06,150.3) XU1.AM9
  IN1 w0.102: v1(135.06,150.3) 136.07,149.28 136.07,147.48 136.83,146.72 136.83,146.39 137.34,145.88 137.34,143.39 137.47,143.26
  IN1 w0.14: 137.47,143.26 138,142.73 138,141.13 143.78,135.35 150.07,135.35 150.58,134.84 150.58,134.57 150.05,134.04 150.05,133.77 150.24,133.58 150.51,133.58 151.04,134.11 151.31,134.11 151.5,133.92 151.5,133.65 150.94,133.09 150.94,132.83 151.13,132.64 151.4,132.64 151.96,133.19 152.23,133.19 152.42,133 152.42,132.74 151.86,132.18 151.86,131.91 152.05,131.72 152.32,131.72 152.87,132.28 153.14,132.28 153.47,131.95 153.47,131.72 153.14,131.39 153.14,131.17 153.39,130.91 153.77,130.91 153.97,131.11 154.31,131.11 158.62,126.8 158.62,121.54 161.21,118.95 164.85,118.95 168.85,122.95 174.43,122.95 174.9,122.48 176.4,122.48 177.25,121.63 178.09,121.63 179.06,122.48 180.25,122.48 181.1,121.63 181.81,121.63 182.66,122.48 184.23,122.48 184.68,122.02 184.68,122.02 185.07,121.63 185.76,121.63 186.61,122.48 187.83,122.48 188.68,123.33 190.26,123.33 191.11,124.18 192.84,124.18 193.7,123.33 194.37,123.33 195.28,124.23 v1(195.5,124.23)
M_CHB_DQ53: length 104
  TOP w0.102: CON_XMM4.264 198.58,124 198.69,124.1 200.22,124.1 201.19,123.13 v1(202.21,123.13) 202.76,123.13 202.9,123.27 202.9,123.47 202.59,123.77 202.59,124.08 202.82,124.31 203.17,124.31 203.49,124 CON_XMM2.264
  TOP w0.159: XU1.AL9 v1(134.14,150.3)
  IN1 w0.102: v1(134.14,150.3) 134.58,149.86 135.21,149.86 135.86,149.21 135.86,147.34 136.45,146.75 136.45,145.57 137.08,144.93 137.08,143.16 137.62,142.63
  IN1 w0.14: 137.62,142.63 137.62,140.61 143.52,134.71 147.79,134.71 152.97,129.53 154.06,129.53 154.58,129.01 154.58,127.92 157.98,124.52 157.98,121.28 160.94,118.31 165.11,118.31 168.74,121.94 175.26,121.94 175.43,122.12 176.26,122.12 177.11,121.27 178.52,121.27 179.37,122.12 180.08,122.12 180.93,121.27 182.28,121.27 183.38,122.12 184.03,122.12 184.88,121.27 186.12,121.27 187.22,122.12 188.02,122.12 188.87,122.97 191.12,122.97 191.97,123.82 192.66,123.82 193.51,122.97 194.95,122.97 195.8,123.82 196.53,123.82 197.05,123.29 198.25,123.29 198.86,123.9 200.43,123.9 201.19,123.13 v1(202.21,123.13)
M_CHB_DQ54: length 100.8
  TOP w0.102: CON_XMM4.269 195.83,119.39 195.83,119.2 195.94,119.1 196.7,119.1 197.15,119.56 198.04,119.56 198.58,119.02 199.29,119.02 v1(199.47,119.2) 199.62,119.05 200.79,119.05 201.33,119.59 202.65,119.59 202.8,119.74 CON_XMM2.269
  TOP w0.159: XU1.AM6 135.06,146.64 v1(135.02,146.64)
  IN1 w0.102: v1(135.02,146.64) 135.02,146.34 135.46,145.9 135.46,144.18
  IN1 w0.14: 135.46,144.18 135.75,143.89 135.75,139.37 142.61,132.5 145.53,132.5 148.18,129.84 149.57,129.84 150.02,129.39 150.02,129.13 149.71,128.82 149.71,128.55 149.9,128.36 150.17,128.36 150.47,128.67 150.74,128.67 150.93,128.48 150.93,128.21 150.62,127.9 150.62,127.63 150.81,127.44 151.08,127.44 151.39,127.75 151.66,127.75 155.78,123.63 155.78,120.37 160.2,115.95 165.96,115.95 168.52,118.5 175.32,118.5 175.54,118.72 176.26,118.72 177.11,117.87 178.38,117.87 179.48,118.72 180.06,118.72 180.91,117.87 182.21,117.87 183.06,118.72 184.04,118.72 184.89,117.87 186.42,117.87 187.27,118.72 188.02,118.72 188.87,119.57 190.03,119.57 190.25,119.79 191.27,119.79 191.9,120.42 192.67,120.42 193.52,119.57 194.88,119.57 195.73,120.42 196.48,120.42 197.33,119.57 198.06,119.57 198.42,119.2 v1(199.47,119.2)
M_CHB_DQ55: length 102.2
  TOP w0.102: CON_XMM2.271 203.29,118.05 203.12,117.88 201.12,117.88 200.61,117.37 199.57,117.37 v1(199.4,117.54) 199.02,117.54 198.98,117.5 198.63,117.5 198.27,117.86 197.26,117.86 196.72,117.32 195.86,117.32 195.73,117.45 195.73,117.59 CON_XMM4.271
  TOP w0.159: v1(134.14,146.64) XU1.AL6
  IN1 w0.102: 134.18,141.52 134.18,143.01 134.56,143.38 134.56,145.06 134.39,145.22 134.39,146.39 v1(134.14,146.64)
  IN1 w0.14: 134.18,141.52 134.8,140.91 134.8,139.19 136.35,137.64 136.35,136.97 142.13,131.19 145.04,131.19 152.61,123.62 152.86,123.62 153.29,124.05 153.54,124.05 153.81,123.79 153.81,123.56 153.33,123.08 153.33,122.9 153.68,122.56 154.32,122.56 154.48,122.4 154.48,121.72 154.38,121.62 154.03,121.62 153.93,121.52 153.93,121.05 154.05,120.93 154.33,120.93 154.48,120.78 154.48,119.87 159.68,114.68 166.57,114.68 168.73,116.84 175.31,116.84 175.49,117.02 176.26,117.02 177.11,116.17 178.32,116.17 179.42,117.02 180.06,117.02 180.91,116.17 182.25,116.17 183.42,117.02 184.04,117.02 184.89,116.17 186,116.17 187.1,117.02 188.02,117.02 188.87,117.87 190.28,117.87 191.13,118.72 192.66,118.72 193.51,117.87 194.73,117.87 195.83,118.72 196.48,118.72 197.32,117.88 198.09,117.88 198.44,117.54 v1(199.4,117.54)
M_CHB_DQ56: length 106.6
  TOP w0.102: CON_XMM2.275 202.53,114.65 202.41,114.53 201.49,114.53 200.35,113.89 199.87,113.89 v1(199.21,114.47) 197.22,114.47 196.65,113.89 195.71,113.89 195.5,114.1 195.5,114.45 195.7,114.65 CON_XMM4.275
  TOP w0.159: v1(132.31,146.64) XU1.AJ6
  IN1 w0.102: 132.22,142.9 132.75,143.43 132.75,146.21 v1(132.31,146.64)
  IN1 w0.14: v1(199.21,114.47) 197.29,114.47 196.44,115.32 195.83,115.32 194.99,114.47 193.51,114.47 192.66,115.32 192.1,115.32 191.35,114.57 190.28,114.57 189.98,114.27 189.74,114.27 189.54,114.47 188.87,114.47 188.02,113.62 187.31,113.62 186.21,112.77 184.88,112.77 184.03,113.62 183.52,113.62 182.64,112.94 182.42,112.77 180.96,112.77 180.11,113.62 179.38,113.62 178.53,112.77 177.11,112.77 176.26,113.62 175.52,113.62 175.38,113.48 172.06,113.48 171.94,113.36 171.87,113.29 171.87,112.53 171.68,112.34 171.41,112.34 171.22,112.53 171.22,113.29 171.03,113.48 170.47,113.48 170.28,113.29 170.28,112.61 170.1,112.43 169.76,112.43 169.56,112.63 169.56,113.29 169.37,113.48 169.07,113.48 167.67,112.08 158.68,112.08 145.12,125.64 144.08,125.64 143.23,126.5 143.23,127.46 142.88,127.81 141.91,127.81 133.63,136.1 133.63,137.92 133.02,138.53 133.02,140.2 132.22,141 132.22,142.9
M_CHB_DQ57: length 107.4
  TOP w0.102: CON_XMM4.128 195.22,117.2 195.4,117.02 196.8,117.02 197.33,116.48 198.55,116.48 v1(198.65,116.38) 199.11,116.38 199.8,117.07 200.79,117.07 200.91,116.94 200.91,116.61 201.04,116.48 201.98,116.48 202.14,116.64 202.14,116.82 CON_XMM2.128
  TOP w0.159: XU1.AJ7 133.15,148.39 133.15,148.48 v1(133.15,148.48)
  IN1 w0.102: v1(133.15,148.48) 133.15,148.48 133.71,147.92 133.71,143.62
  IN1 w0.14: v1(198.65,116.38) 198.51,116.53 197.5,116.53 196.65,117.38 195.4,117.38 194.3,116.53 193.69,116.53 192.85,117.38 190.55,117.38 189.7,116.53 188.67,116.53 188.22,116.07 188.22,116.07 187.83,115.68 186.84,115.68 185.88,114.83 185.07,114.83 184.22,115.68 182.68,115.68 181.83,114.83 181.1,114.83 181.02,114.91 180.25,115.68 179.03,115.68 177.92,114.83 177.3,114.83 176.91,115.22 176.91,115.22 176.45,115.68 175.51,115.68 175.29,115.9 168.79,115.9 166.94,114.04 159.41,114.04 153.29,120.17 153.29,122.04 152.84,122.49 152.57,122.49 151.99,121.91 151.72,121.91 151.53,122.1 151.53,122.37 152.11,122.95 152.11,123.22 151.92,123.41 151.65,123.41 151.07,122.83 150.8,122.83 150.61,123.02 150.61,123.29 151.2,123.87 151.2,124.14 151.01,124.33 150.74,124.33 150.16,123.75 149.89,123.75 149.7,123.94 149.7,124.2 150.28,124.79 150.28,125.05 144.8,130.53 141.89,130.53 135.69,136.73 135.69,137.77 134.32,139.14 134.32,140.76 133.89,141.19 133.89,143.44 133.71,143.62
M_CHB_DQ58: length 108.1
  TOP w0.102: CON_XMM2.282 203.41,108.7 203.05,108.33 203.05,108.13 202.69,107.77 202.21,107.77 202.08,107.9 201.32,107.9 v1(201.19,108.03) 200.53,108.7 199.5,108.7 199.31,108.51 199.31,108.03 199.14,107.85 198.93,107.85 198.78,108 198.78,108.57 198.65,108.7 CON_XMM4.282
  TOP w0.159: v1(129.57,146.64) XU1.AE6
  IN1 w0.102: v1(129.57,146.64) 129.97,146.24 129.97,140.06 129.96,140.04
  IN1 w0.14: v1(201.19,108.03) 200.66,108.56 199.72,108.56 198.1,107.9 197.54,107.9 196.46,108.52 195.25,108.52 194.77,109 194.27,109.37 193.58,109.37 192.37,108.7 191.65,108.7 190.16,107.9 188.67,107.9 188.05,108.52 187.24,108.52 185.92,107.67 184.88,107.67 184.03,108.52 182.89,108.52 182.04,107.67 180.95,107.67 180.09,108.53 179.52,108.53 178.04,107.67 177.11,107.67 176.26,108.52 156.3,108.52 129.96,134.86 129.96,140.04
M_CHB_DQ59: length 109
  TOP w0.102: CON_XMM4.135 194.48,111.25 194.64,111.4 194.64,111.79 194.94,112.09 195.33,112.09 195.5,111.91 v1(195.5,110.69) 195.63,110.57 196.75,110.57 197.43,111.25 CON_XMM2.135
  TOP w0.159: v1(130.4,147.56) 130.4,147.65 XU1.AF7
  IN1 w0.102: 131.62,139.95 131.39,140.18 131.39,146.6 130.43,147.56 v1(130.4,147.56)
  IN1 w0.14: 131.62,139.95 131.62,137.67 131.9,137.39 131.9,135.61 143.96,123.56 144.23,123.56 144.51,123.84 144.71,123.84 144.97,123.58 144.97,123.38 144.65,123.06 144.65,122.86 144.95,122.57 145.15,122.57 145.47,122.89 145.66,122.89 145.96,122.59 145.96,122.39 145.64,122.07 145.64,121.88 145.94,121.58 146.14,121.58 146.45,121.9 146.65,121.9 146.95,121.6 146.95,121.4 146.63,121.09 146.63,120.89 146.93,120.59 147.12,120.59 147.44,120.91 147.64,120.91 147.94,120.61 147.94,120.42 147.62,120.1 147.62,119.9 147.91,119.6 148.11,119.6 148.43,119.92 148.63,119.92 148.92,119.63 148.92,119.43 148.61,119.11 148.61,118.91 148.9,118.62 149.1,118.62 149.42,118.93 149.62,118.93 149.91,118.64 149.91,118.44 149.59,118.12 149.59,117.92 149.89,117.63 150.09,117.63 150.41,117.95 150.6,117.95 158.09,110.46 174.01,110.46 174.12,110.57 174.12,111.2 174.32,111.4 174.78,111.4 174.96,111.23 174.96,110.77 175.15,110.58 176.46,110.58 176.91,110.12 176.91,110.12 177.3,109.73 178.03,109.73 178.88,110.58 180.2,110.58 181.05,109.73 181.86,109.73 182.71,110.58 184.19,110.58 185.04,109.73 185.78,109.73 186.63,110.58 187.83,110.58 187.83,110.59 187.85,110.59 188.69,111.43 189.86,111.43 190.63,112.19 192.66,112.19 193.42,111.43 194.77,111.43 v1(195.5,110.69)
M_CHB_DQ60: length 108.1
  TOP w0.102: CON_XMM4.273 195.73,115.89 195.73,115.75 195.86,115.62 196.85,115.62 197,115.77 197,116.05 197.13,116.18 198.17,116.18 198.81,115.54 199.05,115.54 v1(199.21,115.7) 199.24,115.67 200.74,115.67 201.27,116.2 202.44,116.2 202.58,116.35 CON_XMM2.273
  TOP w0.159: XU1.AH7 v1(132.31,148.47)
  IN1 w0.102: v1(132.31,148.47) 132.74,148.04 132.74,147.35 133.31,146.77 133.31,143.44
  IN1 w0.14: v1(199.21,115.7) 198.57,115.7 198.11,116.17 197.33,116.17 196.48,117.02 195.88,117.02 194.77,116.17 193.53,116.17 192.68,117.02 192.1,117.02 191.81,116.73 190.84,116.73 190.11,116.01 189.76,116.01 189.6,116.17 188.87,116.17 188.02,115.32 187.32,115.32 186.22,114.47 184.88,114.47 184.03,115.32 183.39,115.32 182.29,114.47 180.91,114.47 180.06,115.32 179.44,115.32 178.34,114.47 177.1,114.47 176.25,115.32 175.49,115.32 175.21,115.04 168.83,115.04 167.18,113.39 159.17,113.39 148.74,123.81 148.74,124.16 149.42,124.83 149.42,125.01 148.97,125.46 148.7,125.46 148.09,124.85 147.82,124.85 147.63,125.04 147.63,125.31 148.25,125.92 148.25,126.19 148.06,126.38 147.79,126.38 147.17,125.77 146.9,125.77 146.71,125.96 146.71,126.22 147.33,126.84 147.33,127.11 144.57,129.87 141.65,129.87 135.03,136.5 135.03,137.77 133.88,138.91 133.88,140.52 133.56,140.84 133.56,143.19 133.31,143.44
M_CHB_DQ61: length 106.8
  TOP w0.102: CON_XMM4.130 195.73,115.34 196.67,115.34 197.21,114.81 198.4,114.81 v1(198.65,115.06) 198.78,114.94 199.26,114.94 199.67,115.34 200.81,115.34 200.94,115.21 200.94,114.94 201.07,114.81 202.13,114.81 202.21,114.88 202.21,115.04 CON_XMM2.130
  TOP w0.159: XU1.AH6 v1(132.31,147.56)
  IN1 w0.102: 133.05,143.27 133.05,146.75 132.31,147.48 v1(132.31,147.56)
  IN1 w0.14: 133.05,143.27 133.16,143.16 133.16,140.54 133.48,140.21 133.48,138.91 134.37,138.02 134.37,136.26 142.15,128.47 143.15,128.47 143.89,129.21 144.33,129.21 145.08,128.46 145.08,128.14 143.95,127 143.95,126.76 144.14,126.57 144.43,126.57 145.45,127.58 145.77,127.58 146,127.36 146,127.05 145.41,126.47 145.41,126.24 158.94,112.72 167.41,112.72 168.8,114.11 175.34,114.11 175.48,113.98 176.45,113.98 176.91,113.52 176.91,113.52 177.3,113.13 178.09,113.13 179.06,113.98 180.23,113.98 181.08,113.13 181.95,113.13 182.92,113.98 184.19,113.98 185.04,113.13 185.85,113.13 186.81,113.98 187.83,113.98 188.68,114.83 189.43,114.83 189.43,114.83 189.51,114.83 189.94,115.27 190.6,115.27 191.01,115.68 192.85,115.68 193.69,114.84 194.34,114.84 195.43,115.67 196.62,115.67 197.51,114.78 198.37,114.78 v1(198.65,115.06)
