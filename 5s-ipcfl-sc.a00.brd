# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1VSB_BOT_C on TOP (solid shape): 194.61,94.59 194.61,93.34 194.26,92.99 194.26,92.23 193.65,92.23 193.6,92.28 193.6,92.76 192.81,93.55 192.81,94.59 192.94,94.72 194.49,94.72
+1VSB_BOTR_C on TOP (solid shape): 196.67,94.56 196.67,93.27 196.34,92.94 196.34,92.48 196.27,92.41 195.5,92.41 195.43,92.48 195.43,93.12 195.2,93.34 195.2,94.67 195.28,94.74 196.49,94.74
+1VSB_HG_D on TOP (solid shape): 195.1,92.59 195.1,91.87 194.92,91.69 193.73,91.69 193.68,91.74 193.68,91.92 193.73,91.97 194.41,91.97 194.49,92.05 194.49,92.56 194.59,92.66 195.02,92.66
+1VSB_HGR_D on TOP (solid shape): 207.68,90.98 207.68,89.52 207.66,89.5 205.53,89.5 205.46,89.57 204.91,89.57 204.85,89.62 204.85,90.14 205.05,90.33 205.32,90.33 206.27,91.27 207.38,91.27
+1VSB_LG_D on TOP (solid shape): 194.26,90.42 194.27,90.36 194.3,90.29 194.3,88.77 193.85,88.77 193.6,89.03 193.6,90.37 193.7,90.47 194.21,90.47
+1VSB_LG_SW_D on TOP (solid shape): 206.43,86.48 206.43,84.89 206.12,84.58 206.12,83.19 205.87,82.93 204.98,82.93 204.83,83.08 204.83,84.33 205.29,84.79 205.29,86.26 204.84,86.71 204.84,87.18 204.89,87.23 205.68,87.23
+1VSB_SN on TOP (solid shape): 201.8,84.25 201.8,83.39 202.23,82.96 202.23,82.3 202.08,82.14 200.61,82.14 199.97,82.78 199.97,84.23 200.1,84.35 201.7,84.35
+1VSB_SW_C on TOP (solid shape): 196.47,91.67 196.47,91.06 196.29,90.88 195.02,90.88 194.69,91.21 193.68,91.21 193.65,91.24 193.65,91.47 195.05,91.47 195.4,91.82 196.32,91.82
+1VSB_SW_C on TOP (solid shape): 207.68,89.06 207.68,86.97 207.52,86.82 206.59,86.82 205.94,87.47 202.8,87.47 202.35,87.02 202.35,85.64 201.7,84.99 199.85,84.99 197.17,82.31 193.89,82.31 193.47,82.73 193.47,86.96 193.91,87.41 198.55,87.41 200.11,88.97 202.01,88.97 202.58,88.4 205.42,88.4 206.15,89.13 207.61,89.13
+1VSB_SW_C on VCC (solid shape): 207.65,86.74 206.55,86.74 205.83,87.47 205.79,87.49 205.74,87.5 202.95,87.5 202.9,87.49 202.86,87.47 202.35,86.96 202.32,86.92 202.31,86.87 202.31,85.65 201.62,84.96 199.9,84.96 199.85,84.95 199.81,84.93 197.23,82.35 194.31,82.35 193.42,83.24 193.42,86.94 193.98,87.5 198.5,87.5 198.55,87.51 198.59,87.54 200.08,89.03 202.13,89.03 202.6,88.56 202.64,88.53 202.69,88.52 205.36,88.52 205.41,88.53 205.45,88.56 206.05,89.15 207.65,89.15
+1VSB_TRIP on TOP (solid shape): 190.8,93.68 190.8,92.89 190.74,92.82 190.74,92.19 190.96,91.97 191.52,91.97 191.54,91.95 191.54,91.77 191.49,91.72 190.6,91.72 190.25,92.08 190.25,92.81 190.16,92.9 189.73,92.9 189.64,92.99 189.64,93.65 189.84,93.85 190.63,93.85
+1VSB_VIN on TOP (solid shape): outline of 121 points within 201.24,88.93 215.77,106.05
+5V on TOP (solid shape): 222.36,147.27 222.36,142.98 222.2,142.82 219.09,142.82 218.9,143.01 218.9,146.71 220.14,147.95 221.68,147.95
+5V on TOP (solid shape): 87.45,12.62 87.45,11.54 87.11,11.2 87.11,9.4 87.1,9.39 86.36,9.39 86.33,9.43 86.33,11.24 86.2,11.36 85.86,11.36 85.78,11.29 85.78,11 85.73,10.95 85.38,10.95 85.25,11.08 85.25,12.63 85.29,12.67 87.4,12.67
+5V on TOP (solid shape): outline of 139 points within 229.92,196.75 234.52,206.6
+5V on TOP (solid shape): outline of 717 points within 229.92,162.41 239.5,187.45
+5V on BOTTOM (solid shape): 233.43,207.82 233.43,202.29 232.69,201.93 233.43,201.57 233.43,200.58 232.84,200 232.26,200 231.93,200.32 231.93,202.75 232.58,203.39 232.58,207.79 232.69,207.9 233.35,207.9
+5V on VCC (solid shape): 237.74,206.45 237.74,205.74 237.75,205.69 237.78,205.65 238.87,204.57 237.08,201.45 239.37,204.22 240.23,204.22 240.92,203.53 240.92,154.84 240.89,154.81 238.05,154.81 234.4,158.46 234.36,158.49 234.31,158.5 224.28,158.5 224.23,158.49 224.19,158.46 223.81,158.08 223.78,158.04 223.77,157.99 223.77,157.66 223.05,156.93 223.02,156.89 223.01,156.84 223.01,143.05 222.71,142.75 219.01,142.75 218.82,142.94 218.82,146.3 218.81,146.35 218.78,146.39 218.4,146.77 218.36,146.8 218.31,146.81 215.83,146.81 213.61,149.02 213.61,150.44 213.92,150.75 215.65,150.75 215.69,150.76 215.74,150.79 216.5,151.55 216.53,151.59 216.53,151.64 216.53,157.68 219.16,160.31 219.19,160.35 219.2,160.4 219.2,166.06 220.31,167.17 220.34,167.21 220.34,167.26 220.34,187.27 221.7,188.63 221.73,188.67 221.74,188.72 221.74,202.31 225.68,202.31 225.73,202.32 225.77,202.35 226.91,203.49 226.94,203.53 226.95,203.58 226.95,204.93 228.27,206.25 229.49,206.25 229.54,206.26 229.58,206.29 230.05,206.76 237.44,206.76
+5V_1VSB_IN on TOP (solid shape): outline of 240 points within 215.92,102.18 227.2,142.35
+5V_CHARGER_1 on TOP (solid shape): 230.56,103.86 230.56,103.63 230.07,103.15 230.07,102.63 229.98,102.53 227.68,102.53 227.41,102.53 227.41,102.54 227.41,102.97 227.43,103 229.24,103 229.34,103.1 229.34,103.81 229.39,103.86 230.05,103.86 230.11,103.92 230.49,103.92
+5V_CHARGER_1 on TOP (solid shape): 230.45,100.99 230.45,98.07 229.41,97.03 229.41,92.56 229.18,92.33 229.18,88.42 229.49,88.11 231.95,88.11 232.74,88.9 235.61,88.9 235.74,88.77 235.74,87.93 235.53,87.73 234.52,87.73 233.22,86.44 227.51,86.44 227,86.94 227,94.83 227.03,94.97 227,95.11 227,97.69 229.29,99.97 229.29,101.14 229.37,101.23 230.21,101.23
+5V_CHARGER_1 on TOP (solid shape): 237.41,113.54 239.04,113.54 239.8,112.78 239.8,112.77 240.17,112.4 240.17,109.07 239.98,108.88 238.74,108.88 238.31,109.32 238.31,109.86 238.4,109.86 238.41,109.83 239.88,110 238.5,110.52 238.38,110.48 238.31,110.58 238.31,111.21 237.53,111.99 235.84,111.99 235.18,112.65 235.18,114.18 235.52,114.52 236.43,114.52
+5V_CHARGER_1 on BOTTOM (solid shape): 230.73,103.68 230.73,102.62 230.4,102.29 230.4,99.32 230.17,99.09 229.59,99.09 229.39,99.29 229.39,103.08 230.18,103.87 230.54,103.87
+5V_CHARGER_1 on VCC (solid shape): 237.43,113.63 237.47,113.6 237.52,113.59 239.01,113.59 239.78,112.83 239.78,109.64 239.61,109.47 238.43,109.47 238.12,109.78 238.12,110.74 238.12,110.79 238.09,110.83 237.2,111.72 237.16,111.75 237.11,111.76 235.34,111.76 235.18,111.93 235.18,114.22 235.51,114.55 236.5,114.55
+5V_CHARGER_1 on IN1 (solid shape): outline of 182 points within 232.56,87.6 236.42,115.29
+5V_CHARGER_2 on TOP (solid shape): 230.2,115.75 230.2,115.28 230.2,115.01 231.24,113.97 233.7,113.97 234.23,113.44 234.85,113.44 234.95,113.33 234.95,112.59 234.97,112.56 235.75,111.79 237.23,111.79 237.92,111.09 237.92,110.85 236.36,110.85 236.36,109.33 237.92,109.33 237.92,108.61 237.85,108.51 237.74,108.55 236.64,108.68 236.55,107.59 236.57,107.48 236.48,107.42 233.96,107.42 233.48,107.9 233.48,109.45 232.51,110.41 230.68,110.41 229.64,111.45 229.64,112.45 227.73,114.36 226.91,114.36 226.81,114.39 226.72,114.4 226.59,114.4 226.5,114.39 226.41,114.36 226.21,114.36 226.16,114.41 225.8,114.41 225.71,114.4 225.61,114.37 225.6,114.36 225.57,114.36 225.53,114.4 225.53,115.34 226.11,115.93 230.02,115.93
+5V_DISCHARGE on TOP (solid shape): 230,203.5 230,202.35 229.84,202.2 227.67,202.2 226.87,201.4 226.87,200.63 226.72,200.48 226.01,200.48 225.81,200.69 225.81,202.08 227.36,203.63 229.87,203.63
+5V_DUAL on TOP (solid shape): 20.68,227.43 20.68,226.26 20.5,226.09 17.45,226.09 17.12,226.42 17.12,227.41 17.32,227.61 20.5,227.61
+5V_DUAL on TOP (solid shape): 120.03,2.78 122.26,2.78 122.38,2.67 122.38,1.6 122.12,1.35 115.24,1.35 114.81,1.78 114.81,5.11 115.06,5.36 117.45,5.36
+5V_DUAL on TOP (solid shape): 18.75,157.84 18.75,155.57 18.54,155.37 18.47,155.37 18.42,155.32 16.08,155.32 15.52,155.88 15.52,156.69 15.53,156.71 15.53,157.04 16.41,157.91 18.67,157.91
+5V_DUAL on TOP (solid shape): 15.9,142.9 17.78,142.9 18.06,142.62 18.06,141.73 17.83,141.5 16.95,141.5 16.54,141.92 14.49,141.92 14.27,142.14 14.27,142.93 14.38,143.03 15.77,143.03
+5V_DUAL on TOP (solid shape): 18.77,139.93 18.77,138.61 18.52,138.35 15.9,138.35 15.8,138.46 15.8,138.89 15.98,139.06 16.51,139.06 16.64,139.19 16.64,139.95 16.76,140.08 18.62,140.08
+5V_DUAL on TOP (solid shape): 82.92,12.25 82.92,5.63 83.24,5.31 91.01,5.31 91.32,5 93.42,5 93.9,4.52 109.45,4.52 109.73,4.24 109.73,3.56 109.5,3.33 79.5,3.33 78.92,3.91 78.92,10.05 77.94,11.02 73.43,11.02 71.12,13.34 64.58,13.34 64.42,13.18 64.42,12.31 64.19,12.08 61.86,12.08 61.74,12.19 61.74,14.67 62.31,15.24 79.93,15.24
+5V_DUAL on TOP (solid shape): 227,234.91 227,216.97 226.47,216.43 226.47,215.37 229.77,212.06 234.41,212.06 234.98,211.49 234.98,211.39 235.43,210.94 237.4,210.94 238.38,209.96 238.38,207.62 238.73,207.26 240.16,207.26 240.66,206.76 240.66,204.98 240.41,204.72 238.27,204.72 238.1,204.73 237.94,204.72 237.39,204.72 236.88,205.23 236.88,206.6 236.42,207.06 229.95,207.06 229.37,206.49 228.03,206.49 226.58,205.04 226.58,203.9 223.72,201.04 222.25,201.04 221.56,201.73 221.56,205.31 222.25,205.99 222.25,212.27 219.56,214.96 218.49,214.96 217.98,215.47 217.98,218.49 217.32,219.15 217.32,220.07 218.31,221.06 221.03,221.06 223.58,223.61 223.58,227 223.6,227.1 223.58,227.21 223.58,230.64 220.91,233.32 220.91,236.92 221.82,237.84 224.07,237.84
+5V_DUAL on TOP (solid shape): 60.35,240.06 60.35,236.77 51.94,228.36 51.94,222.91 48.9,219.86 48.9,204.75 46.23,202.09 46.23,178.59 45.47,177.83 45.47,174.73 48.01,172.19 48.01,164.52 46.69,163.19 46.69,156.92 46.41,156.64 30.71,156.64 30.15,157.2 30.15,158.93 30.8,159.58 33.46,159.58 34.67,160.78 38.46,160.78 39.75,162.08 39.75,162.61 39.29,163.07 36.58,163.07 36.47,163.17 36.47,165.61 36.86,165.99 42.09,165.99 42.67,166.57 42.67,172.29 41.67,173.29 41.67,174.28 41.53,174.42 41.53,180.92 42.42,181.81 42.42,202.26 42.21,202.46 41.17,202.46 41.02,202.31 41.02,201.29 40.77,201.04 39.37,201.04 39.12,201.29 39.12,204.47 41.02,206.38 43.69,206.38 43.94,206.63 43.94,210.13 45.09,211.28 45.09,221.56 47.75,224.23 47.75,229.49 51.92,233.65 54.17,233.65 54.53,234.01 54.53,236.37 55.08,236.92 55.08,239.68 55.81,240.42 59.99,240.42
+5V_DUAL on TOP (solid shape): outline of 147 points within 209.04,126.57 213.49,144.09
+5V_DUAL on BOTTOM (solid shape): 59.92,242.24 59.92,239.88 59.69,239.65 55.6,239.65 55.17,240.08 55.17,242.11 55.55,242.49 59.66,242.49
+5V_DUAL on BOTTOM (solid shape): 22.07,227.63 22.07,226.29 21.79,226.01 17.27,226.01 16.94,226.34 16.94,227.76 17.22,228.04 21.67,228.04
+5V_DUAL on BOTTOM (solid shape): 224.72,239.53 224.72,235.79 223.97,235.03 220.76,235.03 220.13,235.66 220.13,236.61 218.14,238.6 217.19,238.6 216.48,239.31 216.48,242.06 216.92,242.49 221.76,242.49
+5V_DUAL on BOTTOM (solid shape): 84.25,4.83 105.97,4.83 107.61,6.47 117.05,6.47 117.47,6.05 117.47,3.99 117.05,3.57 110.82,3.57 108.94,1.68 80.13,1.68 78.92,2.9 78.92,6.19 79.26,6.53 82.55,6.53
+5V_DUAL on BOTTOM (solid shape): 57.14,235.57 57.14,233.59 51.92,228.37 51.92,222.94 48.9,219.91 48.89,219.84 48.89,204.77 47.12,203 46.58,203 46.39,203.19 46.39,204.56 47.37,205.54 47.37,223.17 48.44,224.23 48.44,230.78 53.49,235.84 56.87,235.84
+5V_DUAL on BOTTOM (solid shape): 17.04,157.3 17.04,155.22 16.23,154.41 16.23,153.49 13.57,150.83 13.56,150.74 13.58,150.65 13.58,145.66 13.62,145.61 13.71,145.48 13.84,145.4 16.97,142.27 17.78,142.27 18.03,142.01 18.03,139.57 17.73,139.27 15.09,139.27 15.05,139.28 15.04,139.32 14.88,139.67 14.51,139.77 14.49,139.77 14.35,139.91 14.36,139.94 14.37,140.39 13.98,140.63 13.91,140.62 13.85,140.64 13.81,140.7 13.8,140.74 13.57,141.03 13.21,141.08 13.18,141.07 12.99,141.26 12.99,141.8 11.39,143.4 11.39,144.58 11.86,144.98 11.39,145.39 11.39,151.4 13.82,153.83 14.29,154.3 14.29,155.82 15.95,157.48 16.87,157.48
+5V_DUAL on VCC (solid shape): outline of 1346 points within 34.29,1.4 242.44,242.44
+5V_DUAL on IN1 (solid shape): 59.92,242.24 59.92,239.88 59.69,239.65 55.6,239.65 55.17,240.08 55.17,242.11 55.55,242.49 59.66,242.49
+5V_DUAL on IN1 (solid shape): 224.72,239.53 224.72,235.79 223.97,235.03 220.76,235.03 220.13,235.66 220.13,236.61 218.14,238.6 217.19,238.6 216.48,239.31 216.48,242.06 216.92,242.49 221.76,242.49
+5V_DUAL on IN1 (solid shape): 57.12,235.61 57.12,233.58 51.92,228.37 51.92,222.94 48.9,219.91 48.89,219.84 48.89,204.77 47.12,203 46.58,203 46.39,203.19 46.39,204.56 47.37,205.54 47.37,223.17 48.44,224.23 48.44,230.78 53.49,235.84 56.9,235.84
+5V_LDO on TOP (solid shape): 10.71,18.45 12.34,18.45 12.37,18.42 12.37,18.21 12.34,18.19 10.39,18.19 9.4,17.2 8.68,17.2 8.67,17.2 7.95,17.2 7.78,17.37 7.78,18.07 7.98,18.27 8.77,18.27 9.19,18.69 9.19,19.05 9.32,19.18 9.98,19.18
+5V_LDO on TOP (solid shape): 13.88,11.89 13.88,10.16 13.76,10.04 13.76,9.23 13.97,9.02 13.97,8.67 13.89,8.59 13.51,8.59 12.93,8.01 12.12,8.01 11.96,8.17 11.96,10.19 12.19,10.41 12.73,10.41 13,10.13 13.44,10.13 13.62,10.31 13.62,11.92 13.65,11.95 13.83,11.95
+5VA on TOP (solid shape): 22.48,32.18 22.48,29.42 22.09,29.03 21.74,29.03 20.85,29.92 19.89,29.92 19.81,30 19.81,32.03 19.91,32.13 20.78,32.13 21.11,32.46 21.11,32.69 21.21,32.79 21.87,32.79
+5VA on TOP (solid shape): outline of 182 points within 224.16,181.33 234.82,192.28
+5VSB on TOP (solid shape): 78.94,238.84 78.94,238.2 78.66,237.91 76.29,237.91 75.97,238.23 75.97,239.12 76.25,239.4 78.39,239.4
+5VSB on TOP (solid shape): 106.12,238.76 106.12,237.36 105.49,236.73 104.52,236.73 103.81,237.44 103.81,237.69 105.11,238.99 105.89,238.99
+5VSB on TOP (solid shape): 122.4,236.3 122.4,235.81 122.05,235.46 120.5,235.46 120.4,235.56 120.4,236.4 120.47,236.47 122.22,236.47
+5VSB on TOP (solid shape): 133.3,232.04 133.3,231.55 133.15,231.39 131.83,231.39 131.65,231.57 131.65,232.23 131.71,232.3 133.05,232.3
+5VSB on TOP (solid shape): 194.36,232.94 194.36,232.26 194.34,232.23 192.79,232.23 192.53,232.49 192.53,232.79 192.86,233.12 194.18,233.12
+5VSB on TOP (solid shape): 154.25,231.68 154.25,229.64 153.85,229.24 153.51,229.24 153.03,229.71 153.03,231.65 153.26,231.88 154.06,231.88
+5VSB on TOP (solid shape): 228.05,197.14 228.05,194.52 227.46,193.93 226.82,193.93 226.39,194.36 226.39,194.39 226.31,194.46 226.31,196.77 226.11,196.98 225.68,196.98 225.55,197.1 225.55,197.95 225.75,198.14 227.05,198.14
+5VSB on BOTTOM (solid shape): 133.6,232.49 133.6,231.65 131.95,231.65 131.82,231.78 131.82,232.3 132.17,232.64 133.45,232.64
+5VSB on BOTTOM (solid shape): 78.64,239.22 78.64,238.4 78.38,238.15 76.07,238.15 75.92,238.3 75.92,239.42 76.02,239.52 78.33,239.52
+5VSB on BOTTOM (solid shape): 122.3,236.4 122.3,235.76 122,235.46 120.5,235.46 120.4,235.56 120.4,236.4 120.47,236.47 122.22,236.47
+5VSB on BOTTOM (solid shape): 154.07,231.89 154.07,230.67 153.88,230.48 153.49,230.48 152.73,231.24 152.73,231.98 152.98,232.23 153.73,232.23
+5VSB on BOTTOM (solid shape): 194.64,232.84 194.64,232.18 194.41,231.95 192.84,231.95 192.58,232.21 192.58,232.59 192.92,232.92 194.56,232.92
+5VSB on BOTTOM (solid shape): 106.15,238.71 106.15,237.21 106.02,237.08 105.36,237.08 104.65,237.79 104.65,238.56 105.08,238.99 105.87,238.99
+5VSB on BOTTOM (solid shape): 226.39,198.57 226.39,195.84 226.22,195.67 225.58,195.67 225.4,195.84 225.29,195.84 225.25,195.89 225.23,195.96 225.25,196.03 225.15,196.64 224.56,196.44 224.49,196.37 224.4,196.4 224.26,196.53 224.26,198.54 224.55,198.83 226.13,198.83
+5VSB_AUDIO on TOP (solid shape): 19.16,30.9 19.16,30 18.06,30 15.81,27.75 14.52,27.75 14.3,27.53 13.67,27.53 13.5,27.7 13.5,27.98 14.39,28.87 15.25,28.87 17.42,31.04 19.02,31.04
+5VSB_AUDIO on TOP (solid shape): 12.38,16.4 12.38,16.22 12.35,16.19 10.67,16.19 10.49,16.01 10.49,15.66 9.94,15.11 9.94,15.11 9.7,14.87 9.11,14.87 8.65,14.41 7.21,14.41 7.06,14.55 7.06,15.19 7.41,15.54 8.76,15.54 9.22,16 9.55,16 10,16.45 12.33,16.45
+5VSB_AUDIO on BOTTOM (solid shape): 14.68,28.55 14.68,27.89 14.5,27.71 11.53,27.71 11.42,27.82 11.42,28.76 11.57,28.9 14.33,28.9
+12V on TOP (solid shape): outline of 417 points within 230.07,187.96 240.28,200.79
+12V on BOTTOM (solid shape): 242.44,211.46 242.44,200.46 241.87,199.89 238.51,199.89 238.25,200.14 238.25,200.93 240.04,202.39 239.27,204.57 239.24,204.68 239.34,204.75 240.15,205.22 240.09,206.16 239.37,207.34 238.65,206.16 238.51,205.85 238.49,205.51 238.49,205.24 238.28,205.03 237.79,205.03 237.52,205.31 237.52,209.32 238.35,210.16 238.37,210.16 238.9,210.4 239.14,210.93 239.14,210.95 240.54,212.34 241.55,212.34
+12V_CPU on TOP (solid shape): outline of 83 points within 228.63,218.31 239.93,222.25
+12V_CPU on TOP (solid shape): outline of 1057 points within 49.3,129.16 159.03,242.39
+12V_CPU on BOTTOM (solid shape): 135.28,229.55 136.53,228.3 137.19,228.3 137.43,228.05 137.43,227.79 137.09,227.46 136.47,227.46 135.31,228.63 125.63,228.63 125.6,228.6 123.9,228.6 123.88,228.63 122.3,228.63 121.31,227.63 121.31,221.62 121.13,221.44 118.64,221.44 118.43,221.65 118.43,228.91 119.07,229.55 135.24,229.55
+12V_CPU on BOTTOM (solid shape): outline of 1479 points within 46.25,131.05 66.67,232.74
+12V_CPU on VCC (solid shape): outline of 184 points within 46.23,129.29 142.75,235.97
+12V_GFX on TOP (solid shape): outline of 1665 points within 42.55,16.89 70.23,101.41
+12V_GFX on BOTTOM (solid shape): outline of 238 points within 59.87,92.99 70.43,103.4
+12V_GFX on VCC (solid shape): outline of 84 points within 42.55,16.76 70.23,101.22
+AVDDL on TOP (solid shape): 37.78,213.63 37.78,213.02 38.18,212.62 38.38,212.62 38.38,210.61 38.98,210.01 39.35,210.01 39.38,210 39.64,209.97 39.88,210.09 40.6,210.09 40.86,209.83 40.86,209.37 40.68,209.19 38.26,209.19 37.8,209.66 37.73,209.75 37.63,209.83 37.49,209.97 37.49,211.84 37.29,212.04 37.29,213.44 37.06,213.66 37.06,213.82 37.13,213.89 37.52,213.89
+AVDDVCO on TOP (solid shape): 40.49,214.4 40.49,211.82 40.97,211.34 40.97,210.8 39.91,210.8 39.5,211.21 39.5,212.91 39.58,212.97 39.64,213.04 39.72,213.38 39.5,213.65 39.5,213.85 39.52,213.87 39.59,214.05 39.58,214.24 39.57,214.27 39.73,214.43 40.46,214.43
+DVDDL on TOP (solid shape): 41.2,217.22 41.2,216.71 41.05,216.56 39.29,216.56 39.09,216.36 38.79,216.36 38.73,216.41 38.73,216.61 38.76,216.7 38.76,216.79 39.32,217.35 41.07,217.35
+V1P0A_VCCAMPHYPLL_W25MIL on TOP (solid shape): 193.04,67.94 193.04,67.18 192.79,66.93 191.9,66.93 191.64,66.67 191.64,66.42 191.52,66.29 190.5,66.29 190.5,66.33 189.71,66.33 189.62,66.42 189.62,67.18 189.83,67.39 190.4,67.39 190.5,67.49 190.5,67.94 190.75,68.2 192.79,68.2
+V1P0A_VCCAMPHYPLL_W25MIL on TOP (solid shape): 186.06,63.32 186.06,62.87 185.6,62.42 183.89,62.42 183.76,62.29 182.69,62.29 182.64,62.35 181.14,62.35 180.91,62.12 180.91,61.7 180.89,61.67 180.86,61.38 181.08,61.2 181.18,61.2 181.28,61.23 181.74,61.23 181.81,61.15 181.81,61 181.73,60.92 181.67,60.93 181.52,60.92 181.39,60.83 181.05,60.83 180.9,61.1 180.6,61.19 180.48,61.31 180.48,61.68 180.62,61.83 180.63,61.84 180.63,63.03 180.78,63.18 184.54,63.18 184.84,63.47 185.9,63.47
+VCC_USB2 on TOP (solid shape): outline of 474 points within 10.79,187.48 40.13,199.31
+VCC_USB2 on VCC (solid shape): 40.13,199.08 40.13,194.62 33.35,187.83 18.54,187.83 18.49,187.82 18.45,187.8 18.11,187.45 11.23,187.45 10.79,187.89 10.79,190.07 11.52,190.79 11.55,190.83 11.56,190.88 11.56,192.86 12.88,194.18 23.19,194.18 23.79,193.59 23.83,193.56 23.88,193.55 31.88,193.55 31.93,193.56 31.97,193.59 33.49,195.11 33.52,195.15 33.53,195.2 33.53,198.07 34.72,199.26 39.95,199.26
+VCC_USB2_1 on TOP (solid shape): outline of 295 points within 11.42,207.9 21.37,224.87
+VCC_USB3_1 on TOP (solid shape): 12.45,142.98 12.45,142.42 12.4,142.37 11.33,142.37 11.25,142.29 11.24,142.29 10.94,141.99 10.01,141.99 9.83,142.16 9.83,142.46 9.85,142.55 9.86,142.64 9.86,142.95 10.15,143.23 12.19,143.23
+VCC_USB3_1 on TOP (solid shape): 11.95,139.61 11.95,138.44 12.63,137.77 12.63,137.75 12.72,137.54 12.9,137.4 12.93,137.39 12.93,136.68 12.92,136.67 12.63,135.85 12.8,134.99 12.81,134.96 12.12,134.26 11.66,134.26 11.2,133.81 11.2,132.36 10.95,132.11 10.21,132.11 10.04,132.28 10.04,134.77 10.32,135.94 9.75,136.99 9.68,137.07 9.68,138.84 9.53,138.99 8.07,138.99 8.03,139.03 8.03,139.85 8.56,140.39 11.18,140.39
+VCC_USB3_1 on BOTTOM (solid shape): outline of 300 points within 9.22,130.94 14.63,143.26
+VCC_USB3_2 on TOP (solid shape): 22.53,138.81 25.91,138.81 26.04,138.68 26.04,137.92 25.63,137.52 25.35,137.52 24.82,136.98 20.02,136.98 19.41,137.59 19.41,139.04 19.68,139.32 22.02,139.32
+VCC_USB3_2 on BOTTOM (solid shape): outline of 340 points within 15.87,131.72 22.75,138.76
+VCC_USB3_3 on TOP (solid shape): outline of 248 points within 223.8,116.15 240.39,133.88
+VCCGT on TOP (solid shape): outline of 2401 points within 96.01,166.42 130.89,215.14
+VCCGT on BOTTOM (solid shape): outline of 3004 points within 95.89,166.38 130.78,215.19
+VCCGT on VCC (solid shape): outline of 252 points within 93.85,166.37 130.94,215.14
+VCCPRIM_1P0_5&9 on BOTTOM (solid shape): 168.46,50.9 168.46,50.02 168.33,49.89 167.43,49.89 166.79,50.52 166.79,50.88 166.9,50.98 166.9,50.98 167.02,51.1 168.25,51.1
+VDDQ_SN on TOP (solid shape): 210.21,200.58 210.21,198.98 210.11,198.88 209.3,198.88 209.07,198.65 209.07,197.84 208.86,197.64 208.31,197.64 207.98,197.97 207.98,200.81 208.1,200.94 209.85,200.94
AGND on TOP (solid shape): 40.01,8.56 40.01,8.23 39.83,8.05 39.83,7.24 39.7,7.11 39.47,7.11 39.24,7.34 39.24,8.64 39.27,8.66 39.9,8.66
AGND on TOP (solid shape): outline of 1004 points within 0.51,0.51 33.8,116.71
AGND on BOTTOM (solid shape): 33.1,11.05 33.71,11.05 34.04,11.05 34.42,10.67 35.05,10.67 35.24,10.48 35.26,10.48 35.34,10.44 35.36,10.36 35.36,10.31 35.36,10.23 34.83,9.7 33.8,9.7 33.72,9.74 33.71,9.84 33.64,10.26 33.24,10.44 33.21,10.44 33.19,10.47 32.93,10.47 32.33,10.62 32.07,10.06 32.05,9.97 31.97,9.93 28.97,9.93 28.46,9.42 27.04,9.42 26.96,9.47 26.95,9.57 26.98,9.91 26.76,10.18 26.71,10.26 26.74,10.34 26.79,10.39 27.07,10.39 27.69,10.29 27.83,10.9 27.83,11 27.92,11.05
AGND on BOTTOM (solid shape): 1.14,91.83 1.14,55.24 1.14,22.92 1.14,22.92 1.14,21.57 2.17,20.54 2.17,19.57 3.94,17.8 3.94,14.27 3.94,14.26 3.94,13.86 3.94,13.85 3.94,11.32 3.94,11.32 3.94,10.1 5.44,8.61 5.44,3.58 5.71,3.3 12.5,3.3 13.45,4.25 15.89,4.25 16.04,4.1 16.22,4 16.22,3.99 16.29,3.92 19.88,3.92 21.27,2.54 22.4,2.54 26.92,2.54 26.94,2.5 26.97,2.45 27.99,2.03 28.81,2.78 28.77,3.44 28.33,3.94 28.31,3.95 28.31,4.03 28.53,4.03 29.8,2.77 31.9,2.77 32.11,2.38 32.45,2.12 33.15,2.05 33.73,2.45 33.84,2.48 33.91,2.38 33.91,1.14 33.91,0.51 4.06,0.51 1.55,1.55 0.51,4.06 0.51,116.71 1.14,116.71
AGND on BOTTOM (solid shape): outline of 656 points within 21.95,2.03 39.88,10.48
AGND on BOTTOM (solid shape): outline of 1215 points within 1.65,95.59 18.59,116.71
AGND on VCC (solid shape): outline of 380 points within 0.51,0.51 39.88,116.71
AGND on IN1 (solid shape): outline of 10950 points within 0.51,0.51 39.88,116.71
GND on TOP (solid shape): 174.88,100.91 174.88,100.33 174.62,100.08 172.73,100.08 172.19,100.62 172.19,101.04 174.75,101.04
GND on TOP (solid shape): 208.71,86.06 208.71,85.24 208.51,85.04 207.06,85.04 206.76,85.34 206.76,86.41 208.36,86.41
GND on TOP (solid shape): 225.07,21.2 225.07,20.16 225.02,20.12 223.65,20.12 223.65,21.02 223.89,21.26 225.01,21.26
GND on TOP (solid shape): 229.49,205.99 229.49,204.85 228.94,204.31 228.61,204.31 228.09,204.83 228.09,206.25 229.24,206.25
GND on TOP (solid shape): 15.57,139.7 15.57,138.43 15.42,138.28 14.17,138.28 14.02,138.43 14.02,139.37 14.43,139.78 15.49,139.78
GND on TOP (solid shape): 18.82,229.06 18.82,228.09 18.75,228.02 17.27,228.02 17.09,228.19 17.09,229.03 17.35,229.29 18.59,229.29
GND on TOP (solid shape): 21.72,28.14 21.72,27.13 21.46,26.87 21.03,26.87 20.78,27.12 20.78,28.19 20.83,28.24 21.62,28.24
GND on TOP (solid shape): 26.49,194.69 26.49,194.01 26.24,193.75 24.26,193.75 24.1,193.9 24.1,194.74 24.28,194.92 26.26,194.92
GND on TOP (solid shape): 51.31,114.94 50.39,114.02 50.11,114.02 49.99,114.15 49.99,114.48 50.34,114.83 50.34,115.34 51.31,115.34
GND on TOP (solid shape): 56.41,201.65 56.41,201.14 56.18,200.91 54.76,200.91 54.53,201.14 54.53,201.63 54.71,201.8 56.26,201.8
GND on TOP (solid shape): 66.29,184.28 66.29,183.39 66.17,183.26 65.53,183.26 65.41,183.39 65.41,184.4 65.53,184.53 66.04,184.53
GND on TOP (solid shape): 66.55,149.1 66.55,148.08 66.42,147.96 65.53,147.96 65.41,148.08 65.41,148.97 65.66,149.22 66.42,149.22
GND on TOP (solid shape): 66.93,166.24 66.93,165.86 66.8,165.74 65.53,165.74 65.41,165.86 65.41,166.37 65.53,166.5 66.67,166.5
GND on TOP (solid shape): 67.06,128.24 67.06,127.05 66.88,126.87 64.95,126.87 64.24,127.59 64.24,128.12 64.52,128.4 66.9,128.4
GND on TOP (solid shape): 68.66,189.31 68.66,188.59 68.2,188.14 67.59,188.14 67.41,188.32 67.41,189.31 67.54,189.43 68.53,189.43
GND on TOP (solid shape): 72.22,186.74 72.22,186.28 72.06,186.12 69.37,186.12 69.25,186.24 69.25,186.78 69.45,186.98 71.98,186.98
GND on TOP (solid shape): 95.89,228.64 95.89,226.27 95.78,226.15 95.16,226.15 95.05,226.27 95.05,228.64 95.24,228.83 95.7,228.83
GND on TOP (solid shape): 97.31,159.36 97.31,158.83 97.26,158.78 94.89,158.78 94.79,158.88 94.79,159.28 94.92,159.41 97.26,159.41
GND on TOP (solid shape): 98.02,178.79 98.02,178.26 97.97,178.21 95.61,178.21 95.5,178.31 95.5,178.71 95.63,178.84 97.97,178.84
GND on TOP (solid shape): 98.02,175.31 98.02,174.78 97.97,174.73 95.61,174.73 95.5,174.83 95.5,175.23 95.63,175.36 97.97,175.36
GND on TOP (solid shape): 98.02,170.87 98.02,170.33 97.97,170.28 95.61,170.28 95.5,170.38 95.5,170.79 95.63,170.92 97.97,170.92
GND on TOP (solid shape): 98.02,164.69 98.02,164.16 97.97,164.11 95.61,164.11 95.5,164.21 95.5,164.62 95.63,164.74 97.97,164.74
GND on TOP (solid shape): 99.09,214.73 99.09,213.56 98.78,213.26 97.69,213.26 97.54,213.41 97.54,214.78 97.74,214.99 98.83,214.99
GND on TOP (solid shape): 122,234.52 122,233.3 121.69,232.99 119.28,232.99 118.97,233.3 118.97,234.59 119.25,234.87 121.64,234.87
GND on TOP (solid shape): 127.64,162.05 127.64,159.77 127.38,159.51 123.7,159.51 123.57,159.64 123.57,161.8 123.9,162.13 127.56,162.13
GND on TOP (solid shape): 127.69,171.4 127.69,168.07 127.41,167.79 125.45,167.79 125.27,167.97 125.27,171.27 125.55,171.55 127.53,171.55
GND on TOP (solid shape): 127.89,109.73 127.89,107.95 127.68,107.74 126.38,107.74 126.36,107.73 126.36,110.11 126.49,110.24 127.38,110.24
GND on TOP (solid shape): 131.19,209.85 131.19,208.36 130.99,208.15 129.97,208.15 129.46,208.66 129.46,209.93 129.59,210.06 130.99,210.06
GND on TOP (solid shape): 131.7,162.05 131.7,159.77 131.44,159.51 129.54,159.51 129.29,159.77 129.29,161.93 129.49,162.13 131.62,162.13
GND on TOP (solid shape): 141.57,234.23 141.57,232.8 141.3,232.54 139.09,232.54 138.94,232.69 138.94,234.37 139.29,234.72 141.08,234.72
GND on TOP (solid shape): 152.48,57.4 152.48,56.95 152.3,56.77 148.21,56.77 147.98,57 147.98,57.4 148.03,57.45 152.43,57.45
GND on TOP (solid shape): 192.82,100.9 192.82,99.85 192.66,99.69 189.1,99.69 188.86,99.94 188.86,100.81 189.14,101.09 192.63,101.09
GND on TOP (solid shape): 199.52,60.83 199.52,59.82 199.22,59.52 198.4,59.52 198.2,59.73 198.2,60.71 198.45,60.96 199.39,60.96
GND on TOP (solid shape): 205,65.51 205,62.87 204.63,62.5 203.23,62.5 202.62,63.11 202.62,65.53 203.05,65.96 204.54,65.96
GND on TOP (solid shape): 206.57,13.66 206.57,12.74 206.47,12.65 205.17,12.65 204.82,12.99 204.82,13.66 204.93,13.76 206.47,13.76
GND on TOP (solid shape): 206.91,18.3 206.91,18.01 206.71,17.81 204.17,17.81 204.01,17.97 204.01,18.33 204.18,18.5 206.71,18.5
GND on TOP (solid shape): 209.58,107.34 209.58,106.3 209.19,105.92 206.76,105.92 206.63,106.05 206.63,107.31 206.76,107.44 209.47,107.44
GND on TOP (solid shape): 210.95,157.86 210.95,156.46 210.82,156.34 210.34,156.34 210.16,156.51 210.16,157.94 210.29,158.06 210.74,158.06
GND on TOP (solid shape): 211.15,206.93 211.15,201.83 211.02,201.7 209.25,201.7 209.07,201.88 209.07,206.98 209.22,207.14 210.95,207.14
GND on TOP (solid shape): 212.12,150.9 212.12,149.25 211.56,148.69 207.24,148.69 206.88,149.05 206.88,151 207.19,151.31 211.71,151.31
GND on TOP (solid shape): 220,189.24 220,187.96 219.79,187.76 219.07,187.76 219,187.83 219,189.31 219.13,189.43 219.8,189.43
GND on TOP (solid shape): 229.49,151.38 229.49,150.24 229.29,150.04 228.4,150.04 228.27,150.16 228.27,151.18 228.6,151.51 229.36,151.51
GND on TOP (solid shape): 230.43,186.11 230.43,185.42 230.23,185.22 229.31,185.22 229.06,185.47 229.06,186.08 229.16,186.18 230.35,186.18
GND on TOP (solid shape): 232.13,86.13 232.13,85.17 231.5,84.53 229.29,84.53 228.85,84.96 228.85,85.95 229.13,86.23 232.03,86.23
GND on TOP (solid shape): 237.01,89.64 237.01,88.16 236.85,88.01 236.42,88.01 236.17,88.27 236.17,89.79 236.37,89.99 236.65,89.99
GND on TOP (solid shape): 64.33,220.38 64.33,217.36 63.55,216.59 63.12,216.59 62.96,216.75 62.96,220.38 63.16,220.58 64.13,220.58
GND on TOP (solid shape): 115.93,237.31 115.93,236.35 114.15,234.57 111.76,234.57 111.07,235.25 111.07,237.19 111.56,237.67 115.57,237.67
GND on TOP (solid shape): 207.28,102.15 207.28,101.44 206.84,101 206.54,101 206.45,101.1 206.45,101.54 206.76,101.85 206.76,102.2 207.23,102.2
GND on TOP (solid shape): 230.45,165.97 230.45,163.39 230.35,163.28 229.76,163.28 229.54,163.5 229.54,165.89 229.7,166.05 230.38,166.05
GND on TOP (solid shape): 239.14,115.52 239.14,114.3 238.81,113.97 237.54,113.97 237.45,114.06 237.45,115.17 237.93,115.65 239.01,115.65
GND on TOP (solid shape): 11.3,154.99 11.3,153.8 10.97,153.47 9.73,153.47 9.55,153.64 9.55,154.99 9.8,155.24 11.06,155.24
GND on TOP (solid shape): 18.12,143.71 18.12,143.4 17.88,143.15 16.08,143.15 16,143.23 16,143.71 16.15,143.87 17.97,143.87
GND on TOP (solid shape): 43.56,208.66 43.56,206.76 43.5,206.7 42.02,206.7 41.81,206.91 41.81,208.46 42.27,208.91 43.31,208.91
GND on TOP (solid shape): 45.87,233.25 45.87,231.29 45.59,231.01 41.66,231.01 41.07,231.6 41.07,233.1 41.4,233.43 45.69,233.43
GND on TOP (solid shape): 49.94,117.47 49.94,117.09 49.78,116.94 48.44,116.94 48.29,116.79 48.01,116.79 47.9,116.89 47.9,117.14 48.41,117.65 49.76,117.65
GND on TOP (solid shape): 68.53,205.34 68.53,204.93 68.27,204.67 66.31,204.67 66.18,204.79 65.78,204.79 65.55,205.02 65.55,205.13 65.86,205.44 68.43,205.44
GND on TOP (solid shape): 80.62,137.41 80.62,136.78 79.58,135.74 78.54,135.74 78.05,136.22 78.05,137.54 78.23,137.72 80.31,137.72
GND on TOP (solid shape): 102.35,38.98 102.35,38.27 102.23,38.15 101.5,38.15 101.3,37.95 100.86,37.95 100.61,38.2 100.61,38.94 100.94,39.27 102.06,39.27
GND on TOP (solid shape): 189.7,94.51 189.7,94.29 189.26,93.85 189.26,93.05 189.25,93.04 188.78,93.04 188.76,93.06 188.76,94.12 189.31,94.68 189.54,94.68
GND on TOP (solid shape): 190.91,41.25 190.91,40.72 190.8,40.61 187.22,40.61 187.1,40.74 187.1,41.25 187.22,41.38 190.78,41.38
GND on TOP (solid shape): 191.62,167.59 191.62,166.98 191.52,166.88 191.21,166.88 191.21,166.89 190.92,166.89 190.2,167.61 190.2,167.89 190.3,168 191.21,168
GND on TOP (solid shape): 196.86,67.26 196.86,64.04 196.62,63.8 194.32,63.8 194.01,64.1 194.01,67.09 194.51,67.59 196.54,67.59
GND on TOP (solid shape): 214.6,156.59 214.6,154.86 213.84,154.1 213.23,154.1 213.08,154.25 213.08,156.74 213.21,156.87 214.33,156.87
GND on TOP (solid shape): 226.09,196.62 226.09,194.76 225.77,194.45 225,194.45 224.89,194.56 224.89,196.41 225.21,196.74 225.97,196.74
GND on TOP (solid shape): 41.07,8.31 41.07,7.26 40.94,7.14 40.59,7.14 40.44,7.29 40.44,8.1 40.26,8.28 40.26,8.53 40.34,8.61 40.77,8.61
GND on TOP (solid shape): 43.73,130.09 43.73,129.33 43.19,128.79 43.18,128.79 43.12,128.73 42.52,128.73 42.39,128.85 42.39,130.06 42.71,130.37 43.45,130.37
GND on TOP (solid shape): 73.56,174.14 73.56,173.12 73.95,172.73 73.95,171.99 73.72,171.75 72.62,171.75 72.34,172.03 72.34,174.09 72.52,174.27 73.43,174.27
GND on TOP (solid shape): 73.66,156.59 73.66,155.55 73.86,155.35 73.86,154.81 73.7,154.65 72.17,154.65 72.01,154.81 72.01,156.46 72.26,156.72 73.53,156.72
GND on TOP (solid shape): 74.32,191.62 74.32,190.42 74.28,190.39 74.28,189.85 74.17,189.74 73.28,189.74 72.9,190.12 72.9,191.54 73.13,191.77 74.17,191.77
GND on TOP (solid shape): 80.59,140 80.59,138.89 80.44,138.73 78.46,138.73 77.98,139.22 77.98,139.88 78.08,139.98 79.15,139.98 79.4,140.23 80.37,140.23
GND on TOP (solid shape): 177.93,10.85 178.49,10.85 178.56,10.77 178.56,9.55 178.44,9.42 178.28,9.42 177.24,10.46 177.24,10.9 177.29,10.95 177.83,10.95
GND on TOP (solid shape): 235.57,217.89 236.26,217.89 237.19,216.97 237.19,216.28 236.96,216.05 234.82,216.05 234.31,216.56 234.31,217.81 234.42,217.91 235.56,217.91
GND on TOP (solid shape): 23.22,232.66 23.22,231.9 23.8,231.32 23.8,230.78 23.65,230.63 21.89,230.63 21.56,230.96 21.56,232.23 22.1,232.77 23.11,232.77
GND on TOP (solid shape): 190.58,166.68 190.88,166.68 191.04,166.52 191.04,166.18 190.96,166.09 190.35,166.09 189.85,166.58 189.85,166.82 189.97,166.93 190.32,166.93
GND on TOP (solid shape): 207.4,157.95 207.4,157.65 207.57,157.48 207.57,156.49 207.24,156.16 207.24,154.25 207.11,154.13 206.48,154.13 206.32,154.28 206.32,157.84 206.65,158.17 207.19,158.17
GND on TOP (solid shape): 209.72,112.89 209.72,109.63 209.49,109.4 206.76,109.4 206.65,109.5 206.65,109.83 206.67,109.84 206.67,110.48 208.36,112.16 208.36,112.89 208.53,113.06 209.55,113.06
GND on TOP (solid shape): 233.12,109.4 233.12,107.44 232.97,107.29 231.95,107.29 231.9,107.34 231.9,109.21 232.16,109.46 233.06,109.46
GND on TOP (solid shape): 234.85,222.94 234.85,221.92 233.83,220.9 230.4,220.9 230.12,221.18 230.12,223.19 230.35,223.42 234.37,223.42
GND on TOP (solid shape): 25.98,140 25.98,139.45 25.58,139.04 22.73,139.04 22.15,139.62 20.02,139.62 19.86,139.78 19.86,140.26 22.3,140.26 22.66,140.61 22.66,140.84 22.94,141.12 24.87,141.12
GND on TOP (solid shape): 41.61,214.15 41.94,214.15 42.14,213.94 42.14,212.19 41.7,211.75 40.94,211.75 40.74,211.95 40.74,214.39 40.82,214.46 41.29,214.46
GND on TOP (solid shape): 88.66,13.95 88.66,12.22 88.38,11.94 87.86,11.94 87.81,11.99 87.81,12.73 87.66,12.87 85.58,12.87 85.25,13.2 85.25,14.35 85.32,14.42 88.19,14.42
GND on TOP (solid shape): 100.71,202.82 100.71,198.96 100.48,198.73 100.1,198.73 99.9,198.93 99.9,202.82 100.03,202.95 100.58,202.95
GND on TOP (solid shape): 108.46,202.82 108.46,198.96 108.23,198.73 107.85,198.73 107.65,198.93 107.65,202.82 107.77,202.95 108.33,202.95
GND on TOP (solid shape): 115.95,202.82 115.95,198.96 115.72,198.73 115.34,198.73 115.14,198.93 115.14,202.82 115.27,202.95 115.82,202.95
GND on TOP (solid shape): 123.19,202.82 123.19,198.96 122.96,198.73 122.58,198.73 122.38,198.93 122.38,202.82 122.5,202.95 123.06,202.95
GND on TOP (solid shape): 35.28,136.63 35.28,136.41 34.85,135.98 34.85,134.29 35.13,134.01 35.13,133.73 35,133.6 34.77,133.6 34.64,133.74 34.64,136.56 34.89,136.81 35.1,136.81
GND on TOP (solid shape): 42.24,224.21 42.24,222 41.58,221.34 41.58,221.31 41.5,221.23 41.5,219.3 41.27,219.07 40.39,219.07 40.13,219.33 40.13,222.5 40.64,223.01 40.64,225.04 40.74,225.15 41.3,225.15
GND on TOP (solid shape): 71.75,97.54 71.75,92.96 71.5,92.71 70.61,92.71 70.48,92.84 70.48,97.66 70.69,97.87 71.42,97.87
GND on TOP (solid shape): 123.45,100.43 123.45,99.86 122.8,99.2 122.8,97.83 122.89,97.74 122.89,96.95 122.78,96.85 119.56,96.85 118.49,97.92 118.49,100.01 119.13,100.65 123.24,100.65
GND on TOP (solid shape): 210.2,13.51 210.2,12.32 210.05,12.17 208.81,12.17 208.63,11.99 208.63,9.96 208.55,9.88 207.51,9.88 207.41,9.98 207.41,13.51 207.87,13.97 209.75,13.97
GND on TOP (solid shape): 217.56,218 217.56,217.11 217.3,216.84 215.87,216.84 215.49,217.22 215.48,217.22 215.01,217.22 214.91,217.32 214.91,217.88 214.96,217.93 216.87,217.93 217.12,218.19 217.37,218.19
GND on TOP (solid shape): 230.86,104.85 230.86,104.34 230.76,104.24 229.31,104.24 229.08,104.01 229.08,103.43 229.03,103.38 228.42,103.38 228.37,103.43 228.37,104.14 229.13,104.9 230.81,104.9
GND on TOP (solid shape): 130.5,156.67 130.5,153.26 130.89,152.87 130.89,152.4 130.75,152.26 129.6,152.26 129.24,151.89 129.24,151.51 129.07,151.35 128.38,151.35 128.09,151.64 128.09,156.77 128.22,156.9 130.28,156.9
GND on TOP (solid shape): 203.35,17.97 203.35,14.02 203.58,13.79 203.58,13.55 203.26,13.23 202.72,13.23 202.25,13.7 202.25,16.95 202.39,17.09 202.39,18.08 202.53,18.23 203.1,18.23
GND on TOP (solid shape): 209.52,167.26 211.35,167.26 212,166.61 212,164.86 211.94,164.8 206.76,164.8 206.6,164.95 206.6,165.66 206.88,165.94 206.88,168.1 207.01,168.22 208.56,168.22
GND on TOP (solid shape): 229.67,14.15 229.67,10.01 229.46,9.8 228.12,9.8 228.07,9.86 228.07,11.94 227.97,12.04 227.03,12.04 226.87,12.19 226.87,14.05 227.28,14.45 229.36,14.45
GND on TOP (solid shape): 236.44,206.44 236.44,206.06 236.45,206.04 236.45,205.08 236.22,204.85 234.72,204.85 234.66,204.91 234.66,206.59 234.8,206.73 236.14,206.73
GND on TOP (solid shape): 22.17,107.31 22.17,105.54 22.12,105.49 22.12,105.18 22.53,104.78 25.22,104.78 25.43,104.57 25.43,103.5 25.35,103.43 21.87,103.43 21.03,104.27 21.03,107.24 21.26,107.47 22.02,107.47
GND on TOP (solid shape): 53.75,76.82 53.75,76.31 53.8,76.26 54.44,76.26 54.56,76.15 54.56,75.69 54.41,75.54 53.34,75.54 53.24,75.63 53.24,76.08 53.24,76.09 53.24,76.82 53.29,76.87 53.7,76.87
GND on TOP (solid shape): 71.98,169.43 71.98,168.95 71.82,168.79 69.93,168.79 69.92,168.79 69.66,168.79 69.57,168.7 69.17,168.7 69.09,168.78 69.09,169.15 69.17,169.23 69.17,169.46 69.29,169.57 71.84,169.57
GND on TOP (solid shape): 124.28,156.41 124.28,151.51 124.17,151.4 123.72,151.4 123.53,151.59 123.53,152.62 123.34,152.81 120.95,152.81 120.8,152.96 120.8,154.66 120.6,154.86 119.46,154.86 119.25,155.07 119.25,156.59 119.51,156.84 123.85,156.84
GND on TOP (solid shape): 139.93,237.95 144.86,237.95 145.24,237.57 145.24,236.5 144.87,236.13 144.64,236.13 144.6,236.09 142.47,236.09 142.33,235.95 139.75,235.95 138.58,237.12 138.58,238.12 138.84,238.38 139.5,238.38
GND on TOP (solid shape): 181.41,39.88 182.29,39.88 182.66,39.51 182.66,39.08 181.44,39.08 181.2,39.32 181.2,39.48 180.95,39.73 180.57,39.73 180.52,39.78 180.52,39.95 180.57,40.01 181.28,40.01
GND on TOP (solid shape): 210.19,128.91 210.19,126.62 210.44,126.36 212.6,126.36 212.98,125.98 212.98,124.97 212.6,124.59 212.05,124.59 212.02,124.61 210.66,124.61 210.63,124.59 209.42,124.59 209.04,124.97 209.04,128.91 209.3,129.16 209.93,129.16
GND on TOP (solid shape): 42,218.17 42,217.31 41.86,217.17 41.58,217.17 41.41,217.34 41.41,217.49 41.35,217.55 39.27,217.55 39.24,217.58 39.24,218.11 39.35,218.21 39.38,218.21 39.48,218.31 41.85,218.31
GND on TOP (solid shape): 57.07,78.59 57.07,77.72 57.38,77.42 57.38,76.96 57.94,76.4 57.94,75.49 57.86,75.41 57.56,75.41 57.38,75.59 57.38,75.9 56.74,76.53 56.74,77.67 56.41,78 56.41,78.54 56.59,78.71 56.95,78.71
GND on TOP (solid shape): 224.54,166.67 224.54,161.8 224.79,161.54 224.79,159.26 223.8,158.27 223.8,157.63 223.67,157.51 223.37,157.51 223.24,157.63 223.24,162.86 223.9,163.52 223.9,166.67 224.08,166.85 224.36,166.85
GND on TOP (solid shape): 8.33,146.87 9.03,146.87 9.18,146.71 9.18,146.4 9.03,146.26 8.28,146.26 8.17,146.43 8,146.53 7.8,146.73 7.8,146.87 7.91,146.99 8.21,146.99
GND on TOP (solid shape): 201.37,96.55 201.37,91.63 200.6,90.86 200.6,89.54 200.46,89.41 199.4,89.41 199.15,89.66 199.16,89.83 199.12,89.99 199.12,92.45 198.78,92.8 198.78,96.95 199.07,97.25 200.67,97.25
GND on TOP (solid shape): 204.64,86.62 204.98,86.28 204.98,84.81 204.6,84.43 204.6,82.83 204.9,82.52 204.9,81.63 204.74,81.47 203.49,81.47 202.58,82.38 202.58,83.07 202.08,83.57 202.08,85.08 202.56,85.56 202.56,86.94 202.85,87.22 204.64,87.22
GND on TOP (solid shape): 226.69,103.43 226.69,102.87 226.79,102.77 226.79,102.74 226.82,102.74 226.85,102.72 227.15,102.72 227.2,102.67 227.2,101.07 227.15,101.02 225.48,101.02 225.48,102.64 225.53,102.69 226.34,102.69 226.47,102.82 226.47,103.4 226.54,103.48 226.64,103.48
GND on TOP (solid shape): 234.98,115.82 234.98,115.42 234.92,115.37 234.92,113.89 234.82,113.79 234.44,113.79 234.01,114.22 231.32,114.22 230.4,115.14 230.4,115.93 230.43,115.95 234.85,115.95
GND on TOP (solid shape): 209.3,179.65 209.3,174.6 209.45,174.45 211.48,174.45 212.27,173.66 212.27,172.64 211.91,172.29 206.93,172.29 206.88,172.34 206.88,173.05 207.01,173.18 207.47,173.18 207.65,173.35 207.65,174.14 207.85,174.35 207.85,180.47 207.87,180.49 208.46,180.49
GND on TOP (solid shape): 149.25,228.75 149.25,228.4 149,228.15 147.78,228.15 147.6,227.97 147.6,227.46 147.57,227.43 147.4,227.43 147.37,227.46 147.37,227.97 147.19,228.15 146.44,228.15 146.19,228.4 146.19,228.77 146.4,228.98 149.02,228.98
GND on TOP (solid shape): 215.54,111.84 215.54,110.85 215.39,110.69 213.94,110.69 213.47,110.23 212.48,110.23 212.29,110.41 212.29,111.52 212.33,111.56 212.81,111.56 212.98,111.73 212.98,112.07 213.03,112.12 213.41,112.12 213.61,111.91 214.63,111.91 214.86,112.14 215.24,112.14
GND on TOP (solid shape): 193.07,66.52 193.07,66.05 192.37,65.35 192.35,65.35 191.52,64.52 191.52,64.06 191.2,63.74 190.11,63.74 190.03,63.82 190.01,63.82 189.61,64.22 189.61,65.93 189.68,66 191.62,66 191.95,66.33 191.95,66.61 192.02,66.67 192.91,66.67
GND on TOP (solid shape): 39.3,212.58 39.3,211.13 39.83,210.6 39.85,210.6 39.85,210.29 39.8,210.29 39.74,210.23 39.6,210.17 39.45,210.19 39.4,210.22 39.07,210.22 38.59,210.7 38.59,212.63 39.24,212.63
GND on TOP (solid shape): 209.99,144.54 209.99,144.4 209.99,144.39 209.95,144.1 210.08,143.85 210.08,143.46 209.32,142.7 209.04,142.7 208.91,142.82 208.91,144.27 209.12,144.48 209.37,144.48 209.58,144.68 209.85,144.68
GND on TOP (solid shape): 137.29,226.19 137.29,224.92 137.03,224.66 130.47,224.66 130.32,224.81 130.32,227.44 130.14,227.63 129.36,227.63 128.84,227.11 128.84,226.59 127.98,225.73 127.98,224.91 127.77,224.7 124.34,224.7 124.21,224.82 124.21,228.2 124.23,228.22 135.25,228.22
GND on TOP (solid shape): 57.77,140.91 57.77,139.21 58.82,138.16 59.69,138.16 60.59,139.06 60.59,140.77 60.74,140.92 63.93,140.92 64.01,140.84 64.01,139.06 64.14,138.94 64.14,138.51 64.59,138.05 65.68,138.05 65.79,137.95 65.79,136.68 65.38,136.27 64.57,136.27 63.3,137.54 54.97,137.54 54.51,137.99 54.51,140.87 54.61,140.96 57.71,140.96
GND on TOP (solid shape): 224.84,116.56 224.84,114.62 224.92,114.54 225.21,114.54 225.27,114.48 225.27,112.96 225.23,112.91 223.76,112.91 223.67,113 223.67,114.47 223.72,114.52 224.49,114.52 224.59,114.62 224.59,115.98 224.21,116.36 224.21,116.74 224.29,116.83 224.57,116.83
GND on TOP (solid shape): 49.1,202.3 49.1,174.6 49.78,173.91 49.78,165 50.34,164.44 50.34,151.16 50.06,150.88 49.4,150.88 49.28,151 49.28,163.86 48.77,164.36 48.77,172.49 48.77,172.52 46.99,174.29 46.25,175.03 46.25,177.5 47.05,178.3 47.05,197.37 47.07,197.38 47.07,201.64 47.96,202.54 48.86,202.54
GND on TOP (solid shape): 214.63,160.22 214.63,158.95 214.01,158.33 212.5,158.33 212.24,158.42 211.99,158.33 211.91,158.33 210.72,158.33 209.89,159.16 207.65,159.16 207.44,159.36 207.44,160.48 207.49,160.53 214.33,160.53
GND on TOP (solid shape): 212.25,198.11 212.91,198.11 213,198.02 213,194.73 212.97,194.69 211.46,194.69 211.05,194.28 211.05,193.8 210.95,193.7 210.41,193.7 210.29,193.58 210.29,193.57 210.19,193.47 210.19,192.87 210.76,192.29 212.45,192.29 213.02,191.72 213.02,188.45 212.95,188.38 211.54,188.38 211.24,188.09 210.36,188.09 209.37,189.08 209.37,198.37 209.65,198.65 211.7,198.65
GND on TOP (solid shape): 114.17,226.95 115.19,226.95 115.82,226.31 115.82,224.92 115.57,224.66 109.47,224.66 109.23,224.9 109.23,227.32 108.93,227.62 107.7,227.62 107.44,227.37 107.44,226.95 106.43,225.93 106.43,224.79 106.38,224.74 103.05,224.74 102.99,224.8 102.99,226.27 102.97,226.29 103.23,226.29 103.5,226.57 103.5,228.22 103.63,228.35 112.78,228.35
GND on TOP (solid shape): 221.82,112.5 222.02,112.5 222.15,112.37 222.15,111.84 222.1,111.8 221.66,111.64 221.66,111.17 221.62,111.12 221.11,111.12 220.98,111.25 220.98,112.62 221.16,112.8 221.51,112.8
GND on TOP (solid shape): 57.82,158.58 57.82,156.98 57.82,156.98 57.82,156.81 58.78,155.85 59.82,155.85 60.36,156.4 60.36,158.3 60.72,158.67 64.08,158.67 64.08,156.27 64.52,155.83 65.94,155.83 66.01,155.75 66.01,155.22 65.4,154.6 65.4,153.86 65.28,153.75 63.95,153.75 62.87,154.83 56.62,154.83 56.35,154.56 55.3,154.56 54.44,155.41 54.44,158.74 57.66,158.74
GND on TOP (solid shape): 57.76,176.09 57.76,174.65 58.17,174.25 58.17,173.87 58.17,173.86 58.67,173.35 59.08,173.35 59.08,173.36 59.94,173.36 60.6,174.02 60.6,176.08 60.7,176.18 63.94,176.18 64,176.12 64,174.64 64.12,174.51 64.12,173.61 64.38,173.35 65.79,173.35 65.91,173.23 65.91,172.81 65.32,172.22 65.32,171.64 65.14,171.45 64.14,171.45 62.82,172.76 54.91,172.76 54.51,173.17 54.51,176.22 57.63,176.22
GND on TOP (solid shape): 81.76,221.18 81.76,221.11 81.69,221.03 81.13,221.03 80.95,220.85 80.95,216.61 81.15,216.41 81.69,216.41 81.74,216.36 81.74,216.31 81.69,216.26 80.98,216.26 80.82,216.41 76.5,216.41 76.33,216.23 75.59,216.23 75.51,216.31 75.51,216.38 75.54,216.41 76.15,216.41 76.33,216.59 76.33,220.83 76.12,221.03 75.59,221.03 75.51,221.11 75.51,221.16 75.56,221.21 76.35,221.21 76.53,221.03 80.8,221.03 81,221.23 81.71,221.23
GND on TOP (solid shape): 63.99,192.42 64.13,192.28 64.13,191.26 64.39,191.01 65.79,191.01 65.91,190.88 65.91,190.32 65.35,189.76 65.35,189.18 65.28,189.1 64.9,189.1 64.14,189.87 63.25,189.87 62.72,190.39 55.62,190.39 54.48,191.53 54.48,193.8 57.63,193.8 57.71,193.72 57.71,192.31 58,192.02 58.57,192.02 58.8,191.8 58.8,191.11 58.94,190.96 59.8,190.96 60.36,191.52 60.36,193.62 60.63,193.88 63.99,193.88
GND on TOP (solid shape): 73.38,138.81 75.69,138.81 75.82,138.68 75.82,136.25 75.72,136.14 73,136.14 72.92,136.22 72.92,137.44 72.77,137.59 71.81,137.59 71.55,137.34 71.55,136.25 71.45,136.14 69.85,136.14 69.34,135.64 68.71,135.64 68,134.92 68,134.52 67.72,134.24 65.76,134.24 65.05,134.95 65.05,135.84 65.23,136.02 67.11,136.02 68.29,137.2 68.29,138.14 68.71,138.56 69.07,138.56 69.34,138.29 69.34,138.2 69.62,137.92 70.96,137.92 71.49,138.45 71.49,139.31 71.93,139.75 72.44,139.75
GND on TOP (solid shape): 122.05,161.93 122.05,159.77 121.83,159.55 121.81,159.56 121.67,159.56 121.54,159.51 121.31,159.51 121.11,159.56 120.91,159.51 120.44,159.51 120.43,159.51 120.29,159.54 120.16,159.51 120.15,159.51 119.8,159.51 119.72,159.53 119.63,159.54 119.61,159.54 119.38,159.77 119.38,161.93 119.57,162.12 121.86,162.12
GND on TOP (solid shape): 23,219.76 23.03,219.66 22.96,219.59 22.64,219.06 23.15,218.7 23.43,218.7 23.68,218.44 23.68,216.29 23.5,216.1 21.75,216.1 21.57,216.28 21.57,219.78 21.77,219.98 22.78,219.98
GND on TOP (solid shape): 160.62,40.96 160.63,40.83 160.63,40.79 160.58,40.59 160.63,40.38 160.63,39.88 160.45,39.7 160.38,39.7 160.3,39.78 160.26,39.87 160.19,39.95 160.01,40.13 159.44,40.13 159.26,40.31 159.26,40.51 159.41,40.67 159.66,40.67 159.91,40.91 159.97,40.91 160.08,40.92 160.19,40.97 160.38,40.97 160.45,41.05 160.59,41.05
GND on TOP (solid shape): 37.33,148.01 37.43,147.94 37.41,147.84 37.42,147.2 38.05,147.18 38.1,147.2 38.15,147.22 38.93,147.22 39.24,147.22 40.03,146.43 40.03,145.24 40.54,144.74 40.54,140.82 40.26,140.54 33.17,140.54 32.94,140.77 32.94,147.17 33.1,147.32 34.9,147.32 35.59,148.01
GND on TOP (solid shape): 23.48,118.21 23.77,118.06 24.08,118.17 24.12,118.19 24.15,118.17 24.46,118.06 24.75,118.21 25.1,118.21 25.23,118.08 25.23,116.99 25.2,116.95 24.7,116.95 24.66,116.99 24.66,117.46 24.61,117.5 24.29,117.5 24.26,117.47 24.26,116.98 24.23,116.95 23.77,116.95 23.74,116.98 23.74,117.45 23.69,117.5 23.4,117.5 23.34,117.45 23.34,116.99 23.31,116.95 22.84,116.95 22.83,116.97 22.83,117.95 23.09,118.21
GND on TOP (solid shape): 218.97,165.91 218.97,163.55 218.82,163.4 218.54,163.4 218.45,163.47 218.48,163.58 218.65,163.74 218.76,163.94 218.56,164.84 217.64,164.97 217.47,164.85 217.33,164.69 217.22,164.65 217.14,164.75 217.14,165.61 217.75,166.22 218.67,166.22
GND on TOP (solid shape): 182.61,61.96 182.61,60.9 182.19,60.48 182.05,60.45 181.92,60.38 181.79,60.38 181.63,60.42 181.47,60.38 181.28,60.38 181.15,60.25 180.98,60.25 180.95,60.31 180.9,60.36 180.9,60.47 180.97,60.54 181.02,60.62 181.49,60.62 181.55,60.7 181.6,60.73 181.65,60.73 181.8,60.69 182.02,60.92 182.02,61.24 181.82,61.43 181.67,61.43 181.63,61.44 181.59,61.43 181.24,61.43 181.06,61.45 181.09,61.59 181.12,61.61 181.12,62.04 181.22,62.14 182.43,62.14
GND on TOP (solid shape): 161.7,47.46 161.7,46.62 161.72,46.49 161.79,46.39 161.94,46.25 161.95,46.13 161.96,46.02 161.99,45.92 162,45.85 161.96,45.79 161.87,45.77 161.79,45.72 161.74,45.7 161.69,45.7 161.63,45.76 161.6,45.8 161.57,45.82 161.32,46.07 161.36,46.29 161.22,46.47 161.17,46.53 161.17,46.61 161.2,46.66 161.2,46.79 161.14,46.91 161.14,47.36 161.37,47.59 161.57,47.59
GND on TOP (solid shape): 93.73,147.19 93.73,145.54 93.34,145.16 86.84,145.16 86.74,145.26 86.74,145.87 87.15,146.28 91.26,146.28 91.26,146.2 91.28,146.12 91.3,146.04 91.32,145.97 91.36,145.89 91.4,145.83 91.45,145.76 91.51,145.7 91.57,145.65 91.63,145.6 91.7,145.56 91.78,145.53 91.85,145.5 91.93,145.48 92.01,145.47 92.1,145.47 92.18,145.48 92.26,145.49 92.33,145.51 92.41,145.54 92.48,145.58 92.55,145.62 92.61,145.67 92.67,145.73 92.72,145.79 92.77,145.86 92.81,145.93 92.84,146.01 92.86,146.08 92.88,146.16 92.89,146.24 92.89,146.32 92.88,146.41 92.86,146.48 92.84,146.56 92.81,146.64 92.77,146.71 92.72,146.78 92.67,146.84 92.61,146.89 92.55,146.94 92.48,146.99 92.41,147.03 92.33,147.06 92.26,147.08 92.18,147.09 92.1,147.1 92.01,147.1 91.93,147.09 91.85,147.07 91.78,147.04 91.7,147.01 91.63,146.97 91.57,146.92 91.51,146.87 91.45,146.81 91.4,146.74 91.36,146.67 91.32,146.6 91.3,146.52 91.28,146.45 91.26,146.36 91.26,146.28 87.15,146.28 88.75,147.88 93.04,147.88
GND on TOP (solid shape): 85.57,143.76 85.57,141.12 85.56,141.11 85.56,138.9 84.33,137.67 82.17,137.67 81.71,138.13 81.71,139.12 83.08,139.12 83.09,139.04 83.1,138.96 83.12,138.88 83.15,138.8 83.18,138.73 83.22,138.66 83.27,138.6 83.33,138.54 83.39,138.48 83.45,138.44 83.52,138.4 83.6,138.36 83.68,138.34 83.75,138.32 83.84,138.31 83.92,138.31 84,138.31 84.08,138.33 84.16,138.35 84.23,138.38 84.3,138.42 84.37,138.46 84.43,138.51 84.49,138.57 84.55,138.63 84.59,138.7 84.63,138.77 84.66,138.84 84.69,138.92 84.7,139 84.71,139.08 84.71,139.16 84.7,139.24 84.69,139.32 84.66,139.4 84.63,139.47 84.59,139.55 84.55,139.61 84.49,139.67 84.43,139.73 84.37,139.78 84.3,139.83 84.23,139.86 84.16,139.89 84.08,139.91 84,139.93 83.92,139.93 83.84,139.93 83.75,139.92 83.68,139.9 83.6,139.88 83.52,139.85 83.45,139.8 83.39,139.76 83.33,139.7 83.27,139.64 83.22,139.58 83.18,139.51 83.15,139.44 83.12,139.36 83.1,139.28 83.09,139.2 83.08,139.12 81.71,139.12 81.71,140.77 84.96,144.02 85.32,144.02
