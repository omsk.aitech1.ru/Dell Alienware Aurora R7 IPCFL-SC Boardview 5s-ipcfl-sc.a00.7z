# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_TXP0: length 125.4
  TOP w0.102: PCH.N27 v1(172.15,56.73) ; XU1.AC2 126.92,143.08 126.83,143.08 126.61,142.86 126.61,142.15 126.83,141.94 126.83,139.93 126.55,139.65 126.55,133.46 146.61,113.4 146.61,111.52 147.24,110.9 148.07,110.9 148.35,110.62 148.35,109.8 148.18,109.63 v1(147.72,109.63)
  BOTTOM w0.102: 148.8,102.06 148.8,97.78 151.79,94.79 169.67,94.79 179.22,85.24 179.22,77.73 179.65,77.3 179.65,74.24 173.44,68.03 173.44,61.68 173.28,61.52 173.28,60.68 172.81,60.21 172.81,57.39 v1(172.15,56.73) ; 148.8,102.06 v2(149.1,102.06) ; 148.8,102.06 148.8,109.24 148.58,109.46 147.89,109.46 v1(147.72,109.63)
DMI_TXP1: length 122.7
  TOP w0.102: PCH.G24 171.86,59 v1(172.09,59) ; XU1.AD3 127.62,143.78 127.62,142.23 127.53,142.15 127.53,139.66 127.28,139.4 127.28,133.75 147.78,113.25 147.78,112.14 v1(147.55,111.91)
  BOTTOM w0.089: v1(172.09,59) 171.75,59.34 171.75,60.15 172.12,60.52
  BOTTOM w0.102: 172.12,60.52 172.49,60.89 172.49,61.41 172.19,61.71 172.19,68.03 178.77,74.61 178.77,76.89 178.31,77.34 178.31,84.9 169.3,93.9 151.31,93.9 147.88,97.34 147.88,102.56 147.45,102.99 147.45,106.35 146.86,106.93 146.86,108.33 146.76,108.43 146.76,109.75 ; v1(147.55,111.91) 147.55,111.11 146.99,110.55 146.99,110.32 146.76,110.09 146.76,109.75 ; 146.76,109.75 v2(146.47,109.75)
DMI_TXP2: length 121.3
  TOP w0.102: v1(173.23,59.94) 173.13,59.94 172.97,59.79 172.64,59.79 172.54,59.9 PCH.E26 ; v1(149.84,109.92) 150.17,109.92 150.42,110.17 150.42,111.59 128,134.01 128,139.01 128.31,139.32 128.31,141.21 128.68,141.57 128.68,142.07 128.55,142.19 128.55,142.62 129.11,143.18 XU1.AE2
  BOTTOM w0.102: 149.73,99.19 149.73,97.73 152.19,95.28 169.9,95.28 179.71,85.47 179.71,77.95 180.14,77.52 180.14,74.02 174.4,68.28 174.4,65.28 173.81,64.69 173.81,61.66 173.56,61.41 173.56,60.51 173.44,60.4 173.44,60.16 v1(173.23,59.94) ; 149.73,99.19 v2(149.44,99.19) ; 149.73,99.19 149.73,105.77 149.31,106.19 149.31,109.38 v1(149.84,109.92)
DMI_TXP3: length 126.3
  TOP w0.102: PCH.K29 173.91,57.68 173.71,57.49 173.53,57.49 v1(173.34,57.67) ; XU1.AF2 130.03,143.79 129.95,143.87 129.82,143.87 129.66,143.7 129.66,141.42 129.25,141.01 129.25,138.95 128.93,138.62 128.93,134.34 152.35,110.92 152.35,108.53 152.1,108.28 151.61,108.28 151.41,108.48 v1(151.05,108.48)
  BOTTOM w0.102: 151.12,102.77 151.12,99.71 150.77,99.36 150.77,97.68 152.47,95.99 170.17,95.99 180.39,85.77 180.39,78.25 180.82,77.82 180.82,73.71 175.11,68 175.11,63.65 174.6,63.14 174.6,60.78 174.35,60.53 174.24,60.53 173.84,60.12 173.84,57.84 173.67,57.67 v1(173.34,57.67) ; 151.12,102.77 v2(150.83,102.77) ; 151.12,102.77 151.12,107.57 151.51,107.96 151.51,108.37 151.4,108.48 v1(151.05,108.48)
DONGLE_CTRL_AUX_DN: length 5.1
  TOP w0.102: MQ10.4 32.37,174.35 32.75,174.73 34.66,174.73 M1C13.2 35.46,173.93 v1(35.46,173.53)
  BOTTOM w0.102: v1(35.46,173.53) 35.46,172.87 v2(35.64,172.69)
DONGLE_CTRL_AUX_DP: length 3.8
  TOP w0.102: MQ10.1 33.67,175.4 33.91,175.16 M1C12.2 35.14,175.5 v1(35.48,175.84)
  BOTTOM w0.102: v1(35.48,175.84) v2(35.48,175.08)
DP_3P3V_PWR_FUSE: length 12.3
  TOP w0.508: MQ4.3 21.89,168.62 v1(22.35,169.09) PR641.1 ; v1(21.64,175.77) 21.01,176.4 19.68,176.4
  BOTTOM w0.508: v1(22.35,169.09) 22.38,169.11 v2(22.38,169.9) 22.38,170.54 22.66,170.81 22.66,174.76 21.65,175.77 v1(21.64,175.77)
DP_AUXN_DP_OUT: length 29.3
  TOP w0.102: MQ10.3 32.37,176.62 32.04,176.95 M1R8.2 29.32,176.95 27.78,175.4 MQ12.6 26.3,175.4 26.3,175.4 25.93,175.77 24.15,175.77 23.67,175.29 21.03,175.29 v1(20.83,175.49) ; J125.17 11.39,171.07 14.1,171.07 16,172.97 18.67,172.97 19.28,172.37 20.47,172.37 v1(20.83,172.72)
  BOTTOM w0.102: v1(20.83,172.72) v2(20.83,174.24) v1(20.83,175.49)
DP_AUXP_DP_OUT: length 28.5
  TOP w0.102: MQ10.6 33.67,173.57 33.22,173.13 31.72,173.13 31.22,173.63 30.61,173.63 30.54,173.57 M1R11.1 27.95,173.57 27.42,174.1 MQ12.4 27.04,174.1 25.65,172.72 21.84,172.72 21.21,172.09 19.18,172.09 18.54,172.72 16.07,172.72 14.17,170.81 12.54,170.81 J125.15
DP_CAD_PIN13: length 38.3
  TOP w0.102: MQ8.5 39.67,176.78 39.5,176.61 39.5,174.57 38.96,174.04 38.38,174.04 36.88,172.54 28.6,172.54 27.51,171.45 19.35,171.45 19.14,171.23 M1R36.1 19.14,170.42 19.3,170.26 M1C35.1 17.72,169.93 M1D1.1 16.19,169.42 v1(15.75,169.42) 15.49,169.16 13.58,169.16 10.94,166.52 J125.13
  BOTTOM w0.102: v1(15.75,169.42) 15.75,168.86 v2(15.99,168.62)
DP_DDPD_CTRL: length 21.2
  TOP w0.102: v1(31.42,178.18) 31.55,178.05 36.96,178.05 38.1,179.2 38.87,179.2 M1R4.2 40.11,178.69 40.64,178.16 40.64,177.55 40.53,177.43 MQ8.6 ; MQ12.2 MQ12.5 27.97,174.75 28.16,174.94 28.16,175.28 28.43,175.55 29.38,175.55 29.99,174.94 30.82,174.94 v1(31.27,175.39)
  BOTTOM w0.102: v1(31.42,178.18) v2(31.42,176.78) 31.42,176.4 31.27,176.25 v1(31.27,175.39)
DP_TXN0_RD_OUT: length 156.5
  TOP w0.102: v1(94.41,149.35) 94.69,149.07 94.69,148.77 95.07,148.39 99.42,148.39 105.49,154.46 106.61,154.46 106.94,154.79 107.42,154.79 107.57,154.64 107.57,154.48 107.5,154.42 XU1.A14 ; SC65.2 18.77,163.18 19.27,163.18 19.84,163.75 26.53,163.75 31.5,168.72 39.04,168.72 40.01,167.74 41.37,167.74 v1(41.59,167.96)
  BOTTOM w0.102: 88.39,138.18 v2(88.09,138.18) ; 88.39,138.18 88.39,131.85 82.14,125.61 82.14,125.59 73.35,116.79 73.33,116.79 72.93,116.79 72.93,116.79 61.9,116.79 59.66,119.02 59.66,124.54 47.13,137.08 47.13,143.53 45.01,145.65 45.01,154.65 44.31,155.35 44.31,159.55 43.18,160.68 43.18,166.95 42.38,167.75 41.8,167.75 v1(41.59,167.96) ; 88.39,138.18 88.39,138.67 92.46,142.74 92.78,142.74 94.69,144.65 94.69,149.07 v1(94.41,149.35)
DP_TXN1_RD_OUT: length 158.6
  TOP w0.102: SC67.2 18.77,165.01 19.71,165.01 20.25,164.47 26.27,164.47 31.27,169.47 39.58,169.47 v1(39.89,169.78) ; XU1.B15 108.39,155.33 108.48,155.42 108.48,155.65 108.43,155.7 105.7,155.7 99.18,149.19 97.52,149.19 97.16,149.54 97.16,149.85 v1(96.9,150.11)
  BOTTOM w0.102: v1(96.9,150.11) 97.16,149.86 97.16,149.39 95.55,147.79 95.55,144.53 89.46,138.43 89.46,131.91 73.65,116.1 73.61,116.1 73.61,116.1 72.64,116.1 61.57,116.1 58.93,118.75 58.93,124.29 46.44,136.77 46.44,143.24 44.32,145.36 44.32,154.37 43.62,155.06 43.62,159.25 42.5,160.37 42.5,165.43 40.89,167.03 40.89,168.68 ; v1(39.89,169.78) 40.17,169.49 40.54,169.49 40.89,169.14 40.89,168.68 ; 40.89,168.68 v2(41.19,168.68)
DP_TXN2_RD_OUT: length 159.4
  TOP w0.102: XU1.A16 107.46,156.24 107.56,156.35 107.56,156.49 107.43,156.62 106.88,156.62 106.72,156.46 105.44,156.46 99.78,150.8 95.38,150.8 95.11,151.07 95.11,151.27 v1(94.79,151.59) ; SC69.2 18.82,166.79 19.32,166.79 20.71,165.4 26.24,165.4 31.14,170.31 38.91,170.31 39.34,170.74 41.07,170.74 v1(41.38,171.05)
  BOTTOM w0.102: 87.33,141.83 87.33,131.76 73.04,117.47 62.25,117.47 60.35,119.37 60.35,124.85 47.82,137.38 47.82,143.81 45.69,145.93 45.69,154.93 45,155.63 45,159.89 43.87,161.02 43.87,169.29 42.44,170.71 41.71,170.71 v1(41.38,171.05) ; 87.33,141.83 87.33,143.21 95.11,150.99 95.11,151.27 v1(94.79,151.59) ; 87.33,141.83 v2(87.02,141.83)
DP_TXN3_RD_OUT: length 163.5
  TOP w0.102: SC153.2 18.94,168.5 19.9,168.5 20.14,168.26 20.14,167.09 21.09,166.14 26,166.14 30.85,170.99 37.2,170.99 38.52,172.31 40.23,172.31 v1(40.41,172.49) ; XU1.B17 108.55,157.16 108.57,157.18 108.57,157.44 108.49,157.52 105.41,157.52 100.24,152.35 97.51,152.35 97.41,152.25 97.41,152 v1(97.59,151.82)
  BOTTOM w0.102: v1(97.59,151.82) 97.49,151.93 97.49,152.4 97.23,152.65 94.59,152.65 93.52,151.59 93.52,150.37 86.11,142.96 86.11,131.53 72.74,118.16 62.53,118.16 61.06,119.63 61.06,125.13 48.5,137.69 48.5,146.35 46.38,148.47 46.38,155.22 45.68,155.92 45.68,160.22 44.56,161.35 44.56,170.4 42.66,172.29 42.04,172.29 ; v1(40.41,172.49) 40.61,172.29 42.04,172.29 ; 42.04,172.29 v2(42.04,172.59)
DP_TXP0_RD_OUT: length 156.5
  TOP w0.102: v1(41.59,167.32) 41.37,167.54 39.93,167.54 38.95,168.52 31.58,168.52 26.61,163.55 19.92,163.55 19.35,162.98 18.85,162.98 SC64.2 ; v1(95.07,149.35) 94.89,149.17 94.89,148.85 95.16,148.59 99.33,148.59 105.4,154.66 106.53,154.66 106.86,154.99 107.51,154.99 XU1.B14
  BOTTOM w0.102: 88.6,136.63 v2(88.9,136.63) ; 88.6,136.63 88.6,138.58 92.55,142.53 92.86,142.53 94.89,144.57 94.89,149.17 v1(95.07,149.35) ; 88.6,136.63 88.6,131.77 82.35,125.52 82.35,125.5 73.43,116.59 73.41,116.59 72.84,116.59 61.82,116.59 59.46,118.94 59.46,124.46 46.93,136.99 46.93,143.44 44.81,145.56 44.81,154.57 44.11,155.26 44.11,159.47 42.98,160.59 42.98,166.87 42.3,167.55 41.82,167.55 v1(41.59,167.32)
DP_TXP1_RD_OUT: length 158.6
  TOP w0.102: XU1.C15 108.71,155.62 108.71,155.72 108.53,155.91 105.61,155.91 99.1,149.39 97.6,149.39 97.36,149.63 97.36,149.92 v1(97.56,150.11) ; v1(39.89,169.14) 39.76,169.27 31.36,169.27 26.36,164.26 20.17,164.26 19.62,164.81 18.85,164.81 SC66.2
  BOTTOM w0.102: 42.29,164.53 42.29,160.29 43.42,159.16 43.42,154.98 44.12,154.28 44.12,145.28 46.24,143.16 46.24,136.69 58.72,124.21 58.72,118.66 61.49,115.9 72.56,115.9 73.74,115.9 89.66,131.82 89.66,138.35 95.76,144.44 95.76,147.7 97.36,149.3 97.36,149.91 v1(97.56,150.11) ; 42.29,164.53 v2(42,164.53) ; 42.29,164.53 42.29,165.34 40.69,166.95 40.69,169.05 40.45,169.29 40.05,169.29 v1(39.89,169.14)
DP_TXP2_RD_OUT: length 159.4
  TOP w0.102: XU1.B16 107.87,156.24 107.76,156.35 107.76,156.57 107.52,156.82 106.79,156.82 106.64,156.67 105.36,156.67 99.69,151 95.46,151 95.31,151.16 95.31,151.47 v1(95.45,151.61) ; v1(41.38,170.35) 41.2,170.54 39.43,170.54 39,170.1 31.23,170.1 26.32,165.2 20.62,165.2 19.24,166.59 18.8,166.59 SC68.2
  BOTTOM w0.102: v1(95.45,151.61) 95.32,151.48 95.32,150.91 87.53,143.12 87.53,140.17 ; 87.53,140.17 87.53,131.67 73.13,117.27 62.17,117.27 60.15,119.29 60.15,124.76 47.61,137.3 47.61,143.73 45.49,145.85 45.49,154.85 44.79,155.55 44.79,159.8 43.67,160.93 43.67,169.2 42.36,170.51 41.53,170.51 v1(41.38,170.35) ; 87.53,140.17 v2(87.83,140.17)
DP_TXP3_RD_OUT: length 163.5
  TOP w0.102: SC152.2 18.68,168.3 19.81,168.3 19.94,168.17 19.94,167 21.01,165.94 26.09,165.94 30.94,170.79 37.29,170.79 38.61,172.11 40.15,172.11 v1(40.44,171.83) ; XU1.C17 108.78,157.38 108.78,157.52 108.58,157.72 105.32,157.72 100.15,152.55 97.43,152.55 97.21,152.33 97.21,152.1 v1(96.93,151.82)
  BOTTOM w0.102: 44.35,170.03 44.35,161.26 45.48,160.13 45.48,155.83 46.18,155.14 46.18,148.39 48.3,146.27 48.3,137.6 60.86,125.04 60.86,119.55 62.45,117.96 72.82,117.96 86.31,131.44 86.31,142.87 93.73,150.29 93.73,151.5 94.67,152.45 97.15,152.45 97.28,152.32 97.28,152.17 v1(96.93,151.82) ; 44.35,170.03 44.35,170.32 42.58,172.09 40.7,172.09 v1(40.44,171.83) ; 44.35,170.03 v2(44.06,170.03)
DRAM_RESET#: length 323.1
  TOP w0.089: 164.49,37.97 164.49,38.74 164.59,38.84 164.59,39.57 164.73,39.71 164.73,40.38 164.5,40.6 PCH.BD10
  TOP w0.102: 164.49,37.97 164.49,37.21 162.06,34.78 162.06,34.27 160.71,32.92 v1(160.71,31) ; v1(207.87,58.32) 207.7,58.49 207.7,73.61 209.37,75.29 209.37,79.66 209.74,80.03 209.74,87.74 209.06,88.42 209.06,90.42 209.03,90.45 209.03,91.48 209.19,91.64 209.19,94.23 211,96.04 211.49,96.04 213.08,97.63 v1(213.08,99.24) ; D4R3.1 208.38,181.82 v1(208.38,181.71) ; v1(147.97,25.34) 147.97,25.03 150.42,22.58 151.1,22.58 155.97,17.72 161.48,17.72 162.78,19.02 167.26,19.02 170.32,15.96 170.32,15.13 v1(170.7,14.74) 170.26,14.3 170.26,11.98 167.19,8.92 158.08,8.92 157.22,9.78 155.26,9.78 151.75,13.28 151.26,13.28 150.3,14.25 150.04,14.25 145,14.25 140.26,18.99 140.26,20.75 138.77,22.24 138.77,23.91 133.88,28.8 132.88,28.8 SC121.1 SR659.2
  BOTTOM w0.102: v1(208.38,181.71) 207.82,181.15 207.82,169.62 209.14,168.3 209.14,160.43 212.53,157.04 212.53,142.38 214.2,140.72 214.2,140.03 213.46,139.29 213.46,130.03 215.15,128.34 215.15,127.22 214.4,126.47 214.4,124.35 v2(215.39,123.36) 216.1,122.65 216.1,113.06 215.85,112.8 213.13,112.8 212.39,112.06 212.39,102.57 213.08,101.88 v1(213.08,99.24) ; v1(207.87,58.32) 208.06,58.12 208.06,51.68 207.69,51.3 207.69,50.12 209.21,48.6 209.21,46.92 210.06,46.07 210.06,42.15 211.91,40.29 211.91,38.49 212.24,38.16 212.24,35.41 211.67,34.84 211.67,31.4 210.23,29.96 208.85,29.96 202.21,23.32 202.21,22.11 198.32,18.22 189.49,18.22 187.46,16.19 182.96,16.19 182.16,15.39 181.09,15.39 177.65,15.39 174.12,15.39 173.82,15.1 171.06,15.1 v1(170.7,14.74) ; v1(147.97,25.34) 149.05,26.42 152.77,26.42 154.79,28.44 156.47,28.44 156.7,28.68 158.57,28.68 160.06,30.17 160.33,30.17 160.71,30.54 v1(160.71,31)
DRAM_RESET#_R: length 33
  TOP w0.102: CON_XMM3.58 179.08,183.29 180.46,183.29 181.28,182.47 181.71,182.47 182.22,181.97 184.51,181.97 184.68,181.8 CON_XMM1.58 185.99,181.8 186.18,181.99 188.09,181.99 188.65,182.55 190.93,182.55 191.69,181.8 CON_XMM4.58 196.49,181.8 197.31,180.97 199.1,180.97 199.81,181.69 201.65,181.69 CON_XMM2.58 204.43,181.8 205.14,182.51 D4R3.2 D4C1.1
DUAL_POWER_DISCHARGE: length 10.2
  TOP w0.102: PR512.2 208.62,223.05 209.68,222 PQ10.3 209.68,218.57 209.07,217.96 v1(209.07,217.6) 209.07,217.02 209.3,216.79 MQ24.5 MQ24.2
  BOTTOM w0.102: v2(209.07,218.36) v1(209.07,217.6)
EAPD: length 9.4
  TOP w0.254: AU1.47 18.25,9.92 18.66,9.51 20.84,9.51 21.83,10.5 23.08,10.5 v1(23.39,10.19) 23.75,10.19 24.07,10.5 AR263.1
  BOTTOM w0.102: v1(23.39,10.19) 22.87,9.66 v2(22.87,9.47)
ET_PWRBTN#: length 5.6
  TOP w0.102: P189.4 61.49,7.77 61.17,8.1 61.17,9.45 61.23,9.52 AD20.1 60.61,10.64 O3R5.2
EXP1_TXN0_C: length 9.9
  TOP w0.102: SLOT1.B15 61.01,79.89 61.01,79.55 61.01,79.35 61.14,79.22 61.87,79.22 62.28,79.63 62.28,83.48 61.52,84.25 61.52,85.25 62,85.73 62,85.86 XC2.2
EXP1_TXN1_C: length 9.8
  TOP w0.102: XC4.2 65.37,85.83 65.37,84.32 64.31,83.27 64.31,79.67 64.97,79.02 65.76,79.02 SLOT1.B20
EXP1_TXN2_C: length 9.8
  TOP w0.102: SLOT1.B24 69.73,79.04 69,79.04 68.25,79.8 68.25,83.4 69.3,84.45 69.3,85.83 XC6.2
EXP1_TXN3_C: length 9.7
  TOP w0.102: XC8.2 73.37,85.83 73.37,84.45 72.31,83.4 72.31,79.8 73.2,78.91 73.87,78.91 SLOT1.B28
EXP1_TXN4_C: length 9.8
  TOP w0.102: XC10.2 79.34,85.83 79.34,84.58 78.28,83.52 78.28,79.67 79.04,78.92 79.86,78.92 SLOT1.B34
EXP1_TXN5_C: length 9.8
  TOP w0.102: SLOT1.B38 83.73,79.04 83.1,79.04 82.22,79.93 82.22,83.27 83.4,84.45 83.4,85.83 XC12.2
EXP1_TXN6_C: length 9.8
  TOP w0.102: XC14.2 87.34,85.83 87.34,84.32 86.28,83.27 86.28,79.8 87.16,78.92 87.86,78.92 SLOT1.B42
EXP1_TXN7_C: length 9.8
  TOP w0.102: XC16.2 91.4,85.83 91.4,84.45 90.22,83.27 90.22,79.93 91.1,79.04 91.73,79.04 SLOT1.B46
EXP1_TXN8_C: length 9.7
  TOP w0.102: XC113.2 61.43,25.02 61.43,23.05 62.18,22.3 62.18,21.29 62.28,21.18 62.28,18.88 61.54,18.14 61.32,18.14 61.11,18.34 61.04,18.55 SLOT4.B15
EXP1_TXN9_C: length 9.7
  TOP w0.102: SLOT4.B20 65.86,17.96 65.32,17.96 64.31,18.97 64.31,22.31 65.24,23.24 65.24,25.02 XC115.2
EXP1_TXN10_C: length 9.6
  TOP w0.102: SLOT4.B24 69.84,17.98 69.27,17.98 68.45,18.8 68.45,22.21 69.3,23.06 69.3,25.02 XC117.2
EXP1_TXN11_C: length 9.8
  TOP w0.102: XC119.2 73.37,25.02 73.37,23.36 72.31,22.31 72.31,18.84 73.22,17.93 73.89,17.93 SLOT4.B28
EXP1_TXN12_C: length 10
  TOP w0.102: SLOT4.B34 79.89,17.93 79.06,17.93 78.28,18.71 78.28,22.18 79.46,23.36 79.46,25.02 XC121.2
EXP1_TXN13_C: length 10.1
  TOP w0.102: SLOT4.B38 83.79,18.03 82.9,18.03 82.22,18.71 82.22,22.18 83.4,23.36 83.4,25.02 XC123.2
EXP1_TXN14_C: length 8.7
  TOP w0.102: XC125.2 87.67,24.99 87.67,23.2 88.72,22.15 88.72,18.62 88.45,18.35 SLOT4.B42
EXP1_TXN15_C: length 10
  TOP w0.102: XC127.2 91.27,24.99 91.27,23.24 90.3,22.26 90.3,18.74 90.95,18.08 91.9,18.08 92,17.98 92,17.82 SLOT4.B46
EXP1_TXP0_C: length 9.9
  TOP w0.102: XC1.2 62.2,85.81 62.2,85.65 61.72,85.17 61.72,84.33 62.48,83.57 62.48,79.54 61.96,79.02 61.14,79.02 SLOT1.B14
EXP1_TXP1_C: length 9.8
  TOP w0.102: SLOT1.B19 65.86,79.92 65.86,79.32 65.76,79.22 65.05,79.22 64.52,79.76 64.52,83.19 65.57,84.24 65.57,85.85 XC3.2
EXP1_TXP2_C: length 9.8
  TOP w0.102: XC5.2 69.51,85.85 69.51,84.37 68.45,83.31 68.45,79.88 69.09,79.25 69.75,79.25 69.9,79.4 69.9,79.88 SLOT1.B23
EXP1_TXP3_C: length 9.7
  TOP w0.102: XC7.2 73.57,85.85 73.57,84.37 72.52,83.31 72.52,79.88 73.27,79.13 73.54,79.13 73.84,79.43 73.84,79.94 SLOT1.B27
EXP1_TXP4_C: length 9.8
  TOP w0.102: SLOT1.B33 79.45,79.76 79.76,79.45 79.76,79.25 79.63,79.12 79.12,79.12 78.49,79.76 78.49,83.44 79.54,84.49 79.54,85.85 XC9.2
EXP1_TXP5_C: length 9.9
  TOP w0.102: XC11.2 83.6,85.85 83.6,84.37 82.42,83.19 82.42,80.01 83.19,79.25 83.87,79.25 83.97,79.35 83.97,79.81 SLOT1.B37
EXP1_TXP6_C: length 9.7
  TOP w0.102: SLOT1.B41 87.86,79.92 87.86,79.48 87.5,79.12 87.25,79.12 86.49,79.88 86.49,83.19 87.54,84.24 87.54,85.85 XC13.2
EXP1_TXP7_C: length 9.8
  TOP w0.102: XC15.2 91.61,85.85 91.61,84.37 90.42,83.19 90.42,80.01 91.19,79.25 91.72,79.25 91.92,79.45 91.92,79.86 SLOT1.B45
EXP1_TXP8_C: length 9.7
  TOP w0.102: XC112.2 61.63,24.99 61.63,23.13 62.38,22.39 62.38,21.37 62.48,21.27 62.48,18.8 61.62,17.93 61.01,17.93 SLOT4.B14
EXP1_TXP9_C: length 9.7
  TOP w0.102: XC114.2 65.44,24.99 65.44,23.15 64.52,22.23 64.52,19.05 65.41,18.16 65.62,18.16 65.86,18.4 65.86,18.55 SLOT4.B19
EXP1_TXP10_C: length 9.7
  TOP w0.102: SLOT4.B23 69.85,18.57 69.85,18.31 69.72,18.19 69.35,18.19 68.66,18.88 68.66,22.12 69.51,22.97 69.51,24.99 XC116.2
EXP1_TXP11_C: length 9.9
  TOP w0.102: XC118.2 73.57,24.99 73.57,23.28 72.52,22.23 72.52,18.92 73.3,18.14 73.57,18.14 73.77,18.28 73.86,18.55 SLOT4.B27
EXP1_TXP12_C: length 10
  TOP w0.102: SLOT4.B33 79.86,18.55 79.76,18.27 79.57,18.14 79.15,18.14 78.49,18.8 78.49,22.1 79.67,23.28 79.67,24.99 XC120.2
EXP1_TXP13_C: length 10.1
  TOP w0.102: XC122.2 83.6,24.99 83.6,23.28 82.42,22.1 82.42,18.8 82.98,18.24 83.64,18.24 83.89,18.48 83.89,18.93 SLOT4.B37
EXP1_TXP14_C: length 8.7
  TOP w0.102: XC124.2 87.46,25.02 87.46,23.12 88.52,22.06 88.52,18.7 88.41,18.59 88.23,18.59 SLOT4.B41
EXP1_TXP15_C: length 10
  TOP w0.102: SLOT4.B45 91.97,18.85 91.97,18.44 91.82,18.29 91.03,18.29 90.5,18.82 90.5,22.17 91.48,23.15 91.48,25.02 XC126.2
EXP_RXN0: length 99.9
  TOP w0.102: XU1.B7 v1(108.56,148.49)
  BOTTOM w0.102: v1(108.56,148.49) 108.55,148.49 108.18,148.12 108.18,147.76 107.7,147.28 107.7,145.24 108.15,144.78 108.15,143.78 108.16,143.77 108.16,142.54 109.19,141.51 109.19,112.46 104.95,108.22 104.95,105.62 103.78,104.44 101.8,104.44 99.77,102.41 84.86,102.41 76.23,93.78 72.59,93.78 69.85,91.03 67,91.03 63.88,87.91 63.88,85.78 63.6,85.5 63.6,84.04 63.45,83.89 SLOT1.A17
EXP_RXN1: length 98.9
  TOP w0.102: v1(109.47,147.53) 109.04,147.1 XU1.C6
  BOTTOM w0.102: SLOT1.A22 68.45,84.2 68.2,83.95 67.85,83.95 67.48,84.31 67.48,88 69.06,89.59 70.43,89.59 72.87,92.03 77.78,92.03 80.05,94.3 84.78,94.3 88.7,98.22 99.24,98.22 100.61,99.59 100.61,100.63 101.35,101.37 104.32,101.37 105.55,102.6 105.71,102.76 105.71,107.77 109.93,111.99 109.93,141.88 109.3,142.51 109.3,143.21 108.61,143.9 108.61,145.04 108.16,145.49 108.16,146.14 109.09,147.07 109.09,147.16 v1(109.47,147.53)
EXP_RXN2: length 93.7
  TOP w0.102: v1(109.45,145.72) 109.91,146.18 XU1.D5
  BOTTOM w0.102: SLOT1.A26 72.45,83.98 72.09,83.62 71.69,83.62 71.47,83.83 71.47,87.62 73.69,89.84 77.54,89.84 80.58,92.89 85.31,92.89 89.25,96.82 100.03,96.82 102.1,98.89 102.59,98.89 103.82,100.13 104.5,100.13 106.68,102.3 106.68,107.76 110.62,111.7 110.62,142.07 109.82,142.86 109.82,143.7 109.04,144.48 109.04,145.23 109.2,145.38 109.2,145.47 v1(109.45,145.72)
EXP_RXN3: length 89.1
  TOP w0.102: XU1.E4 110.82,145.28 v1(110.38,145.73)
  BOTTOM w0.102: v1(110.38,145.73) 110.11,145.46 110.11,144.31 110.46,143.96 110.46,143.07 111.19,142.33 111.19,140.6 111.33,140.47 111.33,111.32 107.67,107.66 107.67,102.32 104.61,99.26 103.97,99.26 102.85,98.15 102.34,98.15 100.33,96.14 98.61,96.14 96.58,94.11 88.47,94.11 85.88,91.52 81.46,91.52 75.51,85.57 75.51,83.85 75.74,83.62 76.25,83.62 76.45,83.82 SLOT1.A30
EXP_RXN4: length 85.8
  TOP w0.102: XU1.F5 111.3,145.74 v1(111.28,145.74)
  BOTTOM w0.102: v1(111.28,145.74) 111.02,145.49 111.02,145.35 110.82,145.15 110.82,144.4 111.33,143.9 111.33,143.21 112.32,142.22 112.32,141.48 112.01,141.17 112.01,110.94 108.58,107.51 108.58,102.15 105,98.58 104.45,98.58 99.8,93.93 98.38,93.93 97.19,92.74 89.04,92.74 85.96,89.66 84.58,89.66 84.4,89.84 83.65,89.84 81.48,87.67 81.48,83.88 81.75,83.62 82.17,83.62 82.45,83.9 SLOT1.A36
EXP_RXN5: length 81.9
  TOP w0.102: v1(112.2,145.73) XU1.G4
  BOTTOM w0.102: SLOT1.A40 86.45,83.88 86.21,83.64 85.68,83.64 85.49,83.83 85.49,87.25 89.45,91.21 98.48,91.21 105.04,97.76 105.18,97.76 109.45,102.03 109.45,107.29 112.7,110.54 112.7,140.91 112.98,141.19 112.98,142.58 111.99,143.56 111.99,145.53 v1(112.2,145.73)
EXP_RXN6: length 79.8
  TOP w0.102: XU1.H5 113.55,146.19 113.11,145.75 v1(113.11,145.73)
  BOTTOM w0.102: v1(113.11,145.73) 112.85,145.47 112.85,145.31 112.62,145.07 112.62,143.96 114.2,142.37 114.2,141.67 113.54,141.01 113.54,110.35 110.52,107.34 110.52,99.4 105.89,94.77 104.98,94.77 99.31,89.1 96.99,89.1 96.66,88.77 94.11,88.77 91.11,85.78 89.97,85.78 89.51,85.32 89.51,83.84 89.74,83.62 90.14,83.62 90.45,83.92 SLOT1.A44
EXP_RXN7: length 77.8
  TOP w0.102: XU1.J4 114.44,145.27 v1(114,145.72)
  BOTTOM w0.102: SLOT1.A48 94.45,83.83 94.21,83.59 93.86,83.59 93.58,83.88 93.58,85.27 93.12,85.73 93.12,86.81 94.39,88.09 96.99,88.09 97.32,88.42 99.65,88.42 105.32,94.08 106.2,94.08 111.35,99.24 111.35,107.19 114.23,110.07 114.23,140.73 114.93,141.42 114.93,142.74 113.87,143.8 113.87,145.12 113.77,145.22 113.77,145.49 v1(114,145.72)
EXP_RXN8: length 154.7
  TOP w0.102: SLOT4.A17 62.87,22.45 62.87,22.83 63.65,23.62 63.65,27.68 70.34,34.37 78.69,34.37 94.23,49.91 94.23,67.67 95.5,68.94 95.5,79.07 96.47,80.04 96.47,83.01 97.61,84.15 97.61,85.8 v1(97.79,85.98) ; v1(114.94,145.73) 114.81,145.86 114.81,146 114.99,146.19 XU1.K5
  BOTTOM w0.102: v1(114.94,145.73) 114.89,145.73 114.48,145.31 114.48,144.48 116.15,142.81 116.15,141.5 114.92,140.27 114.92,109.76 112.24,107.08 112.24,99.14 106.49,93.38 106.49,91.73 105.13,90.37 103.76,90.37 100.35,86.97 98.78,86.97 v1(97.79,85.98)
EXP_RXN9: length 151.4
  TOP w0.102: SLOT4.A22 68.45,22.91 68.15,22.61 67.87,22.61 67.44,23.04 67.44,27.3 73.1,32.97 79.23,32.97 95.61,49.34 95.61,67.1 99.64,71.14 99.64,78.91 100.66,79.93 100.66,83.35 101.68,84.37 101.68,85.1 102.16,85.58 102.16,85.9 v1(102.36,86.11) ; v1(115.84,145.73) 115.85,145.73 XU1.L4
  BOTTOM w0.102: v1(102.36,86.11) 102.14,86.33 102.14,86.66 104.07,88.6 105.82,88.6 108.46,91.24 108.46,93.32 108.89,93.75 108.89,94.77 113.18,99.06 113.18,107.03 115.61,109.45 115.61,139.98 116.71,141.09 116.71,143.31 115.6,144.43 115.6,145.49 v1(115.84,145.73)
EXP_RXN10: length 148.9
  TOP w0.102: SLOT4.A26 72.45,23.15 71.91,22.61 71.69,22.61 71.42,22.87 71.42,27.1 75.9,31.57 79.83,31.57 96.98,48.72 96.98,66.5 103.5,73.03 103.5,78.99 104.52,80.01 104.52,83.44 105.41,84.33 105.41,85.65 v1(105.59,85.83) ; XU1.M5 117.23,146.17 v1(116.78,145.72)
  BOTTOM w0.102: v1(116.78,145.72) 116.56,145.5 116.56,145.18 116.36,144.98 116.36,144.65 117.78,143.23 117.78,141.15 116.29,139.66 116.29,109.04 113.96,106.71 113.96,98.73 110.16,94.94 110.16,94.06 110.77,93.45 110.77,91.24 106.22,86.69 105.61,86.69 105.35,86.42 105.35,86.07 v1(105.59,85.83)
EXP_RXN11: length 143.1
  TOP w0.102: v1(117.69,144.82) 118.14,145.27 XU1.N4 ; v1(109.09,85.85) 109.32,85.62 109.32,84.46 108.25,83.4 108.25,83.23 108.25,80.09 107.24,79.08 107.24,75.11 98.17,66.05 98.17,48.13 77.27,27.23 77.27,23.33 76.55,22.61 75.82,22.61 75.64,22.78 75.64,23.06 SLOT4.A30
  BOTTOM w0.102: v1(109.09,85.85) 109.52,86.28 109.52,87.93 112.5,90.91 112.5,96.48 114.64,98.62 114.64,106.66 116.77,108.8 116.77,139.46 118.36,141.04 118.36,144.19 117.98,144.56 117.98,144.68 117.83,144.82 v1(117.69,144.82)
EXP_RXN12: length 142
  TOP w0.102: XU1.P5 119.49,146.63 v1(119.49,146.67) ; SLOT4.A36 82.12,23.22 81.99,23.09 81.81,23.09 81.66,23.24 81.66,29.39 99.82,47.55 99.82,65.46 111.58,77.22 111.58,78.78 112.6,79.8 112.6,83.35 113.64,84.4 113.64,85.62 v1(113.87,85.85)
  BOTTOM w0.102: v1(113.87,85.85) 113.64,86.08 113.64,88.51 115.06,89.93 115.06,94.99 114.64,95.41 114.64,97.21 115.6,98.16 115.6,106.29 117.66,108.36 117.66,138.92 119.6,140.86 119.6,144 119.23,144.38 119.23,145.42 119.09,145.56 119.09,146.27 v1(119.49,146.67)
EXP_RXN13: length 140.7
  TOP w0.102: SLOT4.A40 86.05,23.08 85.92,23.03 85.71,23.13 85.6,23.25 85.6,31.39 101.19,46.99 101.19,64.84 112.3,75.95 113.67,75.95 115.44,77.72 115.44,78.74 116.59,79.88 116.59,83.19 117.58,84.18 117.58,85.5 v1(117.8,85.73) ; v1(120.37,145.73) 119.97,145.33 XU1.R4
  BOTTOM w0.102: v1(117.8,85.73) 117.6,85.93 117.6,90.78 116.92,91.47 116.92,95.37 117.12,95.57 117.12,106.82 118.35,108.05 118.35,138.64 120.27,140.56 120.27,144.39 120.01,144.65 120.01,145.37 v1(120.37,145.73)
EXP_RXN14: length 144.4
  TOP w0.102: SLOT4.A44 90.17,23.31 90.04,23.05 89.9,23.01 89.79,23.06 89.78,23.07 89.53,23.31 89.53,33.39 102.57,46.42 102.57,64.25 112.89,74.57 116.36,74.57 119.51,77.72 119.51,78.99 120.52,80.01 120.52,83.44 121.54,84.45 121.54,85.65 v1(121.75,85.85) ; XU1.T5 v1(121.33,146.63)
  BOTTOM w0.102: v1(121.33,146.63) 121.01,146.28 120.99,146.27 121,146.16 121,146.01 121.08,145.92 121.08,143.16 121.51,142.73 121.51,141.56 121.01,141.06 121.01,140.32 119.06,138.38 119.06,107.68 117.98,106.6 117.98,96.4 119.35,95.03 119.35,94.11 119.13,93.88 119.13,91.44 121.54,89.03 121.54,86.06 v1(121.75,85.85)
EXP_RXN15: length 146.6
  TOP w0.102: XU1.U4 122.22,145.7 v1(122.22,145.73) ; SLOT4.A48 94.45,23.05 94.05,22.65 93.67,22.65 93.42,22.9 93.42,35.33 103.94,45.85 103.94,63.68 113.46,73.2 118.92,73.2 123.44,77.72 123.44,78.87 124.59,80.01 124.59,83.44 125.5,84.35 125.5,85.87 v1(125.71,86.08)
  BOTTOM w0.102: v1(122.22,145.73) 121.89,145.4 121.89,143.38 122.19,143.09 122.19,141.46 121.74,141.01 121.74,140.09 119.75,138.09 119.75,107.14 118.9,106.29 118.9,96.5 121.82,93.58 121.82,90.91 125.5,87.22 125.5,86.29 v1(125.71,86.08)
EXP_RXP0: length 99.9
  TOP w0.102: v1(107.69,148.45) 108.08,148.85 XU1.B8
  BOTTOM w0.102: v1(107.69,148.45) 107.98,148.16 107.98,147.84 107.49,147.36 107.49,145.15 107.95,144.7 107.95,143.7 107.96,143.69 107.96,142.46 108.99,141.43 108.99,112.54 104.75,108.31 104.75,105.71 103.69,104.65 101.72,104.65 99.69,102.62 84.78,102.62 76.14,93.98 72.51,93.98 69.77,91.24 66.92,91.24 63.68,87.99 63.68,85.86 63.4,85.58 63.4,84.12 63.27,84 63.09,84 62.94,84.15 62.94,84.34 SLOT1.A16
EXP_RXP1: length 98.9
  TOP w0.102: XU1.C7 108.61,147.63 v1(108.61,147.56)
  BOTTOM w0.102: v1(108.61,147.56) 108.89,147.28 108.89,147.16 107.96,146.22 107.96,145.41 108.41,144.96 108.41,143.81 109.09,143.13 109.09,142.43 109.73,141.79 109.73,112.07 105.51,107.86 105.51,102.85 105.41,102.75 104.77,102.11 104.24,101.57 101.26,101.57 100.41,100.72 100.41,99.68 99.15,98.42 88.62,98.42 84.69,94.5 79.97,94.5 77.7,92.23 72.79,92.23 70.35,89.79 68.98,89.79 67.28,88.09 67.28,84.23 67.84,83.66 67.84,83.22 67.81,83.19 SLOT1.A21
EXP_RXP2: length 93.7
  TOP w0.102: v1(109.45,146.62) 109.91,147.08 XU1.D6
  BOTTOM w0.102: v1(109.45,146.62) 109,146.16 109,145.47 108.84,145.31 108.84,144.4 109.62,143.62 109.62,142.78 110.41,141.98 110.41,111.79 106.48,107.85 106.48,102.39 104.42,100.33 103.73,100.33 102.5,99.1 102.01,99.1 99.94,97.03 89.16,97.03 85.22,93.09 80.5,93.09 77.45,90.04 73.6,90.04 71.27,87.71 71.27,83.75 71.45,83.57 SLOT1.A25
EXP_RXP3: length 89.1
  TOP w0.102: v1(110.36,146.65) 110.82,146.19 XU1.E5
  BOTTOM w0.102: SLOT1.A29 75.45,83.19 75.45,83.49 75.45,83.62 75.3,83.76 75.3,85.65 81.37,91.72 85.79,91.72 88.38,94.31 96.49,94.31 98.53,96.34 100.25,96.34 102.25,98.35 102.77,98.35 103.89,99.47 104.52,99.47 107.47,102.41 107.47,107.75 111.12,111.4 111.12,140.38 110.99,140.52 110.99,142.25 110.26,142.98 110.26,143.87 109.91,144.22 109.91,146.2 v1(110.36,146.65)
EXP_RXP4: length 85.7
  TOP w0.102: v1(111.27,146.63) 111.73,147.1 XU1.F6
  BOTTOM w0.102: SLOT1.A35 81.45,83.63 81.28,83.79 81.28,87.76 83.57,90.04 84.49,90.04 84.67,89.87 85.88,89.87 88.95,92.94 97.1,92.94 98.3,94.13 99.72,94.13 104.37,98.78 104.92,98.78 108.38,102.24 108.38,107.59 111.81,111.02 111.81,141.26 112.12,141.56 112.12,142.13 111.12,143.13 111.12,143.81 110.62,144.32 110.62,145.23 110.82,145.43 110.82,146.19 v1(111.27,146.63)
EXP_RXP5: length 81.9
  TOP w0.102: v1(112.2,146.64) XU1.G5
  BOTTOM w0.102: SLOT1.A39 85.45,83.19 85.45,83.59 85.29,83.75 85.29,87.33 89.37,91.41 98.4,91.41 104.95,97.97 105.1,97.97 109.25,102.12 109.25,107.37 112.5,110.63 112.5,141 112.78,141.27 112.78,142.49 111.79,143.48 111.79,145.54 111.76,145.57 111.76,146.21 v1(112.2,146.64)
EXP_RXP6: length 79.8
  TOP w0.102: v1(113.11,146.64) 113.12,146.64 113.57,147.1 XU1.H6
  BOTTOM w0.102: SLOT1.A43 89.45,83.62 89.31,83.76 89.31,85.4 89.88,85.98 91.03,85.98 94.03,88.98 96.57,88.98 96.9,89.31 99.23,89.31 104.89,94.97 105.81,94.97 110.32,99.48 110.32,107.43 113.33,110.44 113.33,141.09 114,141.76 114,142.28 112.41,143.87 112.41,145.15 112.65,145.39 112.65,145.92 113.11,146.38 v1(113.11,146.64)
EXP_RXP7: length 77.8
  TOP w0.102: v1(114.02,146.64) XU1.J5
  BOTTOM w0.102: SLOT1.A47 93.45,83.72 93.37,83.79 93.37,85.19 92.91,85.65 92.91,86.89 94.31,88.29 96.9,88.29 97.23,88.62 99.57,88.62 105.23,94.28 106.11,94.28 111.15,99.32 111.15,107.27 114.03,110.15 114.03,140.81 114.73,141.51 114.73,142.65 113.67,143.71 113.67,145.03 113.56,145.14 113.56,146.18 v1(114.02,146.64)
EXP_RXP8: length 154.6
  TOP w0.102: XU1.K6 v1(114.94,146.64) ; v1(97.16,85.98) 97.41,85.72 97.41,84.23 96.27,83.09 96.27,80.12 95.3,79.16 95.3,69.02 94.03,67.75 94.03,50 78.6,34.57 70.26,34.57 63.45,27.76 63.45,23.71 63.16,23.42 62.9,23.42 SLOT4.A16
  BOTTOM w0.102: v1(97.16,85.98) 97.59,86.41 97.93,86.41 98.7,87.17 100.27,87.17 103.67,90.58 105.05,90.58 106.29,91.82 106.29,93.47 112.04,99.22 112.04,107.16 114.72,109.84 114.72,140.35 115.95,141.59 115.95,142.72 114.27,144.4 114.27,145.4 114.43,145.56 114.43,146.14 v1(114.94,146.64)
EXP_RXP9: length 151.4
  TOP w0.102: v1(115.82,146.65) 115.84,146.65 XU1.L5 ; SLOT4.A21 67.45,22.74 67.23,22.95 67.23,27.39 73.02,33.17 79.15,33.17 95.4,49.43 95.4,67.18 99.44,71.22 99.44,78.99 100.46,80.01 100.46,83.44 101.47,84.45 101.47,85.18 101.95,85.66 101.95,85.88 v1(101.73,86.11)
  BOTTOM w0.102: v1(101.73,86.11) 101.94,86.32 101.94,86.75 103.99,88.8 105.73,88.8 108.25,91.32 108.25,93.4 108.69,93.84 108.69,94.85 112.98,99.14 112.98,107.11 115.4,109.53 115.4,140.07 116.51,141.17 116.51,143.23 115.4,144.34 115.4,146.23 v1(115.82,146.65)
EXP_RXP10: length 148.9
  TOP w0.102: SLOT4.A25 71.45,22.56 71.22,22.78 71.22,27.19 75.81,31.78 79.75,31.78 96.77,48.8 96.77,66.59 103.3,73.12 103.3,79.08 104.32,80.09 104.32,83.52 105.21,84.41 105.21,85.57 v1(104.95,85.83) ; XU1.M6 v1(116.76,146.64)
  BOTTOM w0.102: v1(116.76,146.64) 116.36,146.23 116.36,145.27 116.16,145.07 116.16,144.56 117.58,143.14 117.58,141.23 116.09,139.74 116.09,109.13 113.75,106.79 113.75,98.82 109.96,95.02 109.96,93.97 110.57,93.36 110.57,91.33 106.13,86.89 105.53,86.89 105.14,86.51 105.14,86.02 v1(104.95,85.83)
EXP_RXP11: length 143.1
  TOP w0.102: v1(109.73,85.85) 109.52,85.65 109.52,84.38 108.46,83.31 108.46,80.01 107.44,78.99 107.44,75.03 98.37,65.96 98.37,48.05 77.47,27.14 77.47,23.24 76.63,22.4 75.98,22.4 SLOT4.A29 ; XU1.N5 v1(117.68,145.73)
  BOTTOM w0.102: v1(117.68,145.73) 118.18,145.23 118.18,144.65 118.56,144.27 118.56,140.95 116.98,139.37 116.98,108.71 114.84,106.58 114.84,98.54 112.7,96.39 112.7,90.82 109.73,87.85 v1(109.73,85.85)
EXP_RXP12: length 142
  TOP w0.102: SLOT4.A35 81.45,22.9 81.46,22.91 81.46,29.48 99.62,47.64 99.62,65.54 111.38,77.3 111.38,78.87 112.39,79.88 112.39,83.44 113.44,84.48 113.44,85.62 v1(113.21,85.85) ; v1(118.57,146.62) 118.57,146.62 XU1.P6
  BOTTOM w0.102: v1(113.21,85.85) 113.44,86.08 113.44,88.6 114.86,90.02 114.86,94.91 114.44,95.33 114.44,97.29 115.39,98.25 115.39,106.38 117.46,108.44 117.46,139.01 119.4,140.94 119.4,143.92 119.02,144.29 119.02,145.34 118.88,145.47 118.88,146.3 v1(118.57,146.62)
EXP_RXP13: length 140.7
  TOP w0.102: v1(119.51,145.73) 119.96,146.19 XU1.R5 ; SLOT4.A39 85.45,23.11 85.39,23.16 85.39,31.47 100.99,47.07 100.99,64.93 112.21,76.15 113.58,76.15 115.24,77.81 115.24,78.82 116.38,79.97 116.38,83.27 117.37,84.26 117.37,85.52 v1(117.14,85.75)
  BOTTOM w0.102: v1(119.51,145.73) 119.81,145.43 119.81,144.56 120.07,144.3 120.07,140.65 118.15,138.72 118.15,108.14 116.92,106.91 116.92,95.66 116.71,95.45 116.71,91.38 117.4,90.7 117.4,86.01 v1(117.14,85.75)
EXP_RXP14: length 144.4
  TOP w0.102: XU1.T6 120.88,147.06 v1(120.42,146.6) ; SLOT4.A43 89.45,23.11 89.33,23.23 89.33,33.47 102.36,46.5 102.36,64.34 112.8,74.78 116.27,74.78 119.3,77.81 119.3,79.08 120.32,80.09 120.32,83.52 121.34,84.54 121.34,85.62 v1(121.1,85.85)
  BOTTOM w0.102: v1(121.1,85.85) 121.34,86.08 121.34,88.94 118.92,91.36 118.92,93.96 119.15,94.19 119.15,94.95 117.78,96.32 117.78,106.69 118.86,107.76 118.86,138.46 120.8,140.41 120.8,141.15 121.3,141.65 121.3,142.65 120.88,143.07 120.88,145.84 120.79,145.92 120.79,146.16 120.79,146.26 v1(120.42,146.6)
EXP_RXP15: length 146.6
  TOP w0.102: v1(122.2,146.63) 122.2,146.59 XU1.U5 ; SLOT4.A47 93.45,22.58 93.22,22.81 93.22,35.42 103.73,45.93 103.73,63.77 113.37,73.41 118.84,73.41 123.24,77.81 123.24,78.95 124.38,80.09 124.38,83.52 125.3,84.44 125.3,85.85 v1(125.07,86.08)
  BOTTOM w0.102: v1(122.2,146.63) 122.2,146.51 121.69,146 121.69,143.3 121.99,143 121.99,141.55 121.54,141.1 121.54,140.18 119.54,138.18 119.54,107.22 118.69,106.38 118.69,96.42 121.62,93.5 121.62,90.82 125.3,87.14 125.3,86.31 v1(125.07,86.08)
EXP_TXN0: length 95.4
  TOP w0.102: v1(103.76,106.43) 104.47,106.43 104.85,106.81 104.85,123.68 107.54,126.37 107.54,137.61 105.53,139.62 105.53,145.87 106.5,146.84 106.9,146.84 XU1.A6 ; v1(61.8,87.96) 62,87.76 62,87.36 XC2.1
  BOTTOM w0.102: v1(61.8,87.96) 61.98,88.14 61.98,88.5 65.47,92 69.49,92 72.36,94.87 76.04,94.87 84.6,103.43 99.38,103.43 102.23,106.27 103.61,106.27 v1(103.76,106.43)
EXP_TXN1: length 93.4
  TOP w0.102: v1(65.13,87.8) 65.37,87.57 65.37,87.4 XC4.1 ; XU1.B5 108.08,145.89 107.63,145.44 107.63,145.08 107.51,144.95 107.39,144.83 107.39,144.02 106.28,142.91 106.28,139.89 108.23,137.94 108.23,125.86 105.54,123.17 105.54,104.06 104.78,103.3 103.71,103.3 v1(103.5,103.5)
  BOTTOM w0.102: v1(103.5,103.5) 103.33,103.33 101.68,103.33 100.23,101.88 85.03,101.88 76.09,92.94 72.48,92.94 70.02,90.47 67.33,90.47 65.32,88.46 65.32,87.98 v1(65.13,87.8)
EXP_TXN2: length 90.4
  TOP w0.102: v1(101.73,100.69) 101.93,100.89 101.93,101.4 102.35,101.83 104.41,101.83 106.23,103.64 106.23,122.74 108.94,125.45 108.94,138.25 107,140.18 107,141.75 107.98,142.72 107.98,143.66 108.56,144.25 108.56,144.56 109,144.99 XU1.C4 ; XC6.1 69.28,87.38 69.28,87.64 v1(69.07,87.85)
  BOTTOM w0.102: v1(69.07,87.85) 69.25,88.03 69.25,88.54 69.82,89.1 70.71,89.1 72.79,91.19 77.62,91.19 80.22,93.78 84.94,93.78 88.88,97.71 99.64,97.71 101.94,100.01 101.94,100.47 v1(101.73,100.69)
EXP_TXN3: length 85.9
  TOP w0.102: v1(73.14,87.85) 73.37,87.62 73.37,87.4 XC8.1 ; v1(97.09,95.95) 97.36,95.68 97.87,95.68 100.48,98.3 101.98,98.3 106.91,103.23 106.91,122.43 109.62,125.14 109.62,138.58 107.74,140.46 107.74,141.25 109.41,142.92 109.41,143.52 109.91,144.02 XU1.D3
  BOTTOM w0.102: v1(97.09,95.95) 96.79,95.95 96.6,96.14 89.24,96.14 85.51,92.41 81.09,92.41 77.58,88.9 73.56,88.9 73.14,88.48 v1(73.14,87.85)
EXP_TXN4: length 78.3
  TOP w0.102: v1(99.41,95.6) 99.66,95.85 99.66,96.01 100.61,96.95 101.61,96.95 107.6,102.94 107.6,122.02 110.36,124.79 110.36,142.98 XU1.E2 ; v1(79.08,87.85) 79.34,87.59 79.34,87.4 XC10.1
  BOTTOM w0.102: v1(79.08,87.85) 79.32,88.09 79.32,88.65 80.94,90.27 82.45,90.27 83.19,91.01 86.05,91.01 88.67,93.62 96.8,93.62 97.99,94.82 99.01,94.82 99.41,95.22 v1(99.41,95.6)
EXP_TXN5: length 76.6
  TOP w0.102: XC12.1 83.4,87.4 83.4,87.65 v1(83.19,87.86) ; XU1.F3 111.51,144.12 111.51,143.95 111.17,143.61 111.17,142.27 110.95,142.05 110.95,141.49 111.09,141.35 111.09,124.53 108.28,121.73 108.28,102.31 100.43,94.46 99.43,94.46 98.6,93.63 98.6,93.32 v1(98.37,93.09)
  BOTTOM w0.102: v1(98.37,93.09) 98.37,92.71 98.37,92.38 98.09,92.1 89.08,92.1 85.99,89 83.8,89 83.38,88.58 83.38,88.04 v1(83.19,87.86)
EXP_TXN6: length 73.9
  TOP w0.102: v1(108.07,99.23) 108.31,99.47 108.31,101.37 108.97,102.03 108.97,121.44 111.8,124.27 111.8,141.3 112.09,141.59 112.09,142.89 112.28,143.08 112.55,143.08 112.65,143.18 XU1.G2 ; v1(87.13,87.85) 87.33,87.65 87.33,87.39 XC14.1
  BOTTOM w0.102: v1(108.07,99.23) 108.31,98.99 108.31,98.57 108.17,98.42 106.55,98.42 105.41,97.28 105.25,97.28 98.7,90.73 89.65,90.73 87.32,88.4 87.32,88.04 v1(87.13,87.85)
EXP_TXN7: length 72.7
  TOP w0.102: v1(91.19,87.86) 91.4,87.64 91.4,87.4 XC16.1 ; v1(105.7,96.62) 105.7,97.01 105.46,97.25 105.46,97.75 106.19,98.48 108.86,98.48 109.65,99.27 109.65,121.11 112.48,123.94 112.48,141.2 112.78,141.49 112.78,142.12 113,142.35 113,142.72 113,143.75 113.21,143.95 113.42,143.95 113.57,144.1 XU1.H3
  BOTTOM w0.102: v1(105.7,96.62) 105.7,96.01 105.34,95.66 104.6,95.66 98.93,89.99 96.52,89.99 96.19,89.66 92.52,89.66 91.4,88.54 91.4,88.07 v1(91.19,87.86)
EXP_TXN8: length 149.6
  TOP w0.102: v1(105.16,92.84) 105.16,93.8 110.34,98.99 110.34,120.75 113.2,123.61 113.2,141.01 113.92,141.73 113.92,142.88 XU1.J2 ; XC113.1 61.46,26.57 61.46,26.79 69.94,35.28 78.3,35.28 93.34,50.33 93.34,68.22 94.61,69.49 94.61,76.45 93.34,77.72 93.34,79.09 92.43,80 92.43,83.41 93.47,84.45 93.47,85.8 v1(94.41,86.74)
  BOTTOM w0.102: v1(94.41,86.74) 94.54,86.61 94.97,86.61 95.96,87.6 97.19,87.6 97.52,87.93 100.06,87.93 103.44,91.31 104.61,91.31 105.33,92.03 105.33,92.66 v1(105.16,92.84)
EXP_TXN9: length 144.9
  TOP w0.102: v1(107.16,93.24) 107.4,93.48 107.4,94.83 111.03,98.46 111.03,120.37 113.88,123.23 113.88,140.7 114.74,141.56 114.74,142.15 114.83,142.24 114.83,143.79 115.31,144.27 XU1.K3 ; XC115.1 65.24,26.54 65.24,27.81 71.29,33.86 78.86,33.86 94.72,49.71 94.72,67.47 97.21,69.96 97.21,78.95 98.35,80.09 98.35,83.4 99.36,84.41 99.36,85.01 99.36,85.02 99.36,85.5 99.75,85.89 v1(99.75,86.03)
  BOTTOM w0.102: v1(99.75,86.03) 100.15,86.44 100.54,86.44 103.92,89.81 105.53,89.81 107.42,91.7 107.42,92.99 v1(107.16,93.24)
EXP_TXN10: length 141
  TOP w0.102: XC117.1 69.3,26.54 69.3,27.68 74.08,32.46 79.42,32.46 96.09,49.13 96.09,66.9 101.4,72.21 101.4,79.08 102.41,80.09 102.41,83.52 103.43,84.54 103.43,85.55 v1(103.23,85.75) ; XU1.L2 116.31,143.14 116.23,143.06 115.91,143.06 115.74,142.89 115.74,142.09 115.82,142 115.82,141.61 114.57,140.36 114.57,122.85 111.71,119.99 111.71,97.91 109.35,95.55 109.35,93.25 v1(109.32,93.22)
  BOTTOM w0.102: v1(103.23,85.75) 103.45,85.98 103.45,86.39 104.65,87.58 105.64,87.58 109.32,91.27 v1(109.32,93.22)
EXP_TXN11: length 139.1
  TOP w0.102: XC119.1 73.37,26.54 73.37,28.06 76.4,31.09 80.08,31.09 97.46,48.47 97.46,66.3 105.33,74.18 105.33,79.08 106.35,80.09 106.35,83.52 107.29,84.46 107.29,85.57 v1(107.06,85.8) ; v1(111.02,94.03) 111.28,94.29 111.28,96.51 112.4,97.63 112.4,119.66 115.25,122.52 115.25,140.07 116.51,141.33 116.51,142.09 116.66,142.24 116.66,143.93 116.89,144.15 117.02,144.15 XU1.M3
  BOTTOM w0.102: v1(107.06,85.8) 107.29,86.03 107.29,86.9 111.26,90.87 111.26,93.79 v1(111.02,94.03)
EXP_TXN12: length 134.3
  TOP w0.102: XU1.N2 117.91,143.22 117.81,143.22 117.58,142.98 117.58,141.38 115.94,139.74 115.94,122.19 113.08,119.33 113.08,97.69 113.64,97.13 113.64,94.85 v1(113.41,94.61) ; XC121.1 79.46,26.54 79.46,28.45 98.93,47.92 98.93,65.84 109.27,76.17 109.27,78.95 110.29,79.97 110.29,83.52 111.4,84.64 111.4,85.65 v1(111.2,85.85)
  BOTTOM w0.102: v1(113.41,94.61) 113.64,94.38 113.64,90.4 111.43,88.19 111.43,86.08 v1(111.2,85.85)
EXP_TXN13: length 135.4
  TOP w0.102: v1(115.56,96.01) 115.74,96.19 115.74,96.77 113.77,98.74 113.77,119 116.62,121.86 116.62,139.43 118.36,141.16 118.36,142.18 118.49,142.31 118.49,143.88 118.66,144.06 119,144.06 119.05,144.11 XU1.P3 ; XC123.1 83.4,26.54 83.4,30.45 100.3,47.35 100.3,65.21 111.93,76.83 112.39,76.83 113.41,77.85 113.41,78.99 114.43,80.01 114.43,83.47 115.36,84.4 115.36,85.63 v1(115.14,85.85)
  BOTTOM w0.102: v1(115.56,96.01) 115.56,89.45 115.37,89.26 115.37,86.08 v1(115.14,85.85)
EXP_TXN14: length 137.1
  TOP w0.102: XC125.1 87.67,26.57 87.67,32.49 101.88,46.7 101.88,64.56 112.58,75.26 115.39,75.26 117.47,77.34 117.47,78.87 118.49,79.88 118.49,83.19 119.63,84.33 119.63,85.72 v1(119.87,85.95) ; XU1.R1 119.97,142.87 119.8,143.04 119.71,143.04 119.61,142.94 119.61,141.15 117.51,139.05 117.51,121.42 114.66,118.56 114.66,99.51 117.01,97.16 117.01,96.64 118.14,95.51 118.14,94.26 v1(118.34,94.05)
  BOTTOM w0.102: v1(118.34,94.05) 118.14,93.85 118.14,91.37 119.63,89.87 119.63,86.19 v1(119.87,85.95)
EXP_TXN15: length 140.4
  TOP w0.102: v1(123.01,86.11) 123.27,85.85 123.27,84.31 122.35,83.4 122.35,79.71 121.41,78.77 121.41,77.98 117.53,74.09 113.09,74.09 103.05,64.05 103.05,46.22 91.27,34.44 91.27,26.57 XC127.1 ; XU1.T3 120.7,144.17 120.57,144.17 120.32,143.92 120.32,142.23 120.22,142.12 120.22,141.07 118,138.85 118,120.99 115.14,118.14 115.14,99.97 120.17,94.95 120.17,94.02 v1(119.93,93.79)
  BOTTOM w0.102: v1(123.01,86.11) 123.24,86.34 123.24,88.18 120.17,91.25 120.17,93.55 v1(119.93,93.79)
EXP_TXP0: length 95.4
  TOP w0.102: XU1.A5 106.72,146.63 106.58,146.63 105.73,145.78 105.73,139.71 107.75,137.69 107.75,126.29 105.06,123.6 105.06,106.73 104.55,106.22 104.19,106.22 v1(103.76,105.79) ; XC1.1 62.2,87.41 62.2,87.73 v1(62.43,87.96)
  BOTTOM w0.102: v1(62.43,87.96) 62.18,88.21 62.18,88.42 65.56,91.8 69.57,91.8 72.44,94.67 76.12,94.67 84.68,103.23 99.47,103.23 102.31,106.07 103.48,106.07 v1(103.76,105.79)
EXP_TXP1: length 93.4
  TOP w0.102: v1(65.89,87.83) 65.74,87.83 65.57,87.67 65.57,87.38 XC3.1 ; XU1.B4 108.36,145 108.36,144.86 108.31,144.81 107.65,144.81 107.59,144.75 107.59,143.93 106.48,142.82 106.48,139.97 108.43,138.02 108.43,125.77 105.74,123.08 105.74,103.97 104.87,103.1 103.73,103.1 v1(103.5,102.87)
  BOTTOM w0.102: v1(103.5,102.87) 103.24,103.12 101.76,103.12 100.31,101.68 85.12,101.68 76.17,92.74 72.57,92.74 70.1,90.27 67.41,90.27 65.52,88.38 65.52,87.97 65.66,87.83 v1(65.89,87.83)
EXP_TXP2: length 90.4
  TOP w0.102: v1(69.71,87.85) 69.48,87.62 69.48,87.4 XC5.1 ; XU1.C3 109.27,144.36 109.42,144.2 109.42,144.09 109.27,143.94 108.54,143.94 108.18,143.58 108.18,142.64 107.21,141.67 107.21,140.26 109.14,138.33 109.14,125.36 106.43,122.65 106.43,103.56 104.5,101.63 102.44,101.63 102.13,101.32 102.13,100.94 v1(102.39,100.69)
  BOTTOM w0.102: v1(102.39,100.69) 102.14,100.44 102.14,99.93 99.73,97.51 88.96,97.51 85.02,93.57 80.3,93.57 77.71,90.98 72.87,90.98 70.79,88.9 69.9,88.9 69.46,88.46 69.46,88.11 v1(69.71,87.85)
EXP_TXP3: length 85.9
  TOP w0.102: v1(96.65,95.48) 97.95,95.48 100.57,98.09 102.07,98.09 107.11,103.14 107.11,122.35 109.83,125.06 109.83,138.66 107.94,140.54 107.94,141.17 109.61,142.84 109.61,143.38 109.68,143.44 XU1.D2 ; v1(73.99,87.86) 73.66,87.86 73.57,87.77 73.57,87.38 XC7.1
  BOTTOM w0.102: v1(96.65,95.48) 96.65,95.81 96.52,95.94 89.33,95.94 85.59,92.2 81.17,92.2 77.67,88.7 73.64,88.7 73.34,88.39 73.34,88.26 73.74,87.86 v1(73.99,87.86)
EXP_TXP4: length 78.3
  TOP w0.102: v1(80.11,87.86) 79.64,87.86 79.54,87.76 79.54,87.38 XC9.1 ; XU1.E1 110.57,142.27 110.57,124.71 107.8,121.94 107.8,102.86 101.69,96.75 100.69,96.75 99.88,95.94 99.88,95.64 v1(100.05,95.48)
  BOTTOM w0.102: v1(100.05,95.48) 99.74,95.17 99.65,95.17 99.09,94.61 98.08,94.61 96.88,93.42 88.75,93.42 86.14,90.81 83.27,90.81 82.53,90.07 81.03,90.07 79.52,88.56 79.52,87.99 79.65,87.86 v1(80.11,87.86)
EXP_TXP5: length 76.5
  TOP w0.102: v1(83.84,87.89) 83.6,87.65 83.6,87.38 XC11.1 ; XU1.F2 111.74,143.61 111.66,143.69 111.53,143.69 111.37,143.53 111.37,142.19 111.15,141.97 111.15,141.57 111.29,141.43 111.29,124.45 108.49,121.64 108.49,102.23 100.52,94.26 99.52,94.26 98.81,93.55 98.81,93.14 v1(99.01,92.94)
  BOTTOM w0.102: v1(83.84,87.89) 83.58,88.14 83.58,88.49 83.88,88.8 86.07,88.8 89.17,91.9 98.18,91.9 98.58,92.3 98.58,92.68 98.84,92.94 v1(99.01,92.94)
EXP_TXP6: length 73.9
  TOP w0.102: XC13.1 87.53,87.39 87.53,87.71 87.68,87.86 v1(87.88,87.86) ; v1(108.71,99.24) 108.51,99.44 108.51,101.28 109.17,101.95 109.17,121.36 112,124.19 112,141.21 112.29,141.5 112.29,142.81 112.36,142.87 112.57,142.87 112.65,142.79 XU1.G1
  BOTTOM w0.102: v1(87.88,87.86) 87.68,87.86 87.52,88.02 87.52,88.31 89.74,90.53 98.78,90.53 105.33,97.08 105.49,97.08 106.64,98.22 108.25,98.22 108.52,98.48 108.52,99.04 v1(108.71,99.24)
EXP_TXP7: length 72.7
  TOP w0.102: XC15.1 91.61,87.38 91.61,87.67 v1(91.82,87.88) ; v1(106.22,97.03) 105.97,97.03 105.66,97.33 105.66,97.66 106.27,98.27 108.94,98.27 109.86,99.19 109.86,121.03 112.69,123.85 112.69,141.11 112.98,141.4 112.98,142.04 113.21,142.26 113.21,142.8 113.21,143.66 113.29,143.75 113.47,143.75 113.57,143.66 XU1.H2
  BOTTOM w0.102: v1(106.22,97.03) 106.22,96.55 105.9,96.22 105.9,95.93 105.43,95.45 104.68,95.45 99.02,89.79 96.6,89.79 96.27,89.46 92.61,89.46 91.6,88.45 91.6,88.1 v1(91.82,87.88)
EXP_TXP8: length 149.6
  TOP w0.102: v1(105.79,92.81) 105.36,93.24 105.36,93.72 110.54,98.9 110.54,120.67 113.4,123.52 113.4,140.92 114.12,141.65 114.12,142.8 114.21,142.88 114.37,142.88 114.48,142.77 XU1.J1 ; v1(94.41,86.11) 94.34,86.18 94.14,86.18 93.68,85.72 93.68,84.37 92.63,83.33 92.63,80.09 93.55,79.17 93.55,77.81 94.82,76.54 94.82,69.41 93.55,68.14 93.55,50.24 78.38,35.08 70.03,35.08 61.66,26.71 61.66,26.54 XC112.1
  BOTTOM w0.102: v1(105.79,92.81) 105.54,92.56 105.54,91.95 104.7,91.11 103.52,91.11 100.15,87.73 97.6,87.73 97.27,87.4 96.05,87.4 95.05,86.41 94.72,86.41 v1(94.41,86.11)
EXP_TXP9: length 144.9
  TOP w0.102: XU1.K2 115.4,143.84 115.34,143.89 115.22,143.89 115.04,143.71 115.04,142.16 114.94,142.06 114.94,141.48 114.08,140.62 114.08,123.14 111.23,120.29 111.23,98.38 107.6,94.75 107.6,93.47 v1(107.8,93.26) ; XC114.1 65.44,26.57 65.44,27.72 71.37,33.66 78.95,33.66 94.92,49.63 94.92,67.38 97.41,69.87 97.41,78.87 98.55,80.01 98.55,83.31 99.57,84.33 99.57,85.1 99.57,85.42 99.71,85.56 100.19,85.56 100.39,85.76 v1(100.39,86)
  BOTTOM w0.102: v1(100.39,86) 104,89.61 105.61,89.61 107.62,91.62 107.62,93.08 v1(107.8,93.26)
EXP_TXP10: length 141
  TOP w0.102: XC116.1 69.51,26.57 69.51,27.6 74.17,32.26 79.5,32.26 96.29,49.05 96.29,66.81 101.6,72.12 101.6,78.99 102.62,80.01 102.62,83.44 103.63,84.45 103.63,85.55 v1(103.86,85.78) ; XU1.L1 116.31,142.8 116.26,142.86 115.99,142.86 115.94,142.81 115.94,142.17 116.03,142.08 116.03,141.53 114.77,140.27 114.77,122.76 111.92,119.91 111.92,97.83 109.55,95.46 109.55,93.65 v1(109.96,93.24)
  BOTTOM w0.102: v1(109.96,93.24) 109.52,92.81 109.52,91.18 105.72,87.38 104.73,87.38 103.66,86.3 103.66,85.98 v1(103.86,85.78)
EXP_TXP11: length 139.1
  TOP w0.102: v1(111.67,94.03) 111.49,94.22 111.49,96.43 112.6,97.54 112.6,119.58 115.46,122.43 115.46,139.98 116.71,141.24 116.71,142 116.87,142.15 116.87,143.84 116.97,143.95 117.16,143.95 117.23,143.88 XU1.M2 ; XC118.1 73.57,26.57 73.57,27.98 76.48,30.89 80.16,30.89 97.66,48.39 97.66,66.22 105.54,74.09 105.54,78.99 106.55,80.01 106.55,83.44 107.49,84.38 107.49,85.57 v1(107.72,85.8)
  BOTTOM w0.102: v1(111.67,94.03) 111.47,93.83 111.47,90.79 107.49,86.82 107.49,86.03 v1(107.72,85.8)
EXP_TXP12: length 134.3
  TOP w0.102: XU1.N1 118.14,142.92 118.05,143.01 117.9,143.01 117.78,142.9 117.78,141.3 116.14,139.65 116.14,122.1 113.29,119.25 113.29,97.77 113.84,97.21 113.84,94.85 v1(114.05,94.64) ; XC120.1 79.67,26.57 79.67,28.37 99.14,47.84 99.14,65.75 109.47,76.09 109.47,78.87 110.49,79.88 110.49,83.44 111.61,84.56 111.61,85.62 v1(111.84,85.85)
  BOTTOM w0.102: v1(111.84,85.85) 111.64,86.05 111.64,88.11 113.84,90.31 113.84,94.43 v1(114.05,94.64)
EXP_TXP13: length 135.3
  TOP w0.102: XC122.1 83.6,26.57 83.6,30.37 100.51,47.27 100.51,65.13 112.01,76.63 112.48,76.63 113.61,77.77 113.61,78.91 114.63,79.93 114.63,83.39 115.56,84.32 115.56,85.64 v1(115.77,85.85) ; v1(116.2,96.01) 115.94,96.27 115.94,96.86 113.97,98.83 113.97,118.92 116.83,121.77 116.83,139.35 118.56,141.08 118.56,142.1 118.69,142.23 118.69,143.8 118.75,143.86 118.99,143.86 119.05,143.79 XU1.P2
  BOTTOM w0.102: v1(115.77,85.85) 115.57,86.06 115.57,89.17 115.76,89.36 115.76,95.57 v1(116.2,96.01)
EXP_TXP14: length 137.1
  TOP w0.102: XC124.1 87.46,26.54 87.46,32.57 101.68,46.79 101.68,64.64 112.5,75.46 115.31,75.46 117.27,77.43 117.27,78.95 118.29,79.97 118.29,83.27 119.43,84.41 119.43,85.72 v1(119.2,85.95) ; XU1.R2 119.77,143.25 119.63,143.25 119.41,143.02 119.41,141.23 117.31,139.14 117.31,121.5 114.46,118.65 114.46,99.43 116.8,97.08 116.8,96.56 117.93,95.43 117.93,94.28 v1(117.7,94.05)
  BOTTOM w0.102: v1(119.2,85.95) 119.43,86.19 119.43,89.79 117.94,91.28 117.94,93.82 v1(117.7,94.05)
EXP_TXP15: length 140.4
  TOP w0.102: XU1.T2 120.88,143.86 120.77,143.97 120.66,143.97 120.53,143.84 120.53,142.14 120.42,142.04 120.42,140.99 118.2,138.76 118.2,120.91 115.34,118.05 115.34,100.06 120.37,95.03 120.37,94.01 v1(120.6,93.78) ; v1(123.67,86.13) 123.47,85.93 123.47,84.23 122.56,83.31 122.56,79.63 121.62,78.69 121.62,77.89 117.61,73.89 113.17,73.89 103.25,63.97 103.25,46.13 91.48,34.36 91.48,26.54 XC126.1
  BOTTOM w0.102: v1(123.67,86.13) 123.44,86.36 123.44,88.27 120.37,91.34 120.37,93.55 v1(120.6,93.78)
F1_U3_SENSE#: length 138.4
  TOP w0.102: v1(239.78,43.92) 239.32,43.47 239.32,42.9 239.5,42.72 239.5,40.77 239.1,40.37 238.37,40.37 237.46,41.27 226.56,41.27 224.18,43.65 224.18,44.68 221.82,47.04 221.82,48.96 220.41,50.37 214.95,50.37 212.18,53.14 209.8,53.14 208.53,54.41 v1(202.59,54.41) ; v1(192.86,56.25) 193.27,55.84 193.4,55.84 SR671.2 ; UR69748.2 237.88,89.9 v1(237.85,89.94) ; PCH.AC33 175.94,51.74 v1(175.79,51.89)
  BOTTOM w0.089: 176.04,52.13 v1(175.79,51.89)
  BOTTOM w0.102: 176.04,52.13 176.39,52.48 180.6,52.48 181.95,53.84 183.91,53.84 184.82,54.75 188.88,54.75 189.73,53.9 191.15,53.9 v2(191.8,54.56) 192.37,55.12 192.37,55.76 v1(192.86,56.25) 193.55,56.25 194.53,55.27 201.73,55.27 v1(202.59,54.41) ; v1(237.85,89.94) 234.06,89.94 232.79,88.67 232.79,87.05 229.26,83.52 229.26,76.61 234.84,71.02 234.84,67.79 235.48,67.16 237.03,67.16 240.04,64.15 240.04,44.19 v1(239.78,43.92)
F2_U3_SENSE#: length 181.8
  TOP w0.089: 184.02,53.81 184.02,53.54 182.54,52.06 180.98,52.06 PCH.AA43
  TOP w0.102: v1(237.06,137.71) UR69747.2 ; SR667.2 v1(195.5,56.21) 195.5,56.36 194.92,56.95 187.16,56.95 184.02,53.81 ; v1(202.59,55.09) 202.77,54.91 208.36,54.91 209.92,53.35 212.27,53.35 215.03,50.6 220.49,50.6 222.03,49.05 222.03,47.13 224.4,44.77 224.4,43.74 226.65,41.49 237.55,41.49 238.46,40.59 238.99,40.59 239.27,40.87 239.27,42.57 239.05,42.79 239.05,44 239.5,44.45 v1(239.5,44.65)
  BOTTOM w0.102: v1(195.5,56.21) 195.83,55.88 v2(198.53,55.88) 201.8,55.88 v1(202.59,55.09) ; v1(237.06,137.71) 237.25,137.71 237.99,136.97 237.99,112.56 238.26,112.28 238.26,91.93 237.44,91.11 234.92,91.11 232.56,88.75 232.56,87.12 229.03,83.59 229.03,75.56 234.63,69.97 234.63,65 235.75,63.88 236.72,63.88 239.83,60.78 239.83,44.98 v1(239.5,44.65)
