# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Text on the board (continued)
TOP: list("[Physical] TOP" "80.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DM_B_C (<uTiL>cId5037<uTiL>.4) (421.39 6015.83)" "[SmdPin] U2DM_B_C (<uTiL>cId5036<uTiL>.4) (423.36 6017.8)" list(423.360000 6017.800000) nil)@@@list("amy_chou" "2017/07/21 16:09:42" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:20" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "193.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DP_B_C (<uTiL>cId5037<uTiL>.1) (421.39 5994.17)" "[SmdPin] U2DP_B_C (<uTiL>cId5036<uTiL>.2) (423.36 5992.2)" list(423.360000 5992.200000) nil)@@@list("amy_chou" "2017/07/21 16:08:36" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "276.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXP1_R (<uTiL>cId5394<uTiL>.4) (425.36 5860.8)" "[SmdPin] USB3P1_TXP1_R (<uTiL>cId5417<uTiL>.4) (423.39 5858.83)" list(423.390000 5858.830000) nil)@@@list("amy_chou" "2017/07/21 16:08:15" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "141.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXN1_R (<uTiL>cId5417<uTiL>.1) (423.39 5837.17)" "[SmdPin] USB3P1_TXN1_R (<uTiL>cId5394<uTiL>.2) (425.36 5835.2)" list(425.360000 5835.200000) nil)@@@list("amy_chou" "2017/07/21 16:08:54" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:09" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "81.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DM_B (<uTiL>cId5037<uTiL>.3) (470.61 6015.83)" "[SmdPin] U2DM_B (<uTiL>cId5036<uTiL>.3) (468.64 6017.8)" list(468.640000 6017.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:36" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:21" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "138.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DP_B (<uTiL>cId5037<uTiL>.2) (470.61 5994.17)" "[SmdPin] U2DP_B (<uTiL>cId5036<uTiL>.1) (468.64 5992.2)" list(468.640000 5992.200000) nil)@@@list("amy_chou" "2017/07/21 16:09:42" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:07" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "82.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXP1_CMC (<uTiL>cId5417<uTiL>.3) (472.61 5858.83)" "[SmdPin] USB3P1_TXP1_CMC (<uTiL>cId5394<uTiL>.3) (470.64 5860.8)" list(470.640000 5860.800000) nil)@@@list("amy_chou" "2017/07/21 16:09:26" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:21" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "280.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXN1_CMC (<uTiL>cId5394<uTiL>.1) (470.64 5835.2)" "[SmdPin] USB3P1_TXN1_CMC (<uTiL>cId5417<uTiL>.2) (472.61 5837.17)" list(472.610000 5837.170000) nil)@@@list("amy_chou" "2017/07/21 16:09:45" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:59" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "274.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXP2_R (<uTiL>cId5396<uTiL>.4) (476.53 5692.8)" "[SmdPin] USB3P1_TXP2_R (<uTiL>cId5419<uTiL>.4) (474.56 5690.83)" list(474.560000 5690.830000) nil)@@@list("amy_chou" "2017/07/21 16:09:25" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:50" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "95.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXN2_R (<uTiL>cId5396<uTiL>.2) (476.53 5667.2)" "[SmdPin] USB3P1_TXN2_R (<uTiL>cId5419<uTiL>.1) (474.56 5669.17)" list(474.560000 5669.170000) nil)@@@list("amy_chou" "2017/07/21 16:09:44" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:34" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "94.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXP2_CMC (<uTiL>cId5396<uTiL>.3) (521.81 5692.8)" "[SmdPin] USB3P1_TXP2_CMC (<uTiL>cId5419<uTiL>.3) (523.78 5690.83)" list(523.780000 5690.830000) nil)@@@list("amy_chou" "2017/07/21 16:09:45" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:33" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "189.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3P1_TXN2_CMC (<uTiL>cId5396<uTiL>.1) (521.81 5667.2)" "[SmdPin] USB3P1_TXN2_CMC (<uTiL>cId5419<uTiL>.2) (523.78 5669.17)" list(523.780000 5669.170000) nil)@@@list("amy_chou" "2017/07/21 16:08:59" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "288.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DP_A+ (<uTiL>cId3429<uTiL>.2) (527.39 4723.83)" "[SmdPin] U2DP_A+ (<uTiL>cId2935<uTiL>.1) (529.36 4725.8)" list(529.360000 4725.800000) nil)@@@list("amy_chou" "2017/07/21 16:10:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "289.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DM_A- (<uTiL>cId3429<uTiL>.3) (527.39 4702.17)" "[SmdPin] U2DM_A- (<uTiL>cId2935<uTiL>.3) (529.36 4700.2)" list(529.360000 4700.200000) nil)@@@list("amy_chou" "2017/07/21 16:14:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:09" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "57.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP12+ (<uTiL>cId490<uTiL>.2) (527.43 4664.83)" "[SmdPin] LP12+ (<uTiL>cId464<uTiL>.1) (529.4 4666.8)" list(529.400000 4666.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:16" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:59" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "285.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP12- (<uTiL>cId490<uTiL>.3) (527.43 4643.17)" "[SmdPin] LP12- (<uTiL>cId464<uTiL>.3) (529.4 4641.2)" list(529.400000 4641.200000) nil)@@@list("amy_chou" "2017/07/21 16:09:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:04" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "201.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DP_A (<uTiL>cId3429<uTiL>.1) (576.61 4723.83)" "[SmdPin] U2DP_A (<uTiL>cId2935<uTiL>.2) (574.64 4725.8)" list(574.640000 4725.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:12" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "92.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U2DM_A (<uTiL>cId3429<uTiL>.4) (576.61 4702.17)" "[SmdPin] U2DM_A (<uTiL>cId2935<uTiL>.4) (574.64 4700.2)" list(574.640000 4700.200000) nil)@@@list("amy_chou" "2017/07/21 16:08:58" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:32" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "200.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP12 (<uTiL>cId490<uTiL>.1) (576.65 4664.83)" "[SmdPin] USBP12 (<uTiL>cId464<uTiL>.2) (574.68 4666.8)" list(574.680000 4666.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:36" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:11" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "64.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN12 (<uTiL>cId464<uTiL>.4) (574.68 4641.2)" "[SmdPin] USBN12 (<uTiL>cId490<uTiL>.4) (576.65 4643.17)" list(576.650000 4643.170000) nil)@@@list("amy_chou" "2017/07/21 16:10:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:07" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "176.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4482<uTiL>.36) (699.5 5865.5)" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" list(699.500000 5865.500000) nil)@@@list("amy_chou" "2017/07/21 16:08:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:50" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "182.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4482<uTiL>.35) (699.5 5825.0)" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" list(699.500000 5825.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:55" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "181.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4482<uTiL>.34) (699.5 5784.5)" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" list(699.500000 5784.500000) nil)@@@list("amy_chou" "2017/07/21 16:08:16" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "177.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4482<uTiL>.38) (740.0 5865.5)" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" list(740.000000 5865.500000) nil)@@@list("amy_chou" "2017/07/21 16:08:17" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:51" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "264.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" "[ThruPin] GND (<uTiL>cId4482<uTiL>.37) (740.0 5784.5)" list(740.000000 5784.500000) nil)@@@list("amy_chou" "2017/07/21 16:08:16" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:37" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "178.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4482<uTiL>.41) (780.5 5865.5)" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" list(780.500000 5865.500000) nil)@@@list("amy_chou" "2017/07/21 16:10:18" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:51" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "179.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4482<uTiL>.40) (780.5 5825.0)" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" list(780.500000 5825.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:52" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "180.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4482<uTiL>.39) (780.5 5784.5)" "[SmdPin] GND (<uTiL>cId4482<uTiL>.33) (740.0 5825.0)" list(780.500000 5784.500000) nil)@@@list("amy_chou" "2017/07/21 16:08:52" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:53" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "286.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN10 (<uTiL>cId509<uTiL>.4) (836.21 4588.39)" "[SmdPin] USBN10 (<uTiL>cId480<uTiL>.4) (834.24 4590.36)" list(834.240000 4590.360000) nil)@@@list("amy_chou" "2017/07/21 16:09:41" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "271.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP10- (<uTiL>cId480<uTiL>.3) (834.24 4635.64)" "[SmdPin] LP10- (<uTiL>cId509<uTiL>.3) (836.21 4637.61)" list(836.210000 4637.610000) nil)@@@list("amy_chou" "2017/07/21 16:09:27" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:46" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "265.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP14+ (<uTiL>cId2936<uTiL>.1) (842.36 4524.8)" "[SmdPin] LP14+ (<uTiL>cId4728<uTiL>.2) (840.39 4522.83)" list(840.390000 4522.830000) nil)@@@list("amy_chou" "2017/07/21 16:09:41" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:38" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "125.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP14- (<uTiL>cId4728<uTiL>.3) (840.39 4501.17)" "[SmdPin] LP14- (<uTiL>cId2936<uTiL>.3) (842.36 4499.2)" list(842.360000 4499.200000) nil)@@@list("amy_chou" "2017/07/21 16:09:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:57" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "287.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP10+ (<uTiL>cId509<uTiL>.2) (857.87 4637.61)" "[SmdPin] LP10+ (<uTiL>cId480<uTiL>.1) (859.84 4635.64)" list(859.840000 4635.640000) nil)@@@list("amy_chou" "2017/07/21 16:10:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "52.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP10 (<uTiL>cId509<uTiL>.1) (857.87 4588.39)" "[SmdPin] USBP10 (<uTiL>cId480<uTiL>.2) (859.84 4590.36)" list(859.840000 4590.360000) nil)@@@list("amy_chou" "2017/07/21 16:09:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "93.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP14 (<uTiL>cId4728<uTiL>.1) (889.61 4522.83)" "[SmdPin] USBP14 (<uTiL>cId2936<uTiL>.2) (887.64 4524.8)" list(887.640000 4524.800000) nil)@@@list("amy_chou" "2017/07/21 16:09:41" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:32" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "202.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN14 (<uTiL>cId4728<uTiL>.4) (889.61 4501.17)" "[SmdPin] USBN14 (<uTiL>cId2936<uTiL>.4) (887.64 4499.2)" list(887.640000 4499.200000) nil)@@@list("amy_chou" "2017/07/21 16:09:28" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:12" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "275.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_N7_C (<uTiL>cId5400<uTiL>.3) (1018.36 5232.59)" "[SmdPin] USB3_TX_N7_C (<uTiL>cId5422<uTiL>.3) (1016.39 5234.56)" list(1016.390000 5234.560000) nil)@@@list("amy_chou" "2017/07/21 16:09:43" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:53" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "203.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_P6_C (<uTiL>cId5399<uTiL>.1) (1018.36 5196.55)" "[SmdPin] USB3_TX_P6_C (<uTiL>cId5421<uTiL>.2) (1016.39 5194.58)" list(1016.390000 5194.580000) nil)@@@list("amy_chou" "2017/07/21 16:09:24" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:13" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "204.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_N6_C (<uTiL>cId5399<uTiL>.3) (1018.36 5170.95)" "[SmdPin] USB3_TX_N6_C (<uTiL>cId5421<uTiL>.3) (1016.39 5172.92)" list(1016.390000 5172.920000) nil)@@@list("amy_chou" "2017/07/21 16:09:44" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:14" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "292.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_P5_C (<uTiL>cId5404<uTiL>.1) (1018.36 5134.75)" "[SmdPin] USB3_TX_P5_C (<uTiL>cId5426<uTiL>.2) (1016.39 5132.78)" list(1016.390000 5132.780000) nil)@@@list("amy_chou" "2017/07/21 16:09:43" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:13" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "97.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_N5_C (<uTiL>cId5404<uTiL>.3) (1018.36 5109.15)" "[SmdPin] USB3_TX_N5_C (<uTiL>cId5426<uTiL>.3) (1016.39 5111.12)" list(1016.390000 5111.120000) nil)@@@list("amy_chou" "2017/07/21 16:09:30" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:36" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "140.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_P7_C (<uTiL>cId5422<uTiL>.2) (1016.39 5256.22)" "[SmdPin] USB3_TX_P7_C (<uTiL>cId5400<uTiL>.1) (1018.36 5258.19)" list(1018.360000 5258.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "267.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP3- (<uTiL>cId4262<uTiL>.4) (1052.36 7319.8)" "[SmdPin] LP3- (<uTiL>cId4307<uTiL>.4) (1050.39 7317.83)" list(1050.390000 7317.830000) nil)@@@list("amy_chou" "2017/07/21 16:08:53" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:41" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "184.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP4- (<uTiL>cId4261<uTiL>.4) (1052.46 7259.3)" "[SmdPin] LP4- (<uTiL>cId4306<uTiL>.4) (1050.49 7257.33)" list(1050.490000 7257.330000) nil)@@@list("amy_chou" "2017/07/21 16:08:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:57" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "268.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP1+ (<uTiL>cId4263<uTiL>.2) (1053.36 7164.2)" "[SmdPin] LP1+ (<uTiL>cId4308<uTiL>.1) (1051.39 7166.17)" list(1051.390000 7166.170000) nil)@@@list("amy_chou" "2017/07/21 16:08:35" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:42" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "137.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP3+ (<uTiL>cId4307<uTiL>.1) (1050.39 7296.17)" "[SmdPin] LP3+ (<uTiL>cId4262<uTiL>.2) (1052.36 7294.2)" list(1052.360000 7294.200000) nil)@@@list("amy_chou" "2017/07/21 16:08:57" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "136.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP4+ (<uTiL>cId4306<uTiL>.1) (1050.49 7235.67)" "[SmdPin] LP4+ (<uTiL>cId4261<uTiL>.2) (1052.46 7233.7)" list(1052.460000 7233.700000) nil)@@@list("amy_chou" "2017/07/21 16:09:40" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "284.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP1- (<uTiL>cId4308<uTiL>.4) (1051.39 7187.83)" "[SmdPin] LP1- (<uTiL>cId4263<uTiL>.4) (1053.36 7189.8)" list(1053.360000 7189.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:24" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:03" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "69.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP2- (<uTiL>cId4309<uTiL>.4) (1051.39 7128.83)" "[SmdPin] LP2- (<uTiL>cId4264<uTiL>.4) (1053.36 7130.8)" list(1053.360000 7130.800000) nil)@@@list("amy_chou" "2017/07/21 16:13:55" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:11" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "91.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP2+ (<uTiL>cId4309<uTiL>.1) (1051.39 7107.17)" "[SmdPin] LP2+ (<uTiL>cId4264<uTiL>.2) (1053.36 7105.2)" list(1053.360000 7105.200000) nil)@@@list("amy_chou" "2017/07/21 16:09:39" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:31" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "139.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_P5_CMC (<uTiL>cId5426<uTiL>.1) (1065.61 5132.78)" "[SmdPin] USB3_TX_P5_CMC (<uTiL>cId5404<uTiL>.2) (1063.64 5134.75)" list(1063.640000 5134.750000) nil)@@@list("amy_chou" "2017/07/21 16:08:37" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "273.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U3TXP_A_CMC (<uTiL>cId5406<uTiL>.2) (1062.77 5448.24)" "[SmdPin] U3TXP_A_CMC (<uTiL>cId5428<uTiL>.1) (1064.74 5450.21)" list(1064.740000 5450.210000) nil)@@@list("amy_chou" "2017/07/21 16:08:59" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:49" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "70.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U3TXP_AMC (<uTiL>cId5406<uTiL>.1) (1062.77 5402.96)" "[SmdPin] U3TXP_AMC (<uTiL>cId5428<uTiL>.2) (1064.74 5400.99)" list(1064.740000 5400.990000) nil)@@@list("amy_chou" "2017/07/21 16:09:24" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:12" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "190.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_P7_CMC (<uTiL>cId5400<uTiL>.2) (1063.64 5258.19)" "[SmdPin] USB3_TX_P7_CMC (<uTiL>cId5422<uTiL>.1) (1065.61 5256.22)" list(1065.610000 5256.220000) nil)@@@list("amy_chou" "2017/07/21 16:09:28" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:03" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "127.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_N7_CMC (<uTiL>cId5400<uTiL>.4) (1063.64 5232.59)" "[SmdPin] USB3_TX_N7_CMC (<uTiL>cId5422<uTiL>.4) (1065.61 5234.56)" list(1065.610000 5234.560000) nil)@@@list("amy_chou" "2017/07/21 16:14:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:59" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "126.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_P6_CMC (<uTiL>cId5399<uTiL>.2) (1063.64 5196.55)" "[SmdPin] USB3_TX_P6_CMC (<uTiL>cId5421<uTiL>.1) (1065.61 5194.58)" list(1065.610000 5194.580000) nil)@@@list("amy_chou" "2017/07/21 16:09:44" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:58" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "290.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_N6_CMC (<uTiL>cId5399<uTiL>.4) (1063.64 5170.95)" "[SmdPin] USB3_TX_N6_CMC (<uTiL>cId5421<uTiL>.4) (1065.61 5172.92)" list(1065.610000 5172.920000) nil)@@@list("amy_chou" "2017/07/21 16:10:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:10" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "272.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_TX_N5_CMC (<uTiL>cId5404<uTiL>.4) (1063.64 5109.15)" "[SmdPin] USB3_TX_N5_CMC (<uTiL>cId5426<uTiL>.4) (1065.61 5111.12)" list(1065.610000 5111.120000) nil)@@@list("amy_chou" "2017/07/21 16:09:29" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:47" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "96.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U3TXN_A_CMC (<uTiL>cId5406<uTiL>.4) (1088.37 5448.24)" "[SmdPin] U3TXN_A_CMC (<uTiL>cId5428<uTiL>.4) (1086.4 5450.21)" list(1086.400000 5450.210000) nil)@@@list("amy_chou" "2017/07/21 16:08:54" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:35" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "122.Pad/Pad Direct Connect" "NOT_ALLOWED [80OHM(DP_4.5/4.5/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] U3TXN_AMC (<uTiL>cId5406<uTiL>.3) (1088.37 5402.96)" "[SmdPin] U3TXN_AMC (<uTiL>cId5428<uTiL>.3) (1086.4 5400.99)" list(1086.400000 5400.990000) nil)@@@list("amy_chou" "2017/07/21 16:14:12" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:55" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "79.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN4 (<uTiL>cId4306<uTiL>.3) (1099.71 7257.33)" "[SmdPin] USBN4 (<uTiL>cId4261<uTiL>.3) (1097.74 7259.3)" list(1097.740000 7259.300000) nil)@@@list("amy_chou" "2017/07/21 16:08:58" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "199.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP4 (<uTiL>cId4306<uTiL>.2) (1099.71 7235.67)" "[SmdPin] USBP4 (<uTiL>cId4261<uTiL>.1) (1097.74 7233.7)" list(1097.740000 7233.700000) nil)@@@list("amy_chou" "2017/07/21 16:09:40" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:10" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "135.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN1 (<uTiL>cId4308<uTiL>.3) (1100.61 7187.83)" "[SmdPin] USBN1 (<uTiL>cId4263<uTiL>.3) (1098.64 7189.8)" list(1098.640000 7189.800000) nil)@@@list("amy_chou" "2017/07/21 16:09:27" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "66.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN3 (<uTiL>cId4262<uTiL>.3) (1097.64 7319.8)" "[SmdPin] USBN3 (<uTiL>cId4307<uTiL>.3) (1099.61 7317.83)" list(1099.610000 7317.830000) nil)@@@list("amy_chou" "2017/07/21 16:08:25" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "185.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP3 (<uTiL>cId4262<uTiL>.1) (1097.64 7294.2)" "[SmdPin] USBP3 (<uTiL>cId4307<uTiL>.2) (1099.61 7296.17)" list(1099.610000 7296.170000) nil)@@@list("amy_chou" "2017/07/21 16:10:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:58" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "120.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP1 (<uTiL>cId4263<uTiL>.1) (1098.64 7164.2)" "[SmdPin] USBP1 (<uTiL>cId4308<uTiL>.2) (1100.61 7166.17)" list(1100.610000 7166.170000) nil)@@@list("amy_chou" "2017/07/21 16:09:38" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "186.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN2 (<uTiL>cId4264<uTiL>.3) (1098.64 7130.8)" "[SmdPin] USBN2 (<uTiL>cId4309<uTiL>.3) (1100.61 7128.83)" list(1100.610000 7128.830000) nil)@@@list("amy_chou" "2017/07/21 16:08:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:59" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "121.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP2 (<uTiL>cId4264<uTiL>.1) (1098.64 7105.2)" "[SmdPin] USBP2 (<uTiL>cId4309<uTiL>.2) (1100.61 7107.17)" list(1100.610000 7107.170000) nil)@@@list("amy_chou" "2017/07/21 16:09:39" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:55" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "291.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP6- (<uTiL>cId492<uTiL>.4) (1171.39 7767.83)" "[SmdPin] LP6- (<uTiL>cId3666<uTiL>.4) (1173.36 7769.8)" list(1173.360000 7769.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:34" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:12" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "78.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP6+ (<uTiL>cId492<uTiL>.1) (1171.39 7746.17)" "[SmdPin] LP6+ (<uTiL>cId3666<uTiL>.2) (1173.36 7744.2)" list(1173.360000 7744.200000) nil)@@@list("amy_chou" "2017/07/21 16:09:29" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:18" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "134.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP5- (<uTiL>cId491<uTiL>.4) (1171.39 7707.83)" "[SmdPin] LP5- (<uTiL>cId2940<uTiL>.4) (1173.36 7709.8)" list(1173.360000 7709.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:34" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:04" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "207.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP5+ (<uTiL>cId491<uTiL>.1) (1171.39 7686.17)" "[SmdPin] LP5+ (<uTiL>cId2940<uTiL>.2) (1173.36 7684.2)" list(1173.360000 7684.200000) nil)@@@list("amy_chou" "2017/07/21 16:14:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:16" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "205.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN6 (<uTiL>cId492<uTiL>.3) (1220.61 7767.83)" "[SmdPin] USBN6 (<uTiL>cId3666<uTiL>.3) (1218.64 7769.8)" list(1218.640000 7769.800000) nil)@@@list("amy_chou" "2017/07/21 16:08:35" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:15" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "206.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP6 (<uTiL>cId492<uTiL>.2) (1220.61 7746.17)" "[SmdPin] USBP6 (<uTiL>cId3666<uTiL>.1) (1218.64 7744.2)" list(1218.640000 7744.200000) nil)@@@list("amy_chou" "2017/07/21 16:08:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:15" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "293.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN5 (<uTiL>cId491<uTiL>.3) (1220.61 7707.83)" "[SmdPin] USBN5 (<uTiL>cId2940<uTiL>.3) (1218.64 7709.8)" list(1218.640000 7709.800000) nil)@@@list("amy_chou" "2017/07/21 16:09:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:14" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "71.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP5 (<uTiL>cId491<uTiL>.2) (1220.61 7686.17)" "[SmdPin] USBP5 (<uTiL>cId2940<uTiL>.1) (1218.64 7684.2)" list(1218.640000 7684.200000) nil)@@@list("amy_chou" "2017/07/21 16:09:38" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:13" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "17.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruVia] GND (VIA20D10A28) (1318.0 8548.0)" list(1318.000000 8548.000000) nil)@@@list("amy_chou" "2017/07/21 16:14:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "128.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruVia] GND (VIA20D10A28) (1318.0 8489.0)" list(1318.000000 8489.000000) nil)@@@list("amy_chou" "2017/07/21 16:08:59" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "64.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruVia] GND (VIA20D10A28) (1318.0 8430.0)" list(1318.000000 8430.000000) nil)@@@list("amy_chou" "2017/07/21 16:08:33" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "59.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3963<uTiL>.50) (1318.34 8547.66)" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" list(1318.340000 8547.660000) nil)@@@list("amy_chou" "2017/07/24 12:18:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:00" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "58.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3963<uTiL>.47) (1318.34 8489.0)" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" list(1318.340000 8489.000000) nil)@@@list("amy_chou" "2017/07/24 12:18:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:59" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "77.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruPin] GND (<uTiL>cId3963<uTiL>.44) (1318.34 8430.34)" list(1318.340000 8430.340000) nil)@@@list("amy_chou" "2017/07/24 12:18:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:18" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "168.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.69) (1358.89 5772.67)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1358.890000 5772.670000) nil)@@@list("amy_chou" "2017/07/21 16:09:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:38" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "174.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.68) (1358.89 5713.62)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1358.890000 5713.620000) nil)@@@list("amy_chou" "2017/07/21 16:10:18" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:48" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "173.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.67) (1358.89 5654.56)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1358.890000 5654.560000) nil)@@@list("amy_chou" "2017/07/21 16:08:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:48" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "175.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" "[ThruPin] GND (<uTiL>cId3455<uTiL>.66) (1358.89 5595.51)" list(1358.890000 5595.510000) nil)@@@list("amy_chou" "2017/07/21 16:08:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:49" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "74.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruPin] GND (<uTiL>cId3963<uTiL>.49) (1377.0 8547.66)" list(1377.000000 8547.660000) nil)@@@list("amy_chou" "2017/07/24 12:18:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:15" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "136.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruVia] GND (VIA20D10A28) (1377.0 8547.5)" list(1377.000000 8547.500000) nil)@@@list("amy_chou" "2017/07/21 16:09:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "36.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[ThruVia] GND (VIA20D10A28) (1377.0 8489.0)" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" list(1377.000000 8489.000000) nil)@@@list("amy_chou" "2017/07/21 16:08:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "72.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruPin] GND (<uTiL>cId3963<uTiL>.46) (1377.0 8489.0)" list(1377.000000 8489.000000) nil)@@@list("amy_chou" "2017/07/24 12:18:26" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:13" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "216.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruVia] GND (VIA20D10A28) (1377.0 8430.5)" list(1377.000000 8430.500000) nil)@@@list("amy_chou" "2017/07/21 16:09:36" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "73.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruPin] GND (<uTiL>cId3963<uTiL>.43) (1377.0 8430.34)" list(1377.000000 8430.340000) nil)@@@list("amy_chou" "2017/07/24 12:18:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:14" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "169.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.71) (1417.94 5772.67)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1417.940000 5772.670000) nil)@@@list("amy_chou" "2017/07/21 16:08:18" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:44" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "263.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" "[ThruPin] GND (<uTiL>cId3455<uTiL>.70) (1417.94 5595.51)" list(1417.940000 5595.510000) nil)@@@list("amy_chou" "2017/07/21 16:08:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:35" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "129.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruVia] GND (VIA20D10A28) (1435.5 8547.5)" list(1435.500000 8547.500000) nil)@@@list("amy_chou" "2017/07/21 16:09:00" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "37.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[ThruVia] GND (VIA20D10A28) (1435.5 8489.0)" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" list(1435.500000 8489.000000) nil)@@@list("amy_chou" "2017/07/21 16:08:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "60.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3963<uTiL>.48) (1435.66 8547.66)" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" list(1435.660000 8547.660000) nil)@@@list("amy_chou" "2017/07/24 12:18:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:01" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "76.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruPin] GND (<uTiL>cId3963<uTiL>.45) (1435.66 8489.0)" list(1435.660000 8489.000000) nil)@@@list("amy_chou" "2017/07/24 12:18:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:17" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "75.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruPin] GND (<uTiL>cId3963<uTiL>.42) (1435.66 8430.34)" list(1435.660000 8430.340000) nil)@@@list("amy_chou" "2017/07/24 12:18:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:16" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "217.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "VIAS_PINS_ONLY" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3963<uTiL>.41) (1377.0 8489.0)" "[ThruVia] GND (VIA20D10A28) (1436.0 8430.0)" list(1436.000000 8430.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:37" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@nil | list("[Physical] TOP" "262.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" "[ThruPin] GND (<uTiL>cId3455<uTiL>.73) (1477.0 5772.67)" list(1477.000000 5772.670000) nil)@@@list("amy_chou" "2017/07/21 16:08:17" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:34" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "170.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.72) (1477.0 5595.51)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1477.000000 5595.510000) nil)@@@list("amy_chou" "2017/07/21 16:08:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:45" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "167.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.77) (1536.05 5772.67)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1536.050000 5772.670000) nil)@@@list("amy_chou" "2017/07/21 16:08:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:37" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "171.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.76) (1536.05 5713.62)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1536.050000 5713.620000) nil)@@@list("amy_chou" "2017/07/21 16:10:17" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:46" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "172.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3455<uTiL>.75) (1536.05 5654.56)" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" list(1536.050000 5654.560000) nil)@@@list("amy_chou" "2017/07/21 16:08:18" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:47" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "261.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3455<uTiL>.65) (1447.47 5684.09)" "[ThruPin] GND (<uTiL>cId3455<uTiL>.74) (1536.05 5595.51)" list(1536.050000 5595.510000) nil)@@@list("amy_chou" "2017/07/21 16:08:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:33" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "314.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.6) (2156.97 6454.54)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2156.970000 6454.540000) nil)@@@list("amy_chou" "2017/07/21 16:14:04" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:38" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "320.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.9) (2156.97 6371.87)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2156.970000 6371.870000) nil)@@@list("amy_chou" "2017/07/21 16:13:57" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:45" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "317.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.12) (2156.97 6289.19)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2156.970000 6289.190000) nil)@@@list("amy_chou" "2017/07/21 16:13:56" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:41" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "332.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.6) (2156.97 5755.54)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2156.970000 5755.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:27" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:38" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "338.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.9) (2156.97 5672.87)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2156.970000 5672.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:29" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:50" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "335.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.12) (2156.97 5590.19)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2156.970000 5590.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:43" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "259.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.6) (2157.45 7838.54)" list(2157.450000 7838.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:30" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "162.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.9) (2157.45 7755.87)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" list(2157.450000 7755.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:08" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:33" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "260.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.12) (2157.45 7673.19)" list(2157.450000 7673.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:31" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "216.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.6) (2157.45 7143.54)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2157.450000 7143.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:23" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "213.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.9) (2157.45 7060.87)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2157.450000 7060.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:21" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "210.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.12) (2157.45 6978.19)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2157.450000 6978.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:17" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:18" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "313.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.7) (2234.53 6454.54)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2234.530000 6454.540000) nil)@@@list("amy_chou" "2017/07/21 16:14:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:37" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "319.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.10) (2234.53 6371.87)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2234.530000 6371.870000) nil)@@@list("amy_chou" "2017/07/21 16:14:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:44" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "316.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.13) (2234.53 6289.19)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2234.530000 6289.190000) nil)@@@list("amy_chou" "2017/07/21 16:14:04" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:40" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "331.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.7) (2234.53 5755.54)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2234.530000 5755.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:15" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:37" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "337.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.10) (2234.53 5672.87)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2234.530000 5672.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:05" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:48" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "334.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.13) (2234.53 5590.19)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2234.530000 5590.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:28" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:42" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "164.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.7) (2235.01 7838.54)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" list(2235.010000 7838.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:35" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "161.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.10) (2235.01 7755.87)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" list(2235.010000 7755.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:08" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:33" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "166.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.13) (2235.01 7673.19)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" list(2235.010000 7673.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:36" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "215.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.7) (2235.01 7143.54)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2235.010000 7143.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:18" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "212.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.10) (2235.01 7060.87)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2235.010000 7060.870000) nil)@@@list("amy_chou" "2017/07/21 16:09:17" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:20" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "209.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.13) (2235.01 6978.19)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2235.010000 6978.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:18" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "381.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.6) (2295.45 8144.54)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2295.450000 8144.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:44" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "380.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.9) (2295.45 8061.87)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2295.450000 8061.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:43" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:04" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "384.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.12) (2295.45 7979.19)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2295.450000 7979.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:44" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:09" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "354.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.6) (2295.45 7448.54)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2295.450000 7448.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:15" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:13" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "353.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.9) (2295.45 7365.87)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2295.450000 7365.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:15" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:11" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "357.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.12) (2295.45 7283.19)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2295.450000 7283.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:16" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:18" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "363.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.6) (2297.97 6763.54)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2297.970000 6763.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:13" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "362.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.9) (2297.97 6680.87)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2297.970000 6680.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:51" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:24" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "366.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.12) (2297.97 6598.19)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2297.970000 6598.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:52" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:31" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "372.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.6) (2297.97 6060.54)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2297.970000 6060.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:55" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "371.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.9) (2297.97 5977.87)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2297.970000 5977.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:12" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "375.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.12) (2297.97 5895.19)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2297.970000 5895.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:51" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:58" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "312.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.8) (2312.09 6454.54)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2312.090000 6454.540000) nil)@@@list("amy_chou" "2017/07/21 16:14:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:35" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "318.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.11) (2312.09 6371.87)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2312.090000 6371.870000) nil)@@@list("amy_chou" "2017/07/21 16:14:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:42" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "315.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.14) (2312.09 6289.19)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3529<uTiL>.5) (2234.53 6371.87)" list(2312.090000 6289.190000) nil)@@@list("amy_chou" "2017/07/21 16:13:56" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:39" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "330.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.8) (2312.09 5755.54)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2312.090000 5755.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:16" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:35" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "336.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.11) (2312.09 5672.87)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2312.090000 5672.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:28" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:47" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "333.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.14) (2312.09 5590.19)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3527<uTiL>.5) (2234.53 5672.87)" list(2312.090000 5590.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:28" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:40" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "163.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.8) (2312.57 7838.54)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" list(2312.570000 7838.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:34" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "160.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.11) (2312.57 7755.87)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" list(2312.570000 7755.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:32" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "165.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.14) (2312.57 7673.19)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3530<uTiL>.5) (2235.01 7755.87)" list(2312.570000 7673.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:36" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "214.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.8) (2312.57 7143.54)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2312.570000 7143.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:18" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "211.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.11) (2312.57 7060.87)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2312.570000 7060.870000) nil)@@@list("amy_chou" "2017/07/21 16:09:17" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "208.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.14) (2312.57 6978.19)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3532<uTiL>.5) (2235.01 7060.87)" list(2312.570000 6978.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:16" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:17" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "379.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.7) (2373.01 8144.54)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2373.010000 8144.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:43" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:03" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "377.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.10) (2373.01 8061.87)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2373.010000 8061.870000) nil)@@@list("amy_chou" "2017/07/21 16:09:13" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:01" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "383.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.13) (2373.01 7979.19)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2373.010000 7979.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "352.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.7) (2373.01 7448.54)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2373.010000 7448.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:15" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:10" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "350.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.10) (2373.01 7365.87)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2373.010000 7365.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:07" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "356.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.13) (2373.01 7283.19)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2373.010000 7283.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:16" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:16" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "361.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.7) (2375.53 6763.54)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2375.530000 6763.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:13" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "359.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.10) (2375.53 6680.87)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2375.530000 6680.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:13" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:20" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "365.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.13) (2375.53 6598.19)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2375.530000 6598.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:13" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:28" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "370.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.7) (2375.53 6060.54)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2375.530000 6060.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:53" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "368.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.10) (2375.53 5977.87)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2375.530000 5977.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:50" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:50" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "374.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.13) (2375.53 5895.19)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2375.530000 5895.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:12" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:57" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "116.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.6) (2402.44 7838.54)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" list(2402.440000 7838.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:49" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:51" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "115.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.9) (2402.44 7755.87)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" list(2402.440000 7755.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:48" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:50" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "118.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.12) (2402.44 7673.19)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" list(2402.440000 7673.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:49" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:52" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "223.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.6) (2402.44 7143.54)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" list(2402.440000 7143.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:12" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:29" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "222.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.9) (2402.44 7060.87)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" list(2402.440000 7060.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:28" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "257.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.12) (2402.44 6978.19)" list(2402.440000 6978.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:47" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:27" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "323.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.6) (2404.44 6454.74)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2404.440000 6454.740000) nil)@@@list("amy_chou" "2017/07/21 16:14:02" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:49" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "329.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.9) (2404.44 6372.07)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2404.440000 6372.070000) nil)@@@list("amy_chou" "2017/07/21 16:14:08" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "327.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.12) (2404.44 6289.39)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2404.440000 6289.390000) nil)@@@list("amy_chou" "2017/07/21 16:14:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:53" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "341.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.6) (2404.44 5755.76)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2404.440000 5755.760000) nil)@@@list("amy_chou" "2017/07/21 16:09:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "347.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.9) (2404.44 5673.09)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2404.440000 5673.090000) nil)@@@list("amy_chou" "2017/07/21 16:08:46" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:03" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "345.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.12) (2404.44 5590.41)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2404.440000 5590.410000) nil)@@@list("amy_chou" "2017/07/21 16:08:46" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:00" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "378.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.8) (2450.57 8144.54)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2450.570000 8144.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:12" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "376.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.11) (2450.57 8061.87)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2450.570000 8061.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:43" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:00" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "382.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3366<uTiL>.14) (2450.57 7979.19)" "[SmdPin] +12V_CPU (<uTiL>cId3366<uTiL>.5) (2373.01 8061.87)" list(2450.570000 7979.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:13" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "351.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.8) (2450.57 7448.54)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2450.570000 7448.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "349.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.11) (2450.57 7365.87)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2450.570000 7365.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:13" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "355.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3367<uTiL>.14) (2450.57 7283.19)" "[SmdPin] +12V_CPU (<uTiL>cId3367<uTiL>.5) (2373.01 7365.87)" list(2450.570000 7283.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:17" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:15" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "360.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.8) (2453.09 6763.54)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2453.090000 6763.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:21" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "358.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.11) (2453.09 6680.87)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2453.090000 6680.870000) nil)@@@list("amy_chou" "2017/07/21 16:09:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "364.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3365<uTiL>.14) (2453.09 6598.19)" "[SmdPin] +12V_CPU (<uTiL>cId3365<uTiL>.5) (2375.53 6680.87)" list(2453.090000 6598.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:26" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "369.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.8) (2453.09 6060.54)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2453.090000 6060.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:51" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:51" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "367.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.11) (2453.09 5977.87)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2453.090000 5977.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:50" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:48" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "373.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3364<uTiL>.14) (2453.09 5895.19)" "[SmdPin] +12V_CPU (<uTiL>cId3364<uTiL>.5) (2375.53 5977.87)" list(2453.090000 5895.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:22:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "258.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.7) (2480.0 7838.54)" list(2480.000000 7838.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:49" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:29" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "114.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.10) (2480.0 7755.87)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" list(2480.000000 7755.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:48" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:49" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "159.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.13) (2480.0 7673.19)" list(2480.000000 7673.190000) nil)@@@list("amy_chou" "2017/07/21 16:10:05" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:31" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "256.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.7) (2480.0 7143.54)" list(2480.000000 7143.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:47" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:26" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "221.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.10) (2480.0 7060.87)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" list(2480.000000 7060.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:27" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "220.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.13) (2480.0 6978.19)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" list(2480.000000 6978.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:27" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "322.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.7) (2482.0 6454.74)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2482.000000 6454.740000) nil)@@@list("amy_chou" "2017/07/21 16:13:57" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:48" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "328.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.10) (2482.0 6372.07)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2482.000000 6372.070000) nil)@@@list("amy_chou" "2017/07/21 16:13:58" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "326.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.13) (2482.0 6289.39)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2482.000000 6289.390000) nil)@@@list("amy_chou" "2017/07/21 16:14:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:52" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "340.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.7) (2482.0 5755.76)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2482.000000 5755.760000) nil)@@@list("amy_chou" "2017/07/21 16:10:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:52" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "346.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.10) (2482.0 5673.09)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2482.000000 5673.090000) nil)@@@list("amy_chou" "2017/07/21 16:09:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "344.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.13) (2482.0 5590.41)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2482.000000 5590.410000) nil)@@@list("amy_chou" "2017/07/21 16:10:04" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:59" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "113.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.8) (2557.56 7838.54)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" list(2557.560000 7838.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:49" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "158.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.11) (2557.56 7755.87)" list(2557.560000 7755.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:04" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:30" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "117.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.14) (2557.56 7673.19)" "[SmdPin] VRM_PWM2_SW_C (<uTiL>cId3531<uTiL>.5) (2480.0 7755.87)" list(2557.560000 7673.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:15" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:52" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "219.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.8) (2557.56 7143.54)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" list(2557.560000 7143.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "218.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.11) (2557.56 7060.87)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" list(2557.560000 7060.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "217.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.14) (2557.56 6978.19)" "[SmdPin] VRM_PWM1_SW_C (<uTiL>cId3533<uTiL>.5) (2480.0 7060.87)" list(2557.560000 6978.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:12" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:24" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "321.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.8) (2559.56 6454.74)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2559.560000 6454.740000) nil)@@@list("amy_chou" "2017/07/21 16:14:05" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:46" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "325.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.11) (2559.56 6372.07)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2559.560000 6372.070000) nil)@@@list("amy_chou" "2017/07/21 16:14:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:51" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "324.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.14) (2559.56 6289.39)" "[SmdPin] VRM_PWM3_SW_C (<uTiL>cId3528<uTiL>.5) (2482.0 6372.07)" list(2559.560000 6289.390000) nil)@@@list("amy_chou" "2017/07/21 16:14:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:50" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "339.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.8) (2559.56 5755.76)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2559.560000 5755.760000) nil)@@@list("amy_chou" "2017/07/21 16:08:45" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:51" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "343.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.11) (2559.56 5673.09)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2559.560000 5673.090000) nil)@@@list("amy_chou" "2017/07/21 16:08:45" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:58" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "342.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.14) (2559.56 5590.41)" "[SmdPin] VRM_PWM4_SW_C (<uTiL>cId3526<uTiL>.5) (2482.0 5673.09)" list(2559.560000 5590.410000) nil)@@@list("amy_chou" "2017/07/21 16:08:46" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:20:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "227.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId2520<uTiL>.11) (2725.0 4790.0)" "[ThruPin] GND (<uTiL>cId2520<uTiL>.13) (2704.0 4830.0)" list(2704.000000 4830.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:49" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:32" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "107.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId2520<uTiL>.12) (2704.0 4750.0)" "[SmdPin] GND (<uTiL>cId2520<uTiL>.11) (2725.0 4790.0)" list(2704.000000 4750.000000) nil)@@@list("amy_chou" "2017/07/21 16:08:38" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:44" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "105.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId2520<uTiL>.15) (2746.0 4830.0)" "[SmdPin] GND (<uTiL>cId2520<uTiL>.11) (2725.0 4790.0)" list(2746.000000 4830.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:05" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:42" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "106.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId2520<uTiL>.14) (2746.0 4750.0)" "[SmdPin] GND (<uTiL>cId2520<uTiL>.11) (2725.0 4790.0)" list(2746.000000 4750.000000) nil)@@@list("amy_chou" "2017/07/21 16:08:37" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:43" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "131.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId3490<uTiL>.57) (3096.04 8611.28)" "[ThruPin] GND (<uTiL>cId3490<uTiL>.58) (3016.05 8691.27)" list(3016.050000 8691.270000) nil)@@@list("amy_chou" "2017/07/21 16:08:33" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "130.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3490<uTiL>.60) (3016.05 8531.29)" "[SmdPin] GND (<uTiL>cId3490<uTiL>.57) (3096.04 8611.28)" list(3016.050000 8531.290000) nil)@@@list("amy_chou" "2017/07/21 16:08:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:01" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "128.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3490<uTiL>.59) (3176.03 8691.27)" "[SmdPin] GND (<uTiL>cId3490<uTiL>.57) (3096.04 8611.28)" list(3176.030000 8691.270000) nil)@@@list("amy_chou" "2017/07/21 16:08:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:00" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "129.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId3490<uTiL>.61) (3176.03 8531.29)" "[SmdPin] GND (<uTiL>cId3490<uTiL>.57) (3096.04 8611.28)" list(3176.030000 8531.290000) nil)@@@list("amy_chou" "2017/07/21 16:08:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:00" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "8.Drill Hole to Drill Hole" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] Dummy (<uTiL>cId1011<uTiL>.3) (3462.78 4855.87)" "[ThruPin] Dummy (<uTiL>cId5049<uTiL>.4) (3462.79 4855.87)" list(3462.780000 4776.370000) nil)@@@list("amy_chou" "2017/07/21 16:04:48" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:02:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "7.Drill Hole to Drill Hole" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] Dummy (<uTiL>cId1011<uTiL>.2) (3462.78 7808.63)" "[ThruPin] Dummy (<uTiL>cId5049<uTiL>.5) (3462.79 7809.02)" list(3542.260000 7806.790000) nil)@@@list("amy_chou" "2017/07/21 16:04:49" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:02:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "53.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.14) (4017.43 8807.81)" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" list(4017.430000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:30" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:55" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "63.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.11) (4017.43 8725.13)" list(4017.430000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:32" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "89.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.8) (4017.43 8642.46)" list(4017.430000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:09:33" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:29" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "403.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3328<uTiL>.1) (4083.9 9195.0)" "[SmdPin] +12V_CPU (<uTiL>cId4742<uTiL>.2) (4075.0 9209.5)" list(4075.000000 9209.500000) nil)@@@list("amy_chou" "2017/07/21 16:09:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:32" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "255.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.13) (4094.99 8807.81)" list(4094.990000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:31" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "112.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.10) (4094.99 8725.13)" list(4094.990000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:33" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:48" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "111.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.7) (4094.99 8642.46)" list(4094.990000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:09:33" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:47" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "90.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.12) (4172.55 8807.81)" list(4172.550000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:30" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:30" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "254.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.9) (4172.55 8725.13)" list(4172.550000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:31" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:24" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "253.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.5) (4094.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3525<uTiL>.6) (4172.55 8642.46)" list(4172.550000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:09:32" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "152.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.14) (4261.43 8807.81)" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" list(4261.430000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:10:02" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "155.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.11) (4261.43 8725.13)" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" list(4261.430000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:35" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:28" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "156.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.8) (4261.43 8642.46)" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" list(4261.430000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:09:36" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:29" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "4.Drill Hole to Drill Hole" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] Dummy (<uTiL>cId1011<uTiL>.7) (4230.5 7372.21)" "[ThruPin] Dummy (<uTiL>cId5049<uTiL>.2) (4230.51 7372.8)" list(4305.490000 7371.230000) nil)@@@list("amy_chou" "2017/07/21 16:04:48" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:01:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "151.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.13) (4338.99 8807.81)" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" list(4338.990000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:34" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:24" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "252.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.10) (4338.99 8725.13)" list(4338.990000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:10:01" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:20" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "251.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.7) (4338.99 8642.46)" list(4338.990000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:09:35" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "157.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.12) (4416.55 8807.81)" list(4416.550000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:34" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:29" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "153.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.9) (4416.55 8725.13)" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" list(4416.550000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:35" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:26" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "154.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.6) (4416.55 8642.46)" "[SmdPin] VGT_PWM1_SW_C (<uTiL>cId3524<uTiL>.5) (4338.99 8725.13)" list(4416.550000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:10:01" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:27" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "390.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.6) (4601.44 8897.54)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4601.440000 8897.540000) nil)@@@list("amy_chou" "2017/07/21 16:10:02" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:16" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "389.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.9) (4601.44 8814.87)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4601.440000 8814.870000) nil)@@@list("amy_chou" "2017/07/21 16:09:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:15" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "393.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.12) (4601.44 8732.19)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4601.440000 8732.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:20" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "388.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.7) (4679.0 8897.54)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4679.000000 8897.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:14" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "386.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.10) (4679.0 8814.87)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4679.000000 8814.870000) nil)@@@list("amy_chou" "2017/07/21 16:09:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:12" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "392.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.13) (4679.0 8732.19)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4679.000000 8732.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:12" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "387.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.8) (4756.56 8897.54)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4756.560000 8897.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:10" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:13" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "385.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.11) (4756.56 8814.87)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4756.560000 8814.870000) nil)@@@list("amy_chou" "2017/07/21 16:10:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:10" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "391.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3363<uTiL>.14) (4756.56 8732.19)" "[SmdPin] +12V_CPU (<uTiL>cId3363<uTiL>.5) (4679.0 8814.87)" list(4756.560000 8732.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:11" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:17" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "248.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.14) (4852.44 8807.81)" list(4852.440000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:59" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:14" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "242.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.11) (4852.44 8725.13)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(4852.440000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:08:30" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:03" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "245.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.8) (4852.44 8642.46)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(4852.440000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:08:30" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:07" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "240.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.13) (4930.0 8807.81)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(4930.000000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:59" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:01" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "243.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.10) (4930.0 8725.13)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(4930.000000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:58" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "246.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.7) (4930.0 8642.46)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(4930.000000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:08:42" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:11" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "241.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.12) (5007.56 8807.81)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(5007.560000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:08:29" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "244.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.9) (5007.56 8725.13)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(5007.560000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:08:42" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "247.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.6) (5007.56 8642.46)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3522<uTiL>.5) (4930.0 8725.13)" list(5007.560000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:08:31" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:13" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "5.Drill Hole to Drill Hole" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] Dummy (<uTiL>cId1011<uTiL>.5) (4939.17 4970.44)" "[ThruPin] Dummy (<uTiL>cId5049<uTiL>.1) (4939.17 4970.44)" list(5014.170000 4970.440000) nil)@@@list("amy_chou" "2017/07/21 16:04:47" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:02:04" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "61.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.12) (5058.96 4195.56)" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" list(5058.960000 4195.560000) nil)@@@list("amy_chou" "2017/07/21 16:09:01" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "110.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.13) (5058.96 4118.0)" list(5058.960000 4118.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:02" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:47" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "250.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.14) (5058.96 4040.44)" list(5058.960000 4040.440000) nil)@@@list("amy_chou" "2017/07/21 16:10:00" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:17" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "148.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.14) (5102.44 8807.81)" list(5102.440000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:09:58" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:21" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "101.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.11) (5102.44 8725.13)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" list(5102.440000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:08" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:39" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "102.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.8) (5102.44 8642.46)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" list(5102.440000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:09:08" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:40" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "249.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.9) (5141.64 4195.56)" list(5141.640000 4195.560000) nil)@@@list("amy_chou" "2017/07/21 16:10:00" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:16" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "150.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.10) (5141.64 4118.0)" list(5141.640000 4118.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:23" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "88.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.11) (5141.64 4040.44)" list(5141.640000 4040.440000) nil)@@@list("amy_chou" "2017/07/21 16:09:01" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:28" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "100.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.13) (5180.0 8807.81)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" list(5180.000000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:08:31" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:38" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "239.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.10) (5180.0 8725.13)" list(5180.000000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:08:32" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:59" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "103.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.7) (5180.0 8642.46)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" list(5180.000000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:08:32" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:41" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "149.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.6) (5224.31 4195.56)" list(5224.310000 4195.560000) nil)@@@list("amy_chou" "2017/07/21 16:09:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "87.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.7) (5224.31 4118.0)" list(5224.310000 4118.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:00" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:27" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "109.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.5) (5141.64 4118.0)" "[ThruPin] +1P2V_DUAL (<uTiL>cId281<uTiL>.8) (5224.31 4040.44)" list(5224.310000 4040.440000) nil)@@@list("amy_chou" "2017/07/21 16:09:01" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:46" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "99.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.12) (5257.56 8807.81)" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" list(5257.560000 8807.810000) nil)@@@list("amy_chou" "2017/07/21 16:08:31" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:38" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "147.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.9) (5257.56 8725.13)" list(5257.560000 8725.130000) nil)@@@list("amy_chou" "2017/07/21 16:09:57" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:20" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "238.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_25)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.5) (5180.0 8725.13)" "[ThruPin] VGT_PWM2_SW_C (<uTiL>cId3523<uTiL>.6) (5257.56 8642.46)" list(5257.560000 8642.460000) nil)@@@list("amy_chou" "2017/07/21 16:09:57" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:58" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "399.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.6) (5447.45 8897.54)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5447.450000 8897.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:27" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "397.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.9) (5447.45 8814.87)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5447.450000 8814.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "402.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.12) (5447.45 8732.19)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5447.450000 8732.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:41" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:31" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "398.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.7) (5525.01 8897.54)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5525.010000 8897.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:26" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "396.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.10) (5525.01 8814.87)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5525.010000 8814.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:08" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:24" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "401.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.13) (5525.01 8732.19)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5525.010000 8732.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:09" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:29" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "395.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.8) (5602.57 8897.54)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5602.570000 8897.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:41" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "394.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.11) (5602.57 8814.87)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5602.570000 8814.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:08" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:21" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "400.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +12V_CPU (<uTiL>cId3362<uTiL>.14) (5602.57 8732.19)" "[SmdPin] +12V_CPU (<uTiL>cId3362<uTiL>.5) (5525.01 8814.87)" list(5602.570000 8732.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:07" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:23:28" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing-SameNet] TOP" "39.Thru Pin to Thru Pin Same Net" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4700<uTiL>.2) (5645.08 2715.08)" "[ThruPin] GND (<uTiL>cId90<uTiL>.1) (5645.08 2715.08)" list(5676.080000 2715.080000) nil)@@@list("amy_chou" "2017/07/21 16:05:46" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:26" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "2.Drill Hole to Drill Hole" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] Dummy (<uTiL>cId1011<uTiL>.6) (5647.83 7372.21)" "[ThruPin] Dummy (<uTiL>cId5049<uTiL>.3) (5647.83 7372.8)" list(5722.830000 7372.500000) nil)@@@list("amy_chou" "2017/07/21 16:04:49" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:01:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing-SameNet] TOP" "37.Thru Pin to Thru Pin Same Net" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4700<uTiL>.1) (5845.08 2715.08)" "[ThruPin] GND (<uTiL>cId90<uTiL>.2) (5845.08 2715.08)" list(5845.080000 2715.080000) nil)@@@list("amy_chou" "2017/07/21 16:05:44" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:15" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "1.Shape to Route Keepout" "0 MIL [DEFAULT]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/TOP" "[Shape] Route Keepout/Top ((6303.15 353.15) (6696.85 746.85))" "[Top Shape] N31341317 ((6159.8 410.0) (6640.0 690.09))" list(6335.380000 442.070000) nil)@@@list("amy_chou" "2017/07/21 16:04:51" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:01:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "6.Drill Hole to Drill Hole" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] Dummy (<uTiL>cId1011<uTiL>.1) (6415.55 7808.63)" "[ThruPin] Dummy (<uTiL>cId5049<uTiL>.7) (6415.55 7809.02)" list(6495.050000 7808.820000) nil)@@@list("amy_chou" "2017/07/21 16:04:48" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:02:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing] TOP" "3.Drill Hole to Drill Hole" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] Dummy (<uTiL>cId1011<uTiL>.4) (6415.55 4855.87)" "[ThruPin] Dummy (<uTiL>cId5049<uTiL>.6) (6415.55 4855.87)" list(6495.050000 4855.870000) nil)@@@list("amy_chou" "2017/07/21 16:04:50" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:01:23" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "86.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId113<uTiL>.14) (7562.0 3636.0)" "[SmdPin] GND (<uTiL>cId113<uTiL>.11) (7583.0 3596.0)" list(7562.000000 3636.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:50" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:26" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "108.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId113<uTiL>.11) (7583.0 3596.0)" "[ThruPin] GND (<uTiL>cId113<uTiL>.15) (7562.0 3556.0)" list(7562.000000 3556.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:51" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:45" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "146.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId113<uTiL>.11) (7583.0 3596.0)" "[ThruPin] GND (<uTiL>cId113<uTiL>.12) (7604.0 3636.0)" list(7604.000000 3636.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:50" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "228.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId113<uTiL>.11) (7583.0 3596.0)" "[ThruPin] GND (<uTiL>cId113<uTiL>.13) (7604.0 3556.0)" list(7604.000000 3556.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:51" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:33" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing-SameNet] TOP" "38.Thru Pin to Thru Pin Same Net" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4701<uTiL>.2) (7604.92 1274.92)" "[ThruPin] GND (<uTiL>cId90<uTiL>.3) (7604.92 1274.92)" list(7635.920000 1274.920000) nil)@@@list("amy_chou" "2017/07/21 16:05:45" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "224.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1VSB (<uTiL>cId915<uTiL>.1) (7799.21 2925.0)" "[SmdPin] +1VSB (<uTiL>cId327<uTiL>.1) (7781.59 2942.54)" list(7781.590000 2942.540000) nil)@@@list("amy_chou" "2017/07/21 16:14:05" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:30" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Spacing-SameNet] TOP" "36.Thru Pin to Thru Pin Same Net" "5 MIL [DEFAULT]" "OVERLAP" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId4701<uTiL>.1) (7804.92 1274.92)" "[ThruPin] GND (<uTiL>cId90<uTiL>.4) (7804.92 1274.92)" list(7804.920000 1274.920000) nil)@@@list("amy_chou" "2017/07/21 16:05:44" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:14" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "225.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId110<uTiL>.11) (8340.0 4940.0)" "[ThruPin] GND (<uTiL>cId110<uTiL>.12) (8300.0 4961.0)" list(8300.000000 4961.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:47" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:31" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "84.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId110<uTiL>.14) (8300.0 4919.0)" "[SmdPin] GND (<uTiL>cId110<uTiL>.11) (8340.0 4940.0)" list(8300.000000 4919.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:04" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:23" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "145.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId2782<uTiL>.12) (8360.0 8721.0)" "[SmdPin] GND (<uTiL>cId2782<uTiL>.11) (8400.0 8700.0)" list(8360.000000 8721.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:49" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:19" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "144.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId2782<uTiL>.14) (8360.0 8679.0)" "[SmdPin] GND (<uTiL>cId2782<uTiL>.11) (8400.0 8700.0)" list(8360.000000 8679.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:48" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:18" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "85.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId110<uTiL>.13) (8380.0 4961.0)" "[SmdPin] GND (<uTiL>cId110<uTiL>.11) (8340.0 4940.0)" list(8380.000000 4961.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:05" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:24" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "104.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId110<uTiL>.11) (8340.0 4940.0)" "[ThruPin] GND (<uTiL>cId110<uTiL>.15) (8380.0 4919.0)" list(8380.000000 4919.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:04" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:41" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "297.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.12) (8427.19 7783.55)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8427.190000 7783.550000) nil)@@@list("amy_chou" "2017/07/21 16:08:41" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:18" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "296.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.13) (8427.19 7705.99)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8427.190000 7705.990000) nil)@@@list("amy_chou" "2017/07/21 16:09:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:17" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "301.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.14) (8427.19 7628.43)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8427.190000 7628.430000) nil)@@@list("amy_chou" "2017/07/21 16:08:26" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:23" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "304.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.12) (8427.19 7533.56)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8427.190000 7533.560000) nil)@@@list("amy_chou" "2017/07/21 16:09:53" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:26" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "309.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.13) (8427.19 7456.0)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8427.190000 7456.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:54" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:32" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "308.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.14) (8427.19 7378.44)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8427.190000 7378.440000) nil)@@@list("amy_chou" "2017/07/21 16:09:56" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:30" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "348.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +2P5V_VPP (<uTiL>cId1891<uTiL>.1) (8432.0 4431.38)" "[SmdPin] +2P5V_VPP (<uTiL>cId2535<uTiL>.2) (8439.38 4430.74)" list(8439.380000 4430.740000) nil)@@@list("amy_chou" "2017/07/21 16:09:03" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:21:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "226.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] GND (<uTiL>cId2782<uTiL>.11) (8400.0 8700.0)" "[ThruPin] GND (<uTiL>cId2782<uTiL>.13) (8440.0 8721.0)" list(8440.000000 8721.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:48" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:32" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "143.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] GND (<uTiL>cId2782<uTiL>.15) (8440.0 8679.0)" "[SmdPin] GND (<uTiL>cId2782<uTiL>.11) (8400.0 8700.0)" list(8440.000000 8679.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:47" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:17" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "231.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.6) (8452.45 8109.54)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8452.450000 8109.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:51" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:50" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "236.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.9) (8452.45 8026.87)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8452.450000 8026.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:39" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "237.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.12) (8452.45 7944.19)" list(8452.450000 7944.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:57" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "62.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] +1P2V_DUAL (<uTiL>cId2861<uTiL>.1) (8485.54 6681.94)" "[ThruPin] +1P2V_DUAL (<uTiL>cId4030<uTiL>.1) (8501.0 6664.79)" list(8501.000000 6664.790000) nil)@@@list("amy_chou" "2017/07/21 16:09:02" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "299.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.9) (8509.87 7783.55)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8509.870000 7783.550000) nil)@@@list("amy_chou" "2017/07/21 16:08:40" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:21" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "298.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.10) (8509.87 7705.99)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8509.870000 7705.990000) nil)@@@list("amy_chou" "2017/07/21 16:08:26" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:20" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "302.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.11) (8509.87 7628.43)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8509.870000 7628.430000) nil)@@@list("amy_chou" "2017/07/21 16:08:27" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:24" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "305.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.9) (8509.87 7533.56)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8509.870000 7533.560000) nil)@@@list("amy_chou" "2017/07/21 16:09:56" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:27" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "311.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.10) (8509.87 7456.0)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8509.870000 7456.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:55" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:34" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "310.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.11) (8509.87 7378.44)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8509.870000 7378.440000) nil)@@@list("amy_chou" "2017/07/21 16:09:55" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:33" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "230.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.7) (8530.01 8109.54)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8530.010000 8109.540000) nil)@@@list("amy_chou" "2017/07/21 16:08:38" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:49" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "235.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.10) (8530.01 8026.87)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8530.010000 8026.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:39" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:55" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "234.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.13) (8530.01 7944.19)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8530.010000 7944.190000) nil)@@@list("amy_chou" "2017/07/21 16:09:52" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:54" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "295.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.6) (8592.54 7783.55)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8592.540000 7783.550000) nil)@@@list("amy_chou" "2017/07/21 16:08:26" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:16" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "294.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.7) (8592.54 7705.99)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8592.540000 7705.990000) nil)@@@list("amy_chou" "2017/07/21 16:09:57" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:15" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "300.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.8) (8592.54 7628.43)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3360<uTiL>.5) (8509.87 7705.99)" list(8592.540000 7628.430000) nil)@@@list("amy_chou" "2017/07/21 16:09:06" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "303.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.6) (8592.54 7533.56)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8592.540000 7533.560000) nil)@@@list("amy_chou" "2017/07/21 16:09:53" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:25" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "307.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.7) (8592.54 7456.0)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8592.540000 7456.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:54" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:29" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "306.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.8) (8592.54 7378.44)" "[SmdPin] +1P2V_DUAL__LX_D (<uTiL>cId3359<uTiL>.5) (8509.87 7456.0)" list(8592.540000 7378.440000) nil)@@@list("amy_chou" "2017/07/21 16:09:54" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:28" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "229.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.8) (8607.57 8109.54)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8607.570000 8109.540000) nil)@@@list("amy_chou" "2017/07/21 16:09:52" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:34" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "233.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.11) (8607.57 8026.87)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8607.570000 8026.870000) nil)@@@list("amy_chou" "2017/07/21 16:08:40" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:52" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "232.Pad/Pad Direct Connect" "NOT_ALLOWED [DEFAULT]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] N30429432 (<uTiL>cId3361<uTiL>.14) (8607.57 7944.19)" "[SmdPin] N30429432 (<uTiL>cId3361<uTiL>.5) (8530.01 8026.87)" list(8607.570000 7944.190000) nil)@@@list("amy_chou" "2017/07/21 16:08:38" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:17:51" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "98.Pad/Pad Direct Connect" "NOT_ALLOWED [(PWR_20)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[ThruPin] +3P3VA (<uTiL>cId3704<uTiL>.1) (8915.0 6630.63)" "[SmdPin] +3P3VA (<uTiL>cId325<uTiL>.2) (8900.5 6630.0)" list(8900.500000 6630.000000) nil)@@@list("amy_chou" "2017/07/21 16:09:37" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:37" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "56.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP9 (<uTiL>cId4300<uTiL>.2) (9069.17 5221.39)" "[SmdPin] USBP9 (<uTiL>cId4259<uTiL>.1) (9067.2 5223.36)" list(9067.200000 5223.360000) nil)@@@list("amy_chou" "2017/07/21 16:08:53" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:58" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "65.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP9+ (<uTiL>cId4259<uTiL>.2) (9067.2 5268.64)" "[SmdPin] LP9+ (<uTiL>cId4300<uTiL>.1) (9069.17 5270.61)" list(9069.170000 5270.610000) nil)@@@list("amy_chou" "2017/07/21 16:08:56" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "194.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP3_C (<uTiL>cId5411<uTiL>.1) (9075.17 5042.61)" "[SmdPin] USB3_SS_TXP3_C (<uTiL>cId5388<uTiL>.2) (9073.2 5040.64)" list(9073.200000 5040.640000) nil)@@@list("amy_chou" "2017/07/21 16:08:55" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:06" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "54.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP3_CMC (<uTiL>cId5411<uTiL>.2) (9075.17 4993.39)" "[SmdPin] USB3_SS_TXP3_CMC (<uTiL>cId5388<uTiL>.1) (9073.2 4995.36)" list(9073.200000 4995.360000) nil)@@@list("amy_chou" "2017/07/21 16:09:25" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "269.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB2_P2_N_CHARGE (<uTiL>cId3922<uTiL>.3) (9079.2 4274.64)" "[SmdPin] USB2_P2_N_CHARGE (<uTiL>cId3950<uTiL>.3) (9081.17 4276.61)" list(9081.170000 4276.610000) nil)@@@list("amy_chou" "2017/07/21 16:08:25" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:43" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "187.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP7- (<uTiL>cId3922<uTiL>.4) (9079.2 4229.36)" "[SmdPin] LP7- (<uTiL>cId3950<uTiL>.4) (9081.17 4227.39)" list(9081.170000 4227.390000) nil)@@@list("amy_chou" "2017/07/21 16:09:27" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:00" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "142.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP1_C (<uTiL>cId5415<uTiL>.1) (9092.17 3919.88)" "[SmdPin] USB3_SS_TXP1_C (<uTiL>cId5392<uTiL>.2) (9090.2 3917.91)" list(9090.200000 3917.910000) nil)@@@list("amy_chou" "2017/07/21 16:10:22" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:16" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "119.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN9 (<uTiL>cId4259<uTiL>.3) (9092.8 5223.36)" "[SmdPin] USBN9 (<uTiL>cId4300<uTiL>.3) (9090.83 5221.39)" list(9090.830000 5221.390000) nil)@@@list("amy_chou" "2017/07/21 16:09:38" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:53" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "281.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP1_CMC (<uTiL>cId5392<uTiL>.1) (9090.2 3872.63)" "[SmdPin] USB3_SS_TXP1_CMC (<uTiL>cId5415<uTiL>.2) (9092.17 3870.66)" list(9092.170000 3870.660000) nil)@@@list("amy_chou" "2017/07/21 16:08:56" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:00" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "283.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP9- (<uTiL>cId4300<uTiL>.4) (9090.83 5270.61)" "[SmdPin] LP9- (<uTiL>cId4259<uTiL>.4) (9092.8 5268.64)" list(9092.800000 5268.640000) nil)@@@list("amy_chou" "2017/07/21 16:08:34" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "192.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN3_CMC (<uTiL>cId5388<uTiL>.3) (9098.8 4995.36)" "[SmdPin] USB3_SS_TXN3_CMC (<uTiL>cId5411<uTiL>.3) (9096.83 4993.39)" list(9096.830000 4993.390000) nil)@@@list("amy_chou" "2017/07/21 16:10:24" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:05" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "279.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN3_C (<uTiL>cId5411<uTiL>.4) (9096.83 5042.61)" "[SmdPin] USB3_SS_TXN3_C (<uTiL>cId5388<uTiL>.4) (9098.8 5040.64)" list(9098.800000 5040.640000) nil)@@@list("amy_chou" "2017/07/21 16:09:46" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:58" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "198.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB2_P2_P_CHARGE (<uTiL>cId3950<uTiL>.2) (9102.83 4276.61)" "[SmdPin] USB2_P2_P_CHARGE (<uTiL>cId3922<uTiL>.1) (9104.8 4274.64)" list(9104.800000 4274.640000) nil)@@@list("amy_chou" "2017/07/21 16:10:20" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:09" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "133.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP7+ (<uTiL>cId3950<uTiL>.1) (9102.83 4227.39)" "[SmdPin] LP7+ (<uTiL>cId3922<uTiL>.2) (9104.8 4229.36)" list(9104.800000 4229.360000) nil)@@@list("amy_chou" "2017/07/21 16:08:54" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:03" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "55.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN1_C (<uTiL>cId5392<uTiL>.4) (9115.8 3917.91)" "[SmdPin] USB3_SS_TXN1_C (<uTiL>cId5415<uTiL>.4) (9113.83 3919.88)" list(9113.830000 3919.880000) nil)@@@list("amy_chou" "2017/07/21 16:08:24" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:08:57" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "191.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN1_CMC (<uTiL>cId5392<uTiL>.3) (9115.8 3872.63)" "[SmdPin] USB3_SS_TXN1_CMC (<uTiL>cId5415<uTiL>.3) (9113.83 3870.66)" list(9113.830000 3870.660000) nil)@@@list("amy_chou" "2017/07/21 16:09:25" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:04" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "132.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP13+ (<uTiL>cId3955<uTiL>.1) (9118.0 4070.61)" "[SmdPin] LP13+ (<uTiL>cId3921<uTiL>.2) (9116.03 4068.64)" list(9116.030000 4068.640000) nil)@@@list("amy_chou" "2017/07/21 16:09:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:02" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "68.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB2_P1_P_CHARGE (<uTiL>cId3921<uTiL>.1) (9116.03 4023.36)" "[SmdPin] USB2_P1_P_CHARGE (<uTiL>cId3955<uTiL>.2) (9118.0 4021.39)" list(9118.000000 4021.390000) nil)@@@list("amy_chou" "2017/07/21 16:10:21" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:10" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "183.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP11+ (<uTiL>cId4258<uTiL>.2) (9134.2 5208.64)" "[SmdPin] LP11+ (<uTiL>cId4304<uTiL>.1) (9136.17 5210.61)" list(9136.170000 5210.610000) nil)@@@list("amy_chou" "2017/07/21 16:10:25" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:10:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "67.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBP11 (<uTiL>cId4258<uTiL>.1) (9134.2 5163.36)" "[SmdPin] USBP11 (<uTiL>cId4304<uTiL>.2) (9136.17 5161.39)" list(9136.170000 5161.390000) nil)@@@list("amy_chou" "2017/07/21 16:08:14" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:09" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "188.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP13- (<uTiL>cId3921<uTiL>.4) (9141.63 4068.64)" "[SmdPin] LP13- (<uTiL>cId3955<uTiL>.4) (9139.66 4070.61)" list(9139.660000 4070.610000) nil)@@@list("amy_chou" "2017/07/21 16:08:57" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:01" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "270.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB2_P1_N_CHARGE (<uTiL>cId3921<uTiL>.3) (9141.63 4023.36)" "[SmdPin] USB2_P1_N_CHARGE (<uTiL>cId3955<uTiL>.3) (9139.66 4021.39)" list(9139.660000 4021.390000) nil)@@@list("amy_chou" "2017/07/21 16:08:24" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:44" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "195.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP4_C (<uTiL>cId5387<uTiL>.2) (9150.2 4956.64)" "[SmdPin] USB3_SS_TXP4_C (<uTiL>cId5410<uTiL>.1) (9152.17 4958.61)" list(9152.170000 4958.610000) nil)@@@list("amy_chou" "2017/07/21 16:09:46" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:07" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "124.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP4_CMC (<uTiL>cId5387<uTiL>.1) (9150.2 4911.36)" "[SmdPin] USB3_SS_TXP4_CMC (<uTiL>cId5410<uTiL>.2) (9152.17 4909.39)" list(9152.170000 4909.390000) nil)@@@list("amy_chou" "2017/07/21 16:08:56" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:57" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "197.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] LP11- (<uTiL>cId4258<uTiL>.4) (9159.8 5208.64)" "[SmdPin] LP11- (<uTiL>cId4304<uTiL>.4) (9157.83 5210.61)" list(9157.830000 5210.610000) nil)@@@list("amy_chou" "2017/07/21 16:10:19" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:09" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "266.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USBN11 (<uTiL>cId4258<uTiL>.3) (9159.8 5163.36)" "[SmdPin] USBN11 (<uTiL>cId4304<uTiL>.3) (9157.83 5161.39)" list(9157.830000 5161.390000) nil)@@@list("amy_chou" "2017/07/21 16:09:26" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:39" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "282.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP2_C (<uTiL>cId5391<uTiL>.2) (9165.2 3832.27)" "[SmdPin] USB3_SS_TXP2_C (<uTiL>cId5414<uTiL>.1) (9167.17 3834.24)" list(9167.170000 3834.240000) nil)@@@list("amy_chou" "2017/07/21 16:10:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:19:01" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "196.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXP2_CMC (<uTiL>cId5391<uTiL>.1) (9165.2 3786.99)" "[SmdPin] USB3_SS_TXP2_CMC (<uTiL>cId5414<uTiL>.2) (9167.17 3785.02)" list(9167.170000 3785.020000) nil)@@@list("amy_chou" "2017/07/21 16:08:55" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:11:08" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "278.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN4_C (<uTiL>cId5387<uTiL>.4) (9175.8 4956.64)" "[SmdPin] USB3_SS_TXN4_C (<uTiL>cId5410<uTiL>.4) (9173.83 4958.61)" list(9173.830000 4958.610000) nil)@@@list("amy_chou" "2017/07/21 16:09:47" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "123.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN4_CMC (<uTiL>cId5387<uTiL>.3) (9175.8 4911.36)" "[SmdPin] USB3_SS_TXN4_CMC (<uTiL>cId5410<uTiL>.3) (9173.83 4909.39)" list(9173.830000 4909.390000) nil)@@@list("amy_chou" "2017/07/21 16:10:24" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:56" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "277.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN2_C (<uTiL>cId5391<uTiL>.4) (9190.8 3832.27)" "[SmdPin] USB3_SS_TXN2_C (<uTiL>cId5414<uTiL>.4) (9188.83 3834.24)" list(9188.830000 3834.240000) nil)@@@list("amy_chou" "2017/07/21 16:08:15" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:18:55" nil "p16c000357-pc" "5s-ipcfl-sc.a00") | list("[Physical] TOP" "83.Pad/Pad Direct Connect" "NOT_ALLOWED [85OHM(DP_4/4/2.5/200)]" "ALL_ALLOWED" "" "DRC ERROR CLASS/TOP" "[SmdPin] USB3_SS_TXN2_CMC (<uTiL>cId5414<uTiL>.3) (9188.83 3785.02)" "[SmdPin] USB3_SS_TXN2_CMC (<uTiL>cId5391<uTiL>.3) (9190.8 3786.99)" list(9190.800000 3786.990000) nil)@@@list("amy_chou" "2017/07/21 16:10:23" nil "P143000034-PC" "5s-ipcfl-sc.a00")@@@list("iris_chen" "2017/07/24 16:09:22" nil "p16c000357-pc" "5s-ipcfl-sc.a00")
