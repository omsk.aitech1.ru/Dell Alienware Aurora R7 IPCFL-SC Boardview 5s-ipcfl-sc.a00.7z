# Allegro board 5s-ipcfl-sc.a00.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CENTER: length 15.4
  TOP w0.254: AC167.2 8.98,56.47 v1(11.58,56.47) ; AR207.1 14.72,64.54 v1(14.64,64.47)
  BOTTOM w0.254: v1(14.64,64.47) 14.11,63.93 12.83,63.93 12.55,63.65 12.55,61.37 11.39,60.21 11.39,56.66 v1(11.58,56.47)
CENTER_C: length 51
  TOP w0.254: AU1.43 16.25,12.34 15.02,13.58 v1(14.12,13.58) ; AC167.1 6.68,52.67 6.68,47.9 5.02,46.24 5.02,32.25 7.45,29.81 7.45,28.8 8.98,27.28 v1(10.9,27.28)
  BOTTOM w0.254: v1(14.12,13.58) 13.7,13.99 12.89,13.99 10.26,16.62 10.26,18.16 10.46,18.36 10.46,25.7 v2(10.77,26.01) 10.77,27.15 v1(10.9,27.28)
CFAN_PWM1_4P: length 13.1
  TOP w0.102: P29.4 237,227.15 FR28.1 ; FR28.1 234.26,227.94 234.09,228.12 233.65,228.12 233.32,228.45 232.16,228.45 FD8.1 ; FR28.1 234.26,226.64 234.11,226.49 FC5.1
  BOTTOM w0.102: v2(235.56,227.61) 236.55,227.61 P29.4
CFAN_PWM_4P: length 21.3
  TOP w0.102: FR2.1 130.96,232.97 130.85,233.08 FC2.1 129.98,233.08 129.66,233.41 FD1.1 128.15,233.41 v1(127.99,233.25) 127.58,232.84 125.15,232.84 124.59,233.4 124.59,234.57 122.35,236.8 118.54,236.8 P461.4
  BOTTOM w0.102: v2(128.78,233.25) v1(127.99,233.25)
CFAN_TACH: length 20.9
  TOP w0.102: P461.3 120.87,237.02 122.44,237.02 124.75,234.71 FD3.2 ; FR17.1 FC3.1 131.3,234.02 130.98,234.34 129.48,234.34 FD1.2 128.04,235.79 126.76,235.79 FD3.2 ; FD3.2 FD3.1
CFAN_TACH1: length 19.1
  TOP w0.102: FC6.1 232.14,227.13 FD8.2 ; FC6.1 232.66,226.15 FD9.2 FD9.1 234.47,224.34 234.95,224.82 237.59,224.82 238.27,224.13 P29.3 ; FC6.1 FR29.1
  BOTTOM w0.102: P29.3 239.65,224.72 239.65,226.54 237.39,228.8 v2(236.88,228.8)
CHARGING_CTRL1: length 108.6
  TOP w0.102: v1(204.01,58.57) 205.38,59.94 205.38,61.59 206.15,62.36 206.15,74.14 204.09,76.2 v1(204.09,76.45) ; U51.6 226.08,100.32 225.79,100.03 225.61,100.03 225.4,99.82 v1(225.4,99.03) 225.7,98.73 225.7,89.15 223.01,86.46 v1(223.01,82.68) ; PCH.Y35 176.7,52.53 176.35,52.88 v1(176.35,52.96) ; v1(227.89,106.53) 227.46,106.96 226.76,106.96 226.16,107.56 226.16,107.74 226.16,108.97 224.81,110.32 224.28,110.32 223.79,110.82 223.79,111.57 224.21,111.99 U942691.6
  BOTTOM w0.089: v1(176.35,52.96) 176.76,53.37 178.76,53.37 179.24,52.89 180.2,52.89 181.57,54.26 183.67,54.26 185.07,55.66
  BOTTOM w0.102: v1(204.01,58.57) 196.88,58.57 196.2,57.9 194.54,57.9 193.66,57.02 187.42,57.02 186.06,55.66 185.07,55.66 ; v1(225.4,99.03) 225.4,99.74 226.44,100.78 226.44,102.82 v2(226.67,103.05) 227.05,103.43 227.05,105.05 227.28,105.28 227.28,105.92 v1(227.89,106.53) ; v1(223.01,82.68) 219.14,82.68 215.94,79.48 211.45,79.48 209.16,77.19 204.83,77.19 v1(204.09,76.45)
CHARGING_CTRL2: length 116.7
  TOP w0.102: v1(205.39,58.2) 205.77,58.57 205.77,61.24 206.38,61.85 206.38,74.43 204.85,75.96 v1(204.85,76.45) ; U51.7 226.58,100.02 226.47,99.9 226.26,99.9 v1(225.93,99.57) 225.89,99.53 225.89,98.95 225.95,98.89 225.95,85.1 v1(224.41,83.57) ; v1(174.97,51.89) 174.97,51.83 PCH.AC30 ; U942691.7 224.7,112.17 224,111.46 224,110.91 224.37,110.54 224.98,110.54 226.38,109.14 226.38,107.65 226.85,107.18 228.16,107.18 v1(228.35,106.98)
  BOTTOM w0.089: 181.24,52.07 176.91,52.07 176.27,51.43 175.43,51.43 v1(174.97,51.89)
  BOTTOM w0.102: v1(228.35,106.98) 228.35,106.39 227.51,105.55 227.51,105.11 227.32,104.91 227.32,102.12 226.77,101.57 226.77,100.41 v2(226.49,100.13) 225.93,99.57 v1(225.93,99.57) ; v1(224.41,83.57) 223.94,83.1 223.94,82.94 223.21,82.21 218.98,82.21 216.03,79.26 211.54,79.26 209.25,76.97 205.37,76.97 v1(204.85,76.45) ; 181.24,52.07 184.54,52.07 186.14,53.67 187.54,53.67 188.94,52.28 196.06,52.28 197.98,50.35 202.5,50.35 204.32,52.17 204.32,57.12 v1(205.39,58.2)
CHARGING_CTRL3: length 100.6
  TOP w0.102: v1(206.4,61.16) 206.59,61.35 206.59,74.52 205.61,75.5 v1(205.61,76.33) ; v1(227.61,110.29) 225.88,110.29 225.41,110.76 224.46,110.76 224.22,111 224.22,111.35 224.46,111.59 224.65,111.59 225.21,112.15 U942691.8 ; v1(224.41,82.8) 226.16,84.56 226.16,98.09 227.53,99.47 v1(227.53,99.87) 227.08,100.32 U51.8 ; v1(196.14,59.3) 195.44,59.3 194.87,58.73 186.56,58.73 186.2,58.73 182.69,55.23 PCH.R45
  BOTTOM w0.102: v1(224.41,82.8) 224.11,82.8 223.3,81.99 219.07,81.99 216.12,79.04 211.63,79.04 209.34,76.76 206.04,76.76 v1(205.61,76.33) ; v1(206.4,61.16) 205.82,60.58 197.8,60.58 196.52,59.3 v1(196.14,59.3) ; v1(227.61,110.29) 227.79,110.29 228.78,109.3 228.78,105.61 227.53,104.37 v2(227.53,101.52) v1(227.53,99.87)
CI_EN#: length 115.4
  TOP w0.102: v1(171.34,5.11) 171.34,5.53 170.54,6.34 155.43,6.34 154.69,5.59 153.57,5.59 153.06,6.1 150.23,6.1 149.97,6.35 145.19,6.35 144.66,6.88 137.82,6.88 129.84,14.86 125.93,14.86 123.73,17.07 123.73,18.07 122.73,19.07 122.73,19.73 121.33,21.12 121.17,21.12 120.69,21.61 120.69,22.36 119.68,23.37 119.68,24.27 118,25.95 113.4,25.95 112.42,26.93 U15.27 ; v1(205.12,6.25) OR70.2 206.71,5.78 P17.2
  BOTTOM w0.102: v1(205.12,6.25) 204.84,6.52 191.4,6.52 189.53,8.39 176.44,8.39 173.16,5.11 v1(171.34,5.11)
CK_24M_BCK: length 236.6
  TOP w0.089: 159.07,59.11 159.38,58.8 160.12,58.8 160.48,59.16 PCH.G2
  TOP w0.102: v1(150.95,82.25) 150.55,81.84 150.55,81.13 147.19,77.77 147.19,71.35 146.1,70.26 146.1,66.76 144.88,65.54 144.88,61.19 146.79,59.28 155.12,59.28 155.38,59.54 158.63,59.54 159.07,59.11 ; v1(114.96,149.35) 114.96,149.41 XU1.K9
  BOTTOM w0.102: v1(150.95,82.25) 150.95,82.59 150.84,82.7 149.87,82.7 149.69,82.52 147.57,82.52 147.41,82.68 144.93,82.68 ; 144.93,82.68 v2(144.93,82.38) ; 144.93,82.68 131.34,82.68 130.86,83.16 129.46,83.16 128.12,81.81 63.01,81.81 62.41,82.41 62.41,83.15 61.34,84.22 61.34,85.44 60.53,86.25 60.53,88.22 65.4,93.09 68.94,93.09 71.53,95.68 73.58,95.68 84.51,106.61 93.78,106.61 99.39,112.22 99.39,115.46 100.77,116.84 100.77,121.38 101.35,121.95 101.35,133.41 104.77,136.83 104.77,137.61 104.77,137.61 104.77,140.87 105.62,141.71 105.62,148.83 107,150.22 114.31,150.22 114.76,149.76 114.76,149.55 v1(114.96,149.35)
CK_24M_BCK#: length 236.6
  TOP w0.089: 159.03,59.44 159.49,58.98 159.91,58.98 PCH.G1
  TOP w0.102: 159.03,59.44 158.72,59.75 155.3,59.75 155.03,59.48 146.88,59.48 145.08,61.27 145.08,65.46 146.3,66.67 146.3,70.17 147.4,71.26 147.4,77.69 150.75,81.04 150.75,81.71 150.81,81.78 151.65,81.78 151.76,81.89 151.76,82.07 v1(151.59,82.25) ; XU1.J9 114.57,149.76 114.57,149.5 114.46,149.39 v1(114.03,149.39)
  BOTTOM w0.102: 143.28,82.88 v2(143.28,83.17) ; 143.28,82.88 131.43,82.88 130.95,83.36 129.38,83.36 128.03,82.02 63.09,82.02 62.61,82.5 62.61,83.24 61.54,84.3 61.54,85.52 60.73,86.33 60.73,88.14 65.48,92.89 69.02,92.89 71.61,95.48 73.66,95.48 84.59,106.41 93.87,106.41 99.59,112.13 99.59,115.38 100.98,116.76 100.98,116.76 100.98,121.3 101.55,121.87 101.55,133.32 104.98,136.75 104.98,137.69 104.98,140.78 105.82,141.63 105.82,148.74 107.09,150.01 114.22,150.01 114.56,149.67 114.56,149.49 114.46,149.39 v1(114.03,149.39) ; 143.28,82.88 147.5,82.88 147.65,82.73 149.61,82.73 149.78,82.91 150.93,82.91 v1(151.59,82.25)
CK_100M_ASM1142: length 216.4
  TOP w0.102: v1(162.08,58.8) 162.42,59.14 PCH.G7 ; U4.48 32.42,140.19 29.74,137.52 29.74,133.47 30.8,132.41 31.69,132.41 33.29,130.81 33.89,130.81 34.09,131.01 34.09,131.29 v1(34.32,131.52)
  BOTTOM w0.102: 34.09,128.5 34.09,127.72 35.05,126.75 35.05,121.62 35.41,121.27 35.41,119 35.71,118.7 35.71,100.53 33.83,98.65 33.83,77.86 35.05,76.64 35.05,72.14 44.32,62.87 44.32,62.1 45.09,61.34 45.59,61.34 46.56,60.38 46.56,59.54 47.62,58.47 47.62,57.66 49.44,55.85 58.82,55.85 61.05,53.62 69.22,53.62 70.29,52.55 113.72,52.55 113.94,52.78 127.08,52.78 132.32,58.03 160.01,58.03 160.33,58.34 161.16,58.34 161.62,58.8 v1(162.08,58.8) ; 34.09,128.5 34.09,131.29 v1(34.32,131.52) ; 34.09,128.5 v2(34.42,128.5)
CK_100M_ASM1142#: length 216.4
  TOP w0.102: v1(33.66,131.52) 33.88,131.29 33.88,131.09 33.81,131.01 33.38,131.01 31.78,132.61 30.89,132.61 29.95,133.55 29.95,137.43 32.54,140.02 U4.49 ; PCH.H7 162.63,58.21 162.56,58.14 v1(162.26,58.14)
  BOTTOM w0.102: v1(162.26,58.14) 162.08,57.96 161.9,57.96 161.8,58.06 161.8,58.44 161.72,58.51 161.62,58.51 161.25,58.14 160.41,58.14 160.1,57.82 132.41,57.82 127.16,52.58 114.03,52.58 113.8,52.35 70.21,52.35 69.14,53.42 60.96,53.42 58.74,55.64 49.35,55.64 47.42,57.57 47.42,58.39 46.35,59.45 46.35,60.29 45.51,61.14 45,61.14 44.12,62.02 44.12,62.78 34.85,72.05 34.85,76.55 33.63,77.77 33.63,98.74 35.51,100.62 35.51,118.61 35.2,118.92 35.2,121.18 34.85,121.54 34.85,126.67 33.88,127.64 33.88,130.53 ; 33.88,130.53 v2(33.58,130.53) ; 33.88,130.53 33.88,131.29 v1(33.66,131.52)
CK_100M_BCK: length 138
  TOP w0.089: 159.01,58.71 159.02,58.71 159.02,58.69 159.25,58.46 159.91,58.46 PCH.H1
  TOP w0.102: XU1.W5 123.63,145.83 123.56,145.76 v1(123.19,145.76) ; 159.01,58.71 158.81,58.91 155.79,58.91 155.55,58.67 146.49,58.67 144.22,60.93 144.22,65.78 145.49,67.05 145.49,70.51 146.51,71.53 146.51,79.18 151.38,84.05 151.77,84.05 151.88,83.95 151.88,83.69 v1(151.64,83.46)
  BOTTOM w0.102: v1(123.19,145.76) 123.47,145.48 123.47,145.34 123.37,145.24 123.04,145.24 122.8,144.99 122.8,144.69 122.57,144.46 122.57,143.52 123.17,142.92 123.17,141.41 122.35,140.59 122.35,139.84 120.36,137.84 120.36,110.27 121.23,109.4 121.23,105.12 119.56,103.45 119.56,96.72 122.43,93.85 122.43,91.16 127.81,85.78 128.69,85.78 129.91,84.56 130.63,84.56 131.7,83.49 137.54,83.49 137.72,83.67 139.75,83.67 ; v1(151.64,83.46) 151.88,83.69 151.88,83.89 151.73,84.03 149.95,84.03 149.26,83.34 148,83.34 147.67,83.67 139.75,83.67 ; 139.75,83.67 v2(139.75,83.38)
CK_100M_BCK#: length 138
  TOP w0.089: PCH.H2 160.32,58.53 160.32,58.5 160.1,58.27 159.17,58.27 158.86,58.57
  TOP w0.102: 158.86,58.57 158.73,58.7 155.87,58.7 155.63,58.46 146.4,58.46 144.02,60.85 144.02,65.86 145.29,67.13 145.29,70.59 146.3,71.61 146.3,79.26 151.29,84.25 151.86,84.25 152.08,84.03 152.08,83.72 v1(152.31,83.48) ; XU1.W4 123.63,145.23 v1(123.22,144.82)
  BOTTOM w0.102: 141.58,83.87 137.63,83.87 137.46,83.69 131.78,83.69 130.72,84.76 130,84.76 128.78,85.98 127.9,85.98 122.63,91.24 122.63,93.94 119.76,96.81 119.76,103.37 121.43,105.04 121.43,109.48 120.56,110.35 120.56,137.76 122.56,139.76 122.56,140.51 123.37,141.32 123.37,143 122.77,143.61 122.77,144.37 v1(123.22,144.82) ; 141.58,83.87 v2(141.58,84.16) ; 141.58,83.87 147.75,83.87 148.08,83.54 149.17,83.54 149.86,84.23 151.82,84.23 152.08,83.97 152.08,83.72 v1(152.31,83.48)
CK_100M_LAN: length 291.8
  TOP w0.102: PCH.E4 161.53,59.98 v1(161.29,59.74) ; v1(38.56,214.12) 38.18,214.12 37.69,214.62 U10.33
  BOTTOM w0.102: v1(38.56,214.12) 38.02,213.59 38.02,212.38 36.17,210.52 36.17,210.21 ; 36.17,210.21 v2(35.88,210.21) ; 36.17,210.21 36.17,207.57 36.6,207.14 36.6,201.19 37.19,200.61 37.19,191.36 35.38,189.56 35.38,183.4 34.8,182.81 34.8,179.35 32.75,177.31 32.75,169.34 30.71,167.29 30.71,163.35 31.43,162.63 31.43,153.65 32.07,153.01 32.07,152.04 32.07,152.04 32.07,151.37 32.07,151.36 32.07,150.32 33.06,149.33 33.06,146.75 34.05,145.76 34.63,145.76 38.02,142.38 38.02,141.86 39.6,140.28 39.6,135.36 38.9,134.66 37.55,134.66 37.16,134.26 37.16,128.7 36.02,127.56 36.02,119.25 36.4,118.87 36.4,95.61 39.31,92.7 39.31,70.12 46.24,63.2 46.24,61.99 47.11,61.11 47.62,61.11 48.26,60.47 48.26,59.4 49.3,58.36 49.3,57.5 50.08,56.72 59.18,56.72 61.42,54.48 70.56,54.48 71.86,53.19 112.62,53.19 112.83,53.39 126.67,53.39 132.13,58.85 159.85,58.85 160.89,59.89 161.14,59.89 v1(161.29,59.74)
CK_100M_LAN#: length 291.7
  TOP w0.102: v1(160.5,60.4) 160.5,60.25 160.73,60.02 160.83,60.02 PCH.E3 ; v1(38.71,213.46) 38.51,213.66 38.35,213.66 37.8,214.22 U10.32
  BOTTOM w0.102: 36.8,205.51 36.8,201.28 37.39,200.69 37.39,191.28 35.59,189.48 35.59,183.31 35,182.73 35,179.27 32.96,177.22 32.96,169.25 30.91,167.21 30.91,163.43 31.64,162.71 31.64,153.73 32.27,153.09 32.27,152.12 32.28,152.12 32.28,151.28 32.27,151.28 32.27,150.4 33.26,149.42 33.26,146.83 34.13,145.96 34.72,145.96 38.22,142.46 38.22,141.94 39.8,140.36 39.8,135.27 38.98,134.45 37.64,134.45 37.36,134.18 37.36,128.62 36.22,127.47 36.22,119.34 36.6,118.96 36.6,95.7 39.52,92.78 39.52,70.21 46.44,63.29 46.44,62.07 47.19,61.32 47.7,61.32 48.46,60.55 48.46,59.49 49.5,58.45 49.5,57.58 50.16,56.92 59.27,56.92 61.5,54.69 70.65,54.69 71.94,53.39 112.54,53.39 112.74,53.59 126.59,53.59 132.05,59.05 159.77,59.05 160.79,60.08 160.79,60.22 160.6,60.4 v1(160.5,60.4) ; 36.8,205.51 v2(37.1,205.51) ; 36.8,205.51 36.8,207.22 36.37,207.65 36.37,210.44 38.23,212.29 38.23,213.5 38.39,213.66 38.66,213.66 38.71,213.61 v1(38.71,213.46)
CK_100M_M2_A1: length 204.3
  TOP w0.102: v1(33.91,125.25) 34.34,125.68 35.34,125.68 36.13,124.89 38.59,124.89 39.06,124.42 39.06,124.25 38.92,124.11 J60.47 ; v1(159.29,55.57) 159.29,55.2 160.06,54.43 160.25,54.43 PCH.U2
  BOTTOM w0.102: v2(52.22,54.85) 52.22,54.56 ; 52.22,54.56 58.95,54.56 60.97,52.54 68.03,52.54 68.86,51.71 91.38,51.71 91.84,51.26 116.37,51.26 116.73,51.61 127.48,51.61 132.94,57.07 144.15,57.07 146.13,55.09 152.37,55.09 153.28,56.01 158.85,56.01 v1(159.29,55.57) ; 52.22,54.56 50.43,54.56 49.95,55.03 48.17,55.03 43.51,59.69 43.51,62.52 34.24,71.79 34.24,76.3 33.02,77.52 33.02,99.94 34.9,101.82 34.9,115.98 34.52,116.37 34.52,119.39 33.43,120.47 33.43,125.4 33.51,125.48 33.68,125.48 v1(33.91,125.25)
CK_100M_M2_A1#: length 204.3
  TOP w0.102: PCH.U1 160,54.2 v1(158.64,55.56) ; v1(33.9,125.89) 35.42,125.89 36.21,125.09 38.67,125.09 39.27,124.5 39.27,124.28 39.42,124.13 J60.49
  BOTTOM w0.102: 48.36,54.83 48.08,54.83 43.31,59.61 43.31,62.43 34.04,71.7 34.04,76.22 32.82,77.44 32.82,100.03 34.7,101.9 34.7,115.9 34.32,116.28 34.32,119.3 33.23,120.39 33.23,125.48 33.43,125.68 33.7,125.68 v1(33.9,125.89) ; 48.36,54.83 49.87,54.83 50.34,54.36 58.87,54.36 60.89,52.34 67.95,52.34 68.78,51.51 91.3,51.51 91.75,51.05 116.45,51.05 116.81,51.41 127.56,51.41 133.02,56.87 144.06,56.87 146.04,54.89 152.45,54.89 153.37,55.8 158.4,55.8 v1(158.64,55.56) ; 48.36,54.83 v2(48.36,54.54)
CK_100M_M2_M: length 149.4
  TOP w0.102: v1(152.04,14.63) 152.22,14.81 152.22,16.02 134.04,34.2 134.04,44.19 136.93,47.09 136.93,52.9 138.06,54.02 v1(138.06,54.33) ; v1(143.61,55.07) 144.82,55.07 145.58,54.31 154.47,54.31 154.84,54.67 156.12,54.67 157.85,56.41 159.96,56.41 PCH.M1 ; v1(212.55,5.64) 212.75,5.85 212.75,6.18 214.26,7.69 214.26,9.99 214.11,10.14 SS4.55
  BOTTOM w0.102: v1(152.04,14.63) 152.25,14.43 152.25,14.17 152.53,13.88 153.59,13.88 154.79,13.88 161.85,6.82 168.09,6.82 169.93,8.66 172.81,8.66 174.76,10.62 176.66,10.62 177.56,11.52 182.99,11.52 183.76,11.52 184.4,12.15 184.55,12.31 188.39,12.31 ; 188.39,12.31 188.96,12.31 193.18,8.08 210.43,8.08 212.13,6.38 212.57,6.38 212.78,6.17 212.78,5.87 v1(212.55,5.64) ; 188.39,12.31 v2(188.39,12.01) ; v1(138.06,54.33) 138.26,54.33 138.75,54.81 141.07,54.81 141.8,54.08 143.28,54.08 143.61,54.41 v1(143.61,55.07)
CK_100M_M2_M#: length 149.4
  TOP w0.102: v1(138.51,53.88) 138.2,53.88 137.14,52.81 137.14,47.01 134.24,44.11 134.24,34.29 152.43,16.1 152.43,14.88 v1(152.68,14.63) ; v1(213.19,5.64) 212.96,5.87 212.96,6.1 214.46,7.6 214.46,9.99 214.61,10.14 SS4.53 ; v1(144.05,54.56) 144.35,54.86 144.73,54.86 145.49,54.1 154.56,54.1 154.93,54.47 156.2,54.47 157.94,56.2 159.72,56.2 159.73,56.19 160.26,56.19 PCH.M2
  BOTTOM w0.102: v2(190.42,11.56) 190.21,11.34 ; 190.21,11.34 189.04,12.51 184.47,12.51 184.19,12.24 184.19,12.23 183.68,11.72 182.91,11.72 177.47,11.72 176.57,10.82 174.68,10.82 172.72,8.86 169.84,8.86 168,7.02 161.94,7.02 154.88,14.09 153.67,14.09 152.61,14.09 152.45,14.25 152.45,14.4 v1(152.68,14.63) ; 190.21,11.34 193.27,8.28 210.52,8.28 212.22,6.58 212.66,6.58 212.98,6.26 212.98,5.85 v1(213.19,5.64) ; v1(138.51,53.88) 138.51,54.28 138.83,54.61 140.99,54.61 141.72,53.88 143.37,53.88 v1(144.05,54.56)
CK_100M_PCIE: length 129.8
  TOP w0.089: PCH.J2 160.36,58.05 159.12,58.05 158.99,58.18 158.15,58.18 158.14,58.19 158.12,58.19
  TOP w0.102: 158.12,58.19 156.4,58.19 156.06,57.86 146.15,57.86 143.41,60.6 143.41,66.19 144.68,67.46 144.68,70.92 145.69,71.93 145.69,79.51 150.5,84.32 150.5,85.55 150.57,85.62 150.88,85.62 150.95,85.7 v1(150.95,86.03) ; XU1.W1 123.63,142.77 123.55,142.85 123.42,142.85 123.26,142.69 123.26,141.17 123.05,140.96 123.05,135.13 120.75,132.83 120.75,124.07 123.21,121.62 133.34,121.62 139.6,115.36 139.6,112.9 v1(139.85,112.65)
  BOTTOM w0.102: v1(150.95,86.03) 151.12,86.2 151.12,86.4 151.05,86.46 150.55,86.46 150.5,86.51 150.5,86.92 150.15,87.27 146.93,87.27 145.71,88.49 141.99,88.49 ; v2(141.99,88.79) 141.99,88.49 ; 141.99,88.49 141.36,88.49 140.49,89.37 140.49,95.4 140.72,95.63 140.72,106.35 140.11,106.96 140.11,110.13 139.4,110.85 139.4,112.21 139.5,112.32 139.7,112.32 139.85,112.47 v1(139.85,112.65)
CK_100M_PCIE#: length 129.8
  TOP w0.089: 158.12,57.98 158.14,57.98 158.15,58 158.87,58 159.01,57.85 160.68,57.85 PCH.J3
  TOP w0.102: XU1.W2 123.63,143.13 123.55,143.05 123.33,143.05 123.06,142.78 123.06,141.26 122.84,141.04 122.84,135.21 120.55,132.92 120.55,123.99 123.12,121.41 133.25,121.41 139.4,115.27 139.4,112.88 v1(139.19,112.67) ; v1(150.3,86.03) 150.3,84.41 145.49,79.6 145.49,72.02 144.48,71 144.48,67.55 143.21,66.28 143.21,60.51 146.07,57.65 156.15,57.65 156.48,57.98 158.12,57.98
  BOTTOM w0.102: v2(143.74,88) 143.74,88.29 ; 143.74,88.29 141.27,88.29 140.28,89.28 140.28,95.49 140.51,95.72 140.51,106.27 139.9,106.88 139.9,110.05 139.19,110.76 v1(139.19,112.67) ; 143.74,88.29 145.63,88.29 146.85,87.07 150.07,87.07 150.3,86.84 v1(150.3,86.03)
CK_100M_PE4#_2: length 115.4
  TOP w0.102: v1(162.05,61.49) 162.05,61.22 PCH.C5 ; v1(61.59,56.65) 61.42,56.48 60.31,56.48 59.35,57.44 59.35,58.64 60.45,59.73 SLOT2.A14
  BOTTOM w0.102: v1(162.05,61.49) 159.68,61.49 158.06,59.87 131.41,59.87 125.95,54.41 112.16,54.41 111.96,54.2 72.65,54.2 71.13,55.73 63.66,55.73 62.97,56.41 61.84,56.41 v1(61.59,56.65)
CK_100M_PE4#_3: length 117.1
  TOP w0.102: v1(64.67,50.96) 64.42,50.7 64.42,49.97 62.35,47.9 62.35,46.3 60.96,44.91 60.12,44.91 59.65,44.44 59.65,43.15 59.8,43 60.27,43 60.45,43.18 60.45,44.19 SLOT3.A14 ; PCH.Y10 164.16,52.55 v1(163.75,52.96)
  BOTTOM w0.102: v1(163.75,52.96) 163.75,53.39 163.58,53.57 161.87,53.57 161.1,52.79 154.1,52.79 153.2,51.89 133.87,51.89 130.95,48.97 117.84,48.97 117.48,48.62 100.77,48.62 99.92,47.77 86.7,47.77 83.77,50.69 68.44,50.69 67.68,51.46 64.69,51.46 64.57,51.33 64.57,51.06 v1(64.67,50.96)
CK_100M_PE4_2: length 115.4
  TOP w0.102: PCH.C6 162.19,61.02 162.08,60.91 v1(162.08,60.48) ; v1(61.6,56.02) 61.34,56.28 60.23,56.28 59.15,57.35 59.15,58.72 60.25,59.82 60.25,62.61 60.12,62.74 59.68,62.74 SLOT2.A13
  BOTTOM w0.102: v1(162.08,60.48) 162.08,60.88 161.66,61.29 159.77,61.29 158.14,59.66 131.5,59.66 126.04,54.2 112.24,54.2 112.04,54 72.57,54 71.04,55.52 63.58,55.52 62.89,56.21 61.79,56.21 v1(61.6,56.02)
CK_100M_PE4_3: length 117.1
  TOP w0.102: SLOT3.A13 59.45,44.52 60.04,45.11 60.87,45.11 62.15,46.39 62.15,47.98 64.22,50.05 64.22,50.78 v1(64.04,50.96) ; PCH.Y11 164.49,52.88 v1(164.49,52.98)
  BOTTOM w0.102: v1(164.49,52.98) 163.7,53.77 161.79,53.77 161.01,52.99 154.01,52.99 153.11,52.1 133.79,52.1 130.86,49.17 117.75,49.17 117.4,48.82 100.69,48.82 99.84,47.97 86.78,47.97 83.86,50.9 68.53,50.9 67.76,51.66 64.61,51.66 64.36,51.42 64.36,51.28 v1(64.04,50.96)
CK_100M_PE16: length 150
  TOP w0.102: v1(89.73,49.63) 89.95,49.85 89.95,55.36 92.53,57.95 92.53,68.66 93.8,69.93 93.8,75.78 92.41,77.18 59.8,77.18 59.17,77.8 59.17,78.87 60.18,79.88 60.18,80.5 61.04,81.36 61.04,81.86 60.4,82.49 60.4,82.97 60.11,83.26 59.88,83.26 SLOT1.A13 ; v1(162.97,56.27) 162.82,56.13 PCH.P7
  BOTTOM w0.102: v1(162.97,56.27) 162.56,56.68 161.8,56.68 161.43,56.31 161.43,55.98 160.17,54.72 153.16,54.72 152.32,53.87 146.2,53.87 143.81,56.26 133.74,56.26 128.28,50.8 117.07,50.8 116.72,50.44 90.2,50.44 89.92,50.16 89.92,49.81 v1(89.73,49.63)
CK_100M_PE16#: length 150
  TOP w0.102: v1(90.38,49.64) 90.15,49.87 90.15,55.28 92.74,57.86 92.74,68.58 94.01,69.85 94.01,75.87 92.49,77.38 59.88,77.38 59.38,77.89 59.38,78.79 60.39,79.8 60.39,80.42 61.24,81.27 61.24,81.94 60.6,82.58 60.6,83.05 60.04,83.61 60.04,84.01 SLOT1.A14 ; v1(162.33,56.26) 162.33,56.03 162.24,55.94 PCH.P5
  BOTTOM w0.102: v1(90.38,49.64) 90.12,49.9 90.12,50.08 90.28,50.24 116.8,50.24 117.16,50.6 128.37,50.6 133.83,56.06 143.72,56.06 146.11,53.67 152.4,53.67 153.25,54.52 160.26,54.52 161.65,55.91 161.65,56.24 161.89,56.48 162.12,56.48 v1(162.33,56.26)
CK_100M_PE16#_1: length 123.3
  TOP w0.102: PCH.T8 163,54.34 v1(163,54.26) ; SLOT4.A14 60.45,23.24 60.33,23.11 59.89,23.11 59.65,23.36 59.65,25.85 69.69,35.89 77.92,35.89 87.91,45.87 87.91,49.18 v1(88.1,49.37)
  BOTTOM w0.102: v1(88.1,49.37) 87.92,49.18 87.92,49.02 88.06,48.87 99.4,48.87 100.16,49.63 117.06,49.63 117.42,49.99 130.53,49.99 133.45,52.91 152.78,52.91 153.7,53.83 160.79,53.83 161.83,54.87 162.48,54.87 162.7,54.65 162.7,54.41 162.85,54.26 v1(163,54.26)
CK_100M_PE16_1: length 123.3
  TOP w0.102: SLOT4.A13 59.45,25.94 69.61,36.09 77.84,36.09 87.71,45.96 87.71,49.11 v1(87.44,49.37) ; v1(162.23,54.21) 162.23,54.34 PCH.T7
  BOTTOM w0.102: v1(162.23,54.21) 162.29,54.21 162.49,54.41 162.49,54.57 162.39,54.67 161.91,54.67 160.87,53.63 153.79,53.63 152.86,52.7 133.53,52.7 130.61,49.78 117.5,49.78 117.15,49.43 100.24,49.43 99.48,48.67 87.98,48.67 87.71,48.94 87.71,49.1 v1(87.44,49.37)
CK_100M_XDP: length 131.2
  TOP w0.089: PCH.L3 160.57,57.33 160.45,57.35 160.3,57.35 160.2,57.3 160.1,57.18 160.1,57.17 159.92,57 159.28,57
  TOP w0.102: v1(121.95,95.99) 122.43,95.5 122.43,93.85 120.61,92.04 97.49,92.04 95.53,93.99 95.53,95.88 97.51,97.86 97.51,100.83 95.52,102.82 94.18,102.82 93.09,103.91 93.09,104.08 92.35,104.82 ; v1(149.01,84.49) 149.01,84.67 148.9,84.79 148.61,84.79 144.88,81.05 144.88,72.28 141.5,68.9 141.5,59.53 145.92,55.12 153.77,55.12 154.14,55.49 155.91,55.49 156.44,56.01 157.42,57 159.28,57
  BOTTOM w0.102: v1(121.95,95.99) 122.43,95.5 122.43,95.05 123.24,94.23 123.24,91.5 128.15,86.59 129.03,86.59 130.23,85.39 130.96,85.39 132.05,84.3 136.96,84.3 137.61,84.95 145.77,84.95 ; 145.77,84.95 148.85,84.95 149.01,84.79 v1(149.01,84.49) ; 145.77,84.95 v2(145.77,84.66)
CK_100M_XDP#: length 131.2
  TOP w0.089: 159.28,56.79 159.29,56.79 159.31,56.81 159.35,56.81 159.36,56.82 159.99,56.82 160.28,57.11 PCH.L2
  TOP w0.102: 159.28,56.79 157.51,56.79 156.58,55.87 155.99,55.28 154.22,55.28 153.86,54.91 145.83,54.91 141.3,59.45 141.3,68.99 144.68,72.36 144.68,81.14 148.53,84.99 v1(149.43,84.99) ; v1(122.63,95.94) 122.63,93.77 120.7,91.83 97.4,91.83 95.33,93.91 95.33,95.96 97.31,97.94 97.31,100.74 95.43,102.62 94.1,102.62 92.98,103.73 92.92,103.73 92.92,103.73 92.87,103.73 92.87,103.73 92.73,103.73 XDP2.42
  BOTTOM w0.102: v1(149.43,84.99) 149.11,84.99 148.94,85.16 143.31,85.16 ; 143.31,85.16 137.52,85.16 136.87,84.51 132.14,84.51 131.05,85.6 130.31,85.6 129.12,86.79 128.23,86.79 123.44,91.58 123.44,94.32 122.63,95.13 v1(122.63,95.94) ; 143.31,85.16 v2(143.31,85.45)
CLKOUT_LPC0: length 79.4
  TOP w0.102: SCB68.2 215.63,23.83 215.14,23.83 214.94,24.02 U104.16 214.94,25.52 212.65,27.81 v1(212.65,28.16) ; v1(209.58,31.88) 209.92,32.22 211.21,32.22 212.14,31.29 213.13,31.29 v1(213.46,30.96) ; SR92.1 SC141.1 163.12,31.05 162.69,30.61 162.69,29.84 161.58,28.74 161.58,28.21 161.19,27.81 161.19,27.34 161.52,27.01 161.52,26.59 160.88,25.96 160.88,23.71 v1(162.01,22.58)
  BOTTOM w0.102: v1(162.01,22.58) 165.95,22.58 166.54,21.99 168.92,21.99 169.67,21.23 176.11,21.23 177.51,22.63 180.19,22.63 182.26,24.7 192.9,24.7 193.17,24.43 196.44,24.43 199.65,27.65 200.51,27.65 201.23,28.37 204.06,28.37 204.85,29.16 205.66,29.16 208.12,31.62 209.32,31.62 v1(209.58,31.88) ; v1(212.65,28.16) 213.46,28.97 v2(213.46,30.1) v1(213.46,30.96)
CLKOUT_LPC0_ESPI_CLK: length 11.4
  TOP w0.089: 166.55,36.68 166.85,36.98 v1(166.85,38.07) 166.85,38.73 166.6,38.99 166.6,39.42 166.42,39.6 166.4,39.73 166.42,39.88 166.52,40.03 PCH.BE15
  TOP w0.102: 166.55,36.68 166.55,34.82 164.16,32.43 SR92.2
  BOTTOM w0.102: v1(166.85,38.07) 166.85,38.4 166.8,38.46 166.8,38.71 v2(166.14,39.37)
CLKOUT_LPC1: length 69.8
  TOP w0.102: v1(210.45,23.2) 210.49,23.16 210.49,21.72 210.4,21.63 ECR103.1 ; v1(164.92,22.12) 165.39,22.59 SC147.1 SR745.1 ; P118.12 198.2,10.17 198.34,10.3 SCB121.2 198.34,11.47 198.93,12.06 v1(198.93,14.28) 198.82,14.39 198.82,18.33 196.48,20.67 196.48,23.46 v1(196.49,23.47)
  BOTTOM w0.102: v1(196.49,23.47) 195.86,24.1 182.1,24.1 180.24,22.25 177.56,22.25 176.24,20.93 169.55,20.93 168.79,21.69 165.35,21.69 v1(164.92,22.12) ; v1(198.93,14.28) 201.75,14.28 207.09,19.62 207.09,19.88 208.29,21.08 208.97,21.08 v2(209.61,21.73) 210.45,22.57 v1(210.45,23.2)
CLKOUT_LPC1_CLK_R: length 21.5
  TOP w0.089: PCH.AY17 167.28,43.21 v1(167.21,43.21)
  TOP w0.102: v1(166,28.24) 166,26.99 166.61,26.38 166.61,25.39 SR745.2
  BOTTOM w0.102: v1(167.21,43.21) 166.78,42.78 166.78,42.26 167.04,42 167.04,40.57 167.03,40.55 167.03,39.52 168.19,38.36 168.19,35.59 168.82,34.96 168.82,32.49 168.14,31.8 168.14,30.38 v2(166.75,28.99) v1(166,28.24)
CLKOUT_LPC1_R: length 6.5
  TOP w0.102: SCB69.2 ECR103.2 209.6,22.92 v1(209.6,23.24) 209.93,23.57 210.16,23.57 210.41,23.83 211.21,23.83 211.34,23.95 U104.7
  BOTTOM w0.102: v2(211.18,23.47) 211.02,23.62 209.98,23.62 v1(209.6,23.24)
CON_I2C_LED_SCL: length 87.1
  TOP w0.102: U15.42 120.05,35.77 121.63,34.19 UCR28.2 121.63,31.79 v1(121.59,31.76) ; v1(61.9,32.44) 60.85,31.38 60.85,28.62 57.51,25.28 57.51,23.2 58.43,22.28 58.43,21.4 58.63,21.2 58.63,20 58.51,19.88 58.51,18.68 59.17,18.02 59.17,15.93 SR7776.1
  BOTTOM w0.102: v1(61.9,32.44) 62.29,32.83 94.58,32.83 v2(94.87,32.54) 94.87,32.53 97.28,32.53 97.44,32.7 106.92,32.7 107.12,32.5 112.86,32.5 113.55,31.81 116.93,31.81 117.45,32.33 118.34,32.33 118.68,31.99 121.36,31.99 v1(121.59,31.76)
CON_I2C_LED_SDA: length 88.5
  TOP w0.102: v1(62.59,32.41) 61.06,30.89 61.06,28.47 57.73,25.14 57.73,23.29 58.65,22.37 58.65,21.49 58.85,21.29 58.85,19.81 58.73,19.69 58.73,18.87 59.42,18.18 59.42,15.26 SR7777.1 ; v1(122.29,31.7) 122.29,31.8 122.62,32.13 UCR29.2 122.62,33.71 120.06,36.27 U15.43
  BOTTOM w0.102: v1(62.59,32.41) 62.64,32.47 89.53,32.47 90.09,31.9 v2(96.95,31.9) 97.53,32.48 106.83,32.48 107.03,32.28 112.75,32.28 113.44,31.6 117.02,31.6 117.51,32.09 118.22,32.09 118.58,31.74 120.86,31.74 121.28,31.31 121.9,31.31 v1(122.29,31.7)
CPU_12V: length 24
  TOP w0.178: v1(216.92,34.01) 216.42,33.52 214.41,33.52 213.74,34.19 209.94,34.19 209.68,34.44 U104.108
  TOP w0.254: OR37.1 217.47,45.14 v1(217.53,45.09) 217.89,45.45 O2Q6.6
  BOTTOM w0.203: v1(217.53,45.09) 217.42,44.98 217.42,43.74 216.8,43.12 216.8,41.72 217.64,40.88 217.64,36.28 216.92,35.56 v2(216.92,34.75) v1(216.92,34.01)
CPU_DDI3_AUXN: length 141.5
  TOP w0.102: M1C13.1 36.36,174.62 37.62,174.62 v1(38.25,175.26) ; XU1.C11 108.42,152.25 103.96,152.25 99.62,147.9 98.71,147.9 97.9,147.09 97.43,147.09 v1(97.13,147.4)
  BOTTOM w0.102: 41.5,160.93 41.5,163.25 38.07,166.68 38.07,174.4 37.85,174.62 37.85,174.85 v1(38.25,175.26) ; 41.5,160.93 v2(41.8,160.93) ; 41.5,160.93 41.5,160.38 42.94,158.94 42.94,154.78 43.64,154.08 43.64,145.08 45.76,142.96 45.76,136.49 58.19,124.05 58.19,118.49 61.26,115.42 72.36,115.42 73.94,115.42 90.14,131.62 90.14,132.02 90.14,138.02 96.39,144.27 96.39,146.91 96.61,147.13 96.86,147.13 v1(97.13,147.4)
CPU_DDI3_AUXP: length 141.5
  TOP w0.102: M1C12.1 36.31,174.83 37.41,174.83 37.6,175.01 37.6,175.18 v1(37.52,175.26) ; XU1.B11 108.34,151.41 108.48,151.41 108.61,151.54 108.61,151.77 108.34,152.04 104.04,152.04 99.7,147.7 98.79,147.7 97.98,146.89 97.36,146.89 v1(97.13,146.66)
  BOTTOM w0.102: v1(37.52,175.26) 37.64,175.13 37.64,174.54 37.87,174.31 37.87,166.6 41.3,163.17 41.3,160.29 42.74,158.86 42.74,154.7 43.43,154 43.43,145 45.55,142.87 45.55,136.4 57.99,123.97 57.99,118.41 61.18,115.21 66.93,115.21 ; 66.93,115.21 72.27,115.21 74.02,115.21 90.35,131.54 90.35,132.11 90.35,137.94 96.6,144.19 96.6,146.83 96.69,146.93 96.86,146.93 v1(97.13,146.66) ; 66.93,115.21 v2(66.93,114.92)
CPU_VIDALERT#: length 41.8
  TOP w0.102: v1(111.56,182.3) 111.56,180.9 111.24,180.59 111.24,179.97 XU1.E39 ; v1(92.58,203.63) 90.53,205.69 HR20.2
  BOTTOM w0.102: v1(111.56,182.3) 111.56,182.37 110.21,183.72 105.99,183.72 95,194.71 95,200.74 92.58,203.15 v1(92.58,203.63) 92.63,203.63 93.47,204.47 93.47,206.22 v2(93.98,206.73)
CPU_VIDSCLK: length 46.2
  TOP w0.102: v1(110.11,182.88) 110.11,181.86 110.39,181.58 110.39,179.34 110.67,179.07 111.23,179.07 XU1.E38 ; v1(91.77,203.73) 89.51,205.99 HR17.1
  BOTTOM w0.102: v1(110.11,182.88) 109.75,183.24 105.79,183.24 94.49,194.54 94.49,200.41 91.77,203.12 v1(91.77,203.73) 91.77,203.78 92.91,204.93 92.91,207.06 92.58,207.39 v2(92.58,208.03)
CPU_VIDSOUT: length 38.5
  TOP w0.102: v1(93.36,203.62) 91.44,205.54 HR18.2 ; v1(112.19,182.14) 112.19,180.84 XU1.E40
  BOTTOM w0.102: v1(112.19,182.14) 112.19,182.42 110.54,184.07 110.54,184.07 110.41,184.2 106.19,184.2 95.53,194.86 95.53,200.89 93.36,203.06 v1(93.36,203.62) 93.38,203.62 93.98,204.22 v2(93.98,204.98)
CPU_VREF_CA_A: length 76.6
  TOP w0.254: D4R34.1 D4CB87.1 v1(165.61,225.43) ; XU1.AB40 127.28,180.56 126.72,181.12 126.44,181.12 123.13,184.44 123.13,195.6 134.12,206.59 134.29,206.59 135.34,207.65 v1(135.34,207.81)
  BOTTOM w0.254: v1(165.61,225.43) 165,224.82 147.54,224.82 145.44,222.71 v2(145.44,218.69) 145.44,218.34 135.66,208.56 135.66,208.13 v1(135.34,207.81)
CPU_VREF_CA_A_R: length 29
  TOP w0.254: D4C8.1 D4C21.1 189.98,229.24 189.83,229.4 CON_XMM1.146 186.93,229.4 186.04,230.28 184.96,230.28 184.07,229.39 181.39,229.39 CON_XMM3.146 181.38,229.97 179.98,231.37 174.73,231.37 D4C3.1 173.39,230.03 D4C22.1 171.69,229.38 171.69,229.24 D4R33.2 170.28,228.74 168.53,226.99 D4R32.1 D4R34.2
CPU_VREF_CA_B: length 124.4
  TOP w0.254: v1(189.87,232.53) 191.52,232.53 192.25,231.8 204.37,231.8 206.34,233.77 D4CB86.1 208.53,232.46 208.57,232.42 D4R30.1 ; XU1.AC39 127.76,179.91 127.76,180.59 123.69,184.67 123.69,195.36 134.36,206.04 134.53,206.04 136.22,207.72 v1(136.22,208.33)
  BOTTOM w0.254: v1(136.22,208.33) 146.23,218.34 146.23,222.71 147.77,224.26 165.43,224.26 165.89,224.71 166.91,224.71 v2(168.25,226.05) 168.26,226.06 169.57,226.06 176.04,232.53 v1(189.87,232.53)
CPUFAN_PWM: length 326.9
  TOP w0.102: U104.47 223.68,32.04 224.81,33.17 226.71,33.17 226.93,33.4 227.16,33.4 230.3,36.55 237.29,36.55 238.43,35.41 v1(238.97,35.41) ; FR32.1 146.89,234.31 146.74,234.16 v1(145.41,234.16) 145.08,234.49 FR33.2
  BOTTOM w0.102: v1(145.41,234.16) 146.15,234.16 146.51,233.8 155.06,233.8 159.8,229.07 168.61,229.07 174.42,234.88 174.42,235.02 177.69,238.28 206.67,238.28 207.59,237.36 212.53,237.36 216.64,233.26 225.87,233.26 228.53,230.61 231.93,230.61 v2(232.99,229.54) 232.99,227.07 236.73,223.34 236.73,217.14 237.38,216.5 237.38,215.64 236.91,215.17 236.91,213.07 235.39,211.55 235.39,205.12 235.32,205.04 235.32,198.92 235.62,198.62 235.62,149.76 234.98,149.11 234.98,143.45 235.61,142.81 235.61,117.28 236.52,116.36 236.52,112.04 235.6,111.11 235.6,93.01 231.7,89.11 231.7,87.92 230.36,86.59 229.17,86.59 228.16,85.57 228.16,73.31 233.65,67.81 233.65,62.66 238.25,58.07 238.25,51.63 236.03,49.41 236.03,42.53 238.34,40.22 238.34,36.39 238.97,35.76 v1(238.97,35.41)
CPUFAN_TACH: length 339.2
  TOP w0.102: U104.37 223.72,28.04 224.14,27.62 224.14,27.26 224.78,26.62 226.7,26.62 227.61,27.53 230.99,27.53 234.07,24.44 237.22,24.44 238.25,25.48 v1(238.25,25.96) ; FD7.3 143.76,232.82 143.75,232.8 FR35.2 142.82,233.24 v1(142.82,234.59)
  BOTTOM w0.102: v1(238.25,25.96) 239.05,26.76 239.05,32.75 238.47,33.34 238.47,35.96 238.12,36.3 238.12,40.13 235.81,42.44 235.81,49.5 238.03,51.72 238.03,57.98 233.44,62.57 233.44,67.72 227.94,73.22 227.94,85.66 229.09,86.8 230.27,86.8 231.48,88.01 231.48,89.21 235.38,93.1 235.38,111.2 236.31,112.13 236.31,116.28 235.4,117.19 235.4,142.72 234.76,143.36 234.76,149.2 235.41,149.85 235.41,198.53 234.56,199.38 234.56,208.01 235.03,208.48 235.03,211.49 236.69,213.16 236.69,215.89 236.47,216.1 236.47,223.23 232.49,227.22 232.49,228.94 231.38,230.05 v2(231.27,230.05) 228.78,230.05 225.78,233.04 216.55,233.04 212.44,237.15 207.5,237.15 206.58,238.07 177.78,238.07 174.68,234.96 174.68,234.83 168.7,228.85 159.71,228.85 154.97,233.59 146.42,233.59 146.29,233.72 143.7,233.72 v1(142.82,234.59)
CPUPWRGD: length 284.5
  TOP w0.089: PCH.AL2 160.38,47.35 160.03,47 158.51,47 158.1,46.59
  TOP w0.102: v1(30.46,64.62) 30.46,65.11 31.06,65.72 31.06,69.53 27.37,73.22 27.37,93.83 34.63,101.09 42.41,101.09 48.4,107.09 50.83,107.09 54.04,110.3 69.26,110.3 76,117.04 79.26,117.04 82.33,120.12 82.33,125.37 85.71,128.76 96.39,128.76 101.08,124.07 101.08,121.07 101.34,120.81 101.34,117.28 101.5,117.12 101.5,115.79 HR86.2 ; 158.1,46.59 156.43,44.92 151.92,44.92 151.87,44.87 145.78,44.87 145.33,45.32 143.86,45.32 v1(143.81,45.37)
  BOTTOM w0.102: v1(143.81,45.37) 142.9,45.37 139.63,42.1 139.07,42.1 136.69,39.72 129.19,39.72 128.42,38.95 121.42,38.95 120.97,38.49 106.74,38.49 105.77,39.46 104.05,39.46 103.95,39.56 101.29,39.56 101,39.56 101,39.56 85.09,39.56 82.18,42.47 79.53,42.47 78.11,41.05 59.18,41.05 57.23,43 43.49,43 v2(34.67,51.82) 34.16,52.32 34.16,60.91 v1(30.46,64.62)
CR7_LED: length 3.2
  TOP w0.102: R31.2 101.14,6.71 101.32,6.88 CR7.1 100.85,7.61 100.58,7.34 v1(100.58,7.01)
  BOTTOM w0.102: v2(100.07,6.49) v1(100.58,7.01)
CR9_R: length 6
  TOP w0.102: v1(103.76,7) 103.76,7.42 103.57,7.61 CR9.1 102.9,7.04 103,6.93 R25.2 104.3,6.36 104.7,6.76 Q4.3
  BOTTOM w0.102: v2(104.54,7) 103.76,7 v1(103.76,7)
CR25_R: length 3.3
  TOP w0.102: R27.2 CR25.1 99.2,6.96 v1(99.14,6.96)
  BOTTOM w0.102: v2(98.25,6.43) 98.6,6.43 v1(99.14,6.96)
CR26_R: length 3.5
  TOP w0.102: R69686.2 CR26.1 97.71,7 v1(97.51,7)
  BOTTOM w0.102: v1(97.51,7) 96.95,7 v2(96.52,6.57)
CR27_R: length 3.6
  TOP w0.102: R69687.2 CR27.1 96.46,7.61 95.94,7.09 v1(95.94,6.99)
  BOTTOM w0.102: v1(95.94,6.99) 95.59,6.63 v2(94.79,6.63)
DCPRTC: length 19.4
  TOP w0.089: PCH.BC27 172.89,41.58 172.89,41.95 v1(173.32,42.38)
  TOP w0.102: v1(176.35,32.74) 176.17,32.56 176.17,31.66 177,30.83 SCB36.1
  BOTTOM w0.089: v1(173.32,42.38) 173.89,41.8 173.89,41.21 175.06,40.04 175.06,38.53 176.2,37.39
  BOTTOM w0.102: 176.2,37.39 179.07,37.39 179.35,37.11 179.35,35.2 v2(177.16,33.02) 176.63,33.02 v1(176.35,32.74)
DDPD_HPD: length 294.4
  TOP w0.102: v1(17.84,173.87) MQ15.2 ; v1(21.93,58.06) v1(23.79,59.92) ; PCH.AP8 163.5,45.56 v1(163.93,45.14)
  BOTTOM w0.102: v1(23.79,59.92) 24.29,59.92 25.37,58.84 25.37,45.59 42.38,28.59 109.56,28.59 110.13,28.02 113.96,28.02 114.27,27.72 120.32,27.72 120.62,28.02 129.48,28.02 130.1,28.64 131.17,28.64 133.44,30.91 141.61,30.91 142.17,31.47 142.17,31.71 144.17,33.71 146.71,33.71 152.69,39.69 154.73,39.69 159.39,44.35 161.29,44.35 161.33,44.39 162.26,44.39 162.57,44.7 163.5,44.7 v1(163.93,45.14) ; v1(17.84,173.87) 17.78,173.81 v2(17.78,172.97) 18.01,172.75 18.01,159.74 22.75,155.01 22.75,149.67 22.8,149.62 22.8,148.68 22.56,148.43 22.56,143.92 21.37,142.74 21.37,140.19 23.83,137.73 23.83,136.44 24.49,135.79 24.49,127.88 23.38,126.77 23.38,124.47 23.1,124.19 23.1,121.41 21.32,119.63 21.32,113.17 21.6,112.89 21.6,58.38 v1(21.93,58.06)
DDPD_HPD_F: length 8.4
  TOP w0.102: MQ15.3 14.35,172.92 13.84,172.42 13.84,172.09 13.3,171.54 MR41.1 11.34,171.54 11.1,171.3 9.38,171.3 8.87,170.79 8.87,170.35 J125.18
DDR_VREF_CA_B_R: length 18.1
  TOP w0.254: D4C18.1 207.9,230 207.73,230.16 D4R20.1 D4R30.2 207.73,232.23 D4R21.2 ; D4C18.1 207.9,229.4 D4C23.1 D4C24.1 ; D4C18.1 207.01,229.62 D4C13.1 205.9,229.74 CON_XMM2.146 203.29,229.4 202.44,230.25 201.17,230.25 200.46,230.97 199.86,230.97 198.28,229.4 CON_XMM4.146
DDR_VTT_CNTL: length 221.4
  TOP w0.102: PR381.2 v1(215.67,154.99) ; XU1.AC36 127.82,177.11 127.82,178.55 127.42,178.94 127.14,178.94 122.43,183.66 122.43,196.27 133.93,207.78 133.93,209.07 137.06,212.19 v1(137.72,212.19) ; v1(209.25,233.3) 209.25,232.46 210.06,231.65 211.89,231.65 211.9,231.64 218.83,231.64 221.84,228.63 221.84,224.05 v1(221.72,223.93)
  BOTTOM w0.102: v1(221.72,223.93) 222,223.65 v2(222,222.68) 222,221.87 221.12,220.99 221.12,211.75 223.08,209.79 223.08,191.13 223.08,189.89 222.19,189 222.19,187.63 222.19,178.7 221.65,178.16 221.65,172.73 220.97,172.05 220.97,159.63 216.33,154.99 v1(215.67,154.99) ; v1(137.72,212.19) 144.65,219.13 144.65,222.92 147.25,225.52 161.75,225.52 162.99,226.76 169.28,226.76 175.84,233.32 175.87,233.35 207.98,233.35 208.03,233.3 v1(209.25,233.3)
DDR_VTT_CNTL_R: length 3.5
  TOP w0.102: v1(214.38,151.87) PQ115.1 215.12,152.91 PR381.1
  BOTTOM w0.102: v2(213.59,151.59) 214.1,151.59 v1(214.38,151.87)
DEBUGMODE[0]: length 3.2
  TOP w0.102: U10.5 35.18,218.59 35.31,218.72 35.31,219.13 v1(35.59,219.41) 35.74,219.56 LR23.1
  BOTTOM w0.102: v2(35.53,220.24) 35.59,220.19 v1(35.59,219.41)
DET_FIX#: length 276.4
  TOP w0.089: PCH.Y42 180.43,52.46 180.55,52.59 182.37,52.59 183.19,53.41 183.19,53.88 183.51,54.2
  TOP w0.102: v1(199.19,50.82) 199.19,48.64 198.46,47.91 198.46,36.55 197.85,35.94 197.85,34.9 193.29,30.34 193.29,28.86 194.59,27.57 194.59,19.23 196.63,17.19 196.63,13.62 195.25,12.23 194.87,12.23 194.33,11.68 193.26,11.68 191.96,10.38 191.96,8.4 191.08,7.52 190.04,7.52 189.51,6.99 v1(189.51,6.17) ; v1(120.05,12.18) 120.05,6.53 v1(120.07,6.5) ; v1(59.88,12.24) 59.38,12.24 59.05,11.91 59.05,9.69 SR7767.1 ; v1(143.82,9.89) 143.66,9.73 141.02,9.73 140.42,10.33 138.3,10.33 136.78,11.85 136.78,12.01 135.99,12.8 135.99,18.46 132.71,21.75 132.71,22 130.45,24.26 129.94,24.26 129.78,24.42 129.51,24.68 129.28,24.91 128.64,25.55 126.01,25.55 123.74,27.82 123.74,27.82 123.03,28.53 v1(122.47,28.53) ; SR673.2 198.02,56.9 197.74,57.18 v1(195.62,57.18) 195.36,57.43 186.75,57.43 183.51,54.2 ; UCR46.2 118.23,27.86 118.5,28.14 v1(118.8,28.14)
  BOTTOM w0.102: v1(199.19,50.82) 199.93,51.56 203.33,51.56 204,52.23 204,55.37 202.19,57.18 v1(195.62,57.18) ; v1(120.05,12.18) 120.03,12.17 104.15,12.17 104.07,12.09 94.23,12.09 93.92,12.4 92.02,12.4 91.43,11.8 86.27,11.8 85.42,12.64 62.49,12.64 62.4,12.55 60.19,12.55 v1(59.88,12.24) ; v1(118.8,28.14) 119.98,28.14 120.34,28.49 122.43,28.49 v1(122.47,28.53) ; v1(189.51,6.17) 188.15,7.53 176.86,7.53 173.31,3.98 157.39,3.98 155.15,6.23 v2(155.15,6.66) 155.15,7.5 152.75,9.89 v1(143.82,9.89) 140.18,6.25 120.32,6.25 v1(120.07,6.5)
DET_OPEN#: length 134.3
  TOP w0.102: SR7768.1 76.83,7.98 v1(76.61,7.76) ; v1(133.13,21.92) 136.21,18.84 136.21,12.89 137,12.1 137,11.94 138.29,10.64 139.01,10.64 UCR44.2 139.65,11.28 PQ9787.1 UCR48.2 141.29,11.25 v1(142.39,10.15) ; PCH.BC11 164.75,41.32 v1(164.22,41.84)
  BOTTOM w0.102: v1(142.39,10.15) 139.21,6.96 120.93,6.96 119.9,7.99 106.99,7.99 105.46,6.46 101.65,6.46 101.12,5.93 86.14,5.93 v2(85.57,6.5) 84.7,7.37 84.16,7.37 83.77,7.76 v1(76.61,7.76) ; v1(133.13,21.92) 134.16,22.96 136.44,22.96 139.49,26.01 147.52,26.01 150.89,29.39 152.84,29.39 153.16,29.71 156.35,29.71 156.58,29.48 158.23,29.48 160.15,31.4 160.15,34.23 163.63,37.71 163.63,40.54 163.8,40.7 163.8,41.42 v1(164.22,41.84)
DET_PUMP_FAN#: length 335.5
  TOP w0.102: v1(145.47,232.82) 145.47,232.21 145.29,232.03 143.01,232.03 142.39,232.65 142.39,234.06 141.21,235.24 139.45,235.24 138,236.69 133.78,236.69 SR7714.2 FR36.2 ; PCH.T44 183,54.61 186.47,58.08 198.53,58.08 198.93,57.68 201.73,57.68 204.09,60.05 204.09,61.47 205.21,62.58 205.21,74.19 v1(204.24,75.16)
  BOTTOM w0.102: v1(204.24,75.16) 204.9,75.82 206.68,75.82 207.19,76.33 209.52,76.33 211.8,78.61 217.91,78.61 219.75,80.45 222.07,80.45 223.94,82.33 224.6,82.33 225.32,83.05 v2(225.32,83.77) 225.32,84.81 228.4,87.88 229.68,87.88 230.4,88.61 230.4,89.65 233.39,92.64 233.39,100.88 234.23,101.72 234.23,133.38 230.77,136.84 230.77,141.54 231.2,141.97 231.2,146.69 227.32,150.58 227.32,164.38 229.21,166.27 229.21,179.84 229.12,179.93 229.12,184.53 229.22,184.63 229.22,185.71 229.74,186.23 229.74,190.6 230,190.86 230,203.16 230.91,204.08 230.91,212.53 232.1,213.72 233.26,213.72 233.81,214.26 233.81,214.85 233.71,214.95 233.71,218.57 231.27,221.01 231.27,223.15 223.65,230.77 222.03,230.77 220.39,229.13 216.26,229.13 210.77,234.62 208.94,234.62 206.14,237.42 178.05,237.42 175.32,234.7 175.32,234.56 168.97,228.21 159.44,228.21 154.78,232.87 145.52,232.87 v1(145.47,232.82)
DEVSLP: length 86.1
  TOP w0.089: 182.98,49.81 180.87,49.81 180.23,49.17 179.92,49.17 PCH.AG41
  TOP w0.102: v1(213.03,11.73) 213.03,10.08 213.28,9.83 APR13.1 ; v1(194.08,12.34) 196.15,14.41 196.15,17.06 194.37,18.84 194.37,27.17 193.08,28.47 193.08,30.64 194.51,32.08 194.51,33.17 198.13,36.79 v1(198.13,49.38) ; v1(185.02,51.32) 183.51,49.81 182.98,49.81
  BOTTOM w0.102: v1(213.03,11.73) 212.55,11.73 v2(212.33,11.52) 211.32,10.51 200.25,10.51 198.49,12.27 196.42,12.27 196.15,12.53 194.27,12.53 v1(194.08,12.34) ; v1(185.02,51.32) 186.33,52.64 187.97,52.64 188.76,51.84 195.26,51.84 197.72,49.38 v1(198.13,49.38)
DEVSLP_SSD_SLEEP_MODE: length 14.5
  TOP w0.102: APR13.2 212.83,8.29 212.83,9.58 212.47,9.93 212.47,12.48 v1(213.77,13.78) 215.81,15.82 218.01,15.82 218.36,16.17 SS4.38
  BOTTOM w0.102: v2(214.32,13.23) v1(213.77,13.78)
DIAG_LED#: length 177.1
  TOP w0.102: U104.23 217.74,25.54 v1(217.12,26.16) ; v1(202.02,6.04) 202.41,6.42 202.41,10.17 200.68,11.9 v1(200.68,13.86) ; v1(74.35,7.16) 73.03,8.47 SR7677.1 AC194.1 AD21.1 71.16,8.16 P189.10
  BOTTOM w0.102: v1(200.68,13.86) 201.75,13.86 208.04,20.14 v2(208.05,20.14) 209.48,20.14 212.19,22.86 214.4,22.86 217.12,25.57 v1(217.12,26.16) ; v1(74.35,7.16) 74.43,7.08 77.18,7.08 77.43,7.33 83.59,7.33 85.41,5.5 101.3,5.5 101.73,5.93 105.55,5.93 107.18,7.56 119.66,7.56 120.69,6.53 139.67,6.53 143.46,10.31 152.64,10.31 155.79,7.16 155.79,6.31 157.69,4.41 173.38,4.41 176.71,7.74 188.58,7.74 190.67,5.65 201.64,5.65 v1(202.02,6.04)
DMI_RXN0: length 127.2
  TOP w0.076: PCH.D27 172.58,60.75 172.34,60.99 172.34,61.19 172.28,61.25 172.28,62.52 172.29,62.53 172.29,62.88
  TOP w0.102: v1(140.97,112.01) 140.97,114.88 133.62,122.22 123.59,122.22 121.36,124.45 121.36,132.36 123.66,134.65 123.66,141.12 123.97,141.44 123.97,144.7 XU1.Y4 ; v1(173.13,72.44) 173.35,72.21 173.35,66.02 172.29,64.96 172.29,62.88
  BOTTOM w0.102: v1(140.97,112.01) 141.15,111.84 141.15,110.31 ; v2(140.86,110.31) 141.15,110.31 ; 141.15,110.31 141.15,106.93 144.6,103.48 144.6,96.25 150.18,90.68 168.6,90.68 175.31,83.96 175.31,75.56 173.76,74.02 173.56,74.02 172.87,73.32 172.87,72.93 173.13,72.68 v1(173.13,72.44)
DMI_RXN1: length 119.8
  TOP w0.089: PCH.B27 172.8,61.7 172.8,62.5 172.79,62.51 172.79,62.56 172.77,62.57 172.77,62.59
  TOP w0.102: XU1.AA5 125.29,146.02 125.17,146.02 124.89,145.75 124.89,144.18 124.54,143.84 124.54,142.98 124.69,142.83 124.69,141.17 124.38,140.86 124.38,132.72 141.78,115.31 141.78,112.85 142.32,112.32 v1(142.98,112.32) ; v1(174.37,72.94) 174.48,72.94 174.73,72.69 174.73,71.73 174.07,71.07 174.07,65.95 172.77,64.65 172.77,62.59
  BOTTOM w0.102: 143.6,110.31 143.6,110.88 143.54,110.94 143.54,111.76 v1(142.98,112.32) ; 143.6,110.31 v2(143.3,110.31) ; 143.6,110.31 143.6,105.46 145.29,103.76 145.29,96.55 150.3,91.54 168.72,91.54 176,84.26 176,75.28 174.65,73.93 174.65,73.22 v1(174.37,72.94)
DMI_RXN2: length 119.7
  TOP w0.089: PCH.B28 173.18,61.32 173.24,61.26 173.37,61.26 173.43,61.33 173.43,61.6 173.43,61.66 173.52,61.78 173.52,61.8 173.52,62.34 173.53,62.35
  TOP w0.102: 173.53,62.35 173.53,64.28 174.96,65.7 174.96,70.69 176.53,72.26 v1(176.53,73.36) ; v1(144.43,112.6) 144.43,112.47 144.2,112.24 143.98,112.24 143.89,112.34 143.89,114.46 125.31,133.05 125.31,140.34 125.52,140.55 125.52,143.02 126.01,143.51 126.01,144.62 126.17,144.78 126.29,144.78 126.37,144.7 XU1.AB3
  BOTTOM w0.102: v2(145.44,107.04) 145.14,107.04 ; 145.14,107.04 145.14,111.7 144.92,111.92 144.92,112.11 v1(144.43,112.6) ; 145.14,107.04 145.14,105.22 146.23,104.14 146.23,96.88 150.6,92.51 169.02,92.51 176.89,84.65 176.89,74.91 176.3,74.32 176.3,73.58 v1(176.53,73.36)
DMI_RXN3: length 121.8
  TOP w0.089: PCH.C29 173.7,61.18 174.02,61.49 174.02,63.36
  TOP w0.102: v1(178.16,75.46) 177.65,75.46 177.52,75.34 177.52,72.28 175.64,70.4 175.64,65.25 174.75,64.36 174.37,64.36 174.02,64.01 174.02,63.36 ; XU1.AC5 127.12,146.02 126.92,146.02 126.72,145.82 126.71,145.82 126.71,143.76 125.96,143 125.96,141.42 125.96,141.23 126,141.18 126,140.13 125.83,139.95 125.83,133.21 145.19,113.85 145.19,111.96 145.43,111.71 145.67,111.71 v1(145.9,111.48)
  BOTTOM w0.102: v2(146.43,105.54) 146.72,105.54 ; 146.72,105.54 146.72,97.07 150.68,93.12 169.1,93.12 177.37,84.85 177.37,75.97 177.64,75.7 177.91,75.7 v1(178.16,75.46) ; 146.72,105.54 146.72,106.07 146.18,106.62 146.18,107.19 145.67,107.7 145.67,109.96 146.23,110.52 146.23,111.15 v1(145.9,111.48)
DMI_RXP0: length 127.1
  TOP w0.076: 172.49,62.88 172.49,62.51 172.46,62.48 172.46,61.32 172.52,61.26 172.52,61.19 PCH.C27
  TOP w0.102: XU1.Y3 124.54,144.66 124.47,144.74 124.31,144.74 124.17,144.6 124.17,141.36 123.86,141.04 123.86,134.57 121.56,132.28 121.56,124.54 123.67,122.43 133.71,122.43 141.17,114.96 141.17,112.45 141.25,112.37 141.53,112.37 141.6,112.29 v1(141.6,112.01) ; v1(173.61,72.9) 173.61,72.39 173.56,72.34 173.56,65.94 172.49,64.88 172.49,62.88
  BOTTOM w0.102: 141.35,108.25 141.35,111.76 v1(141.6,112.01) ; 141.35,108.25 v2(141.64,108.25) ; 141.35,108.25 141.35,107.02 144.81,103.56 144.81,96.34 150.26,90.88 168.68,90.88 175.51,84.05 175.51,75.48 173.85,73.81 173.65,73.81 173.08,73.24 173.08,73.01 173.19,72.9 v1(173.61,72.9)
DMI_RXP1: length 119.8
  TOP w0.089: 172.97,62.59 172.97,62.09 PCH.A28
  TOP w0.102: v1(142.97,112.96) 142.52,112.52 142.4,112.52 141.99,112.94 141.99,115.4 124.58,132.8 124.58,140.78 124.89,141.09 124.89,142.92 124.75,143.06 124.75,143.75 125.09,144.1 125.09,145.66 125.22,145.79 125.4,145.79 125.45,145.74 XU1.AA4 ; 172.97,62.59 172.97,64.57 174.27,65.86 174.27,70.98 174.93,71.65 174.93,72.92 v1(175.01,73.01)
  BOTTOM w0.102: 143.8,108.41 143.8,110.96 143.74,111.02 143.74,111.84 143.41,112.17 143.41,112.52 v1(142.97,112.96) ; 143.8,108.41 v2(144.09,108.41) ; 143.8,108.41 143.8,105.54 145.49,103.85 145.49,96.63 150.38,91.74 168.8,91.74 176.2,84.35 176.2,75.19 174.85,73.85 174.85,73.17 v1(175.01,73.01)
DMI_RXP2: length 119.7
  TOP w0.089: 173.33,62.35 173.34,62.34 173.34,62.25 173.34,62.24 173.34,61.86 173.32,61.83 173.25,61.75 173.02,61.67 172.95,61.52 172.93,61.45 172.93,61.2 173,61.13 PCH.C28
  TOP w0.102: 173.33,62.35 173.33,64.36 174.75,65.79 174.75,70.77 176.33,72.35 176.33,72.66 v1(176.01,72.98) ; XU1.AB4 126.11,145.01 125.81,144.71 125.81,143.59 125.32,143.1 125.32,140.64 125.1,140.42 125.1,132.96 143.69,114.38 143.69,112.25 143.9,112.04 144.4,112.04 v1(144.5,111.94)
  BOTTOM w0.102: v1(176.01,72.98) 176.1,73.07 176.1,74.41 176.68,74.99 176.68,84.56 168.94,92.3 150.51,92.3 146.02,96.79 146.02,104.06 144.94,105.14 144.94,105.44 ; 144.94,105.44 144.94,111.62 144.62,111.94 v1(144.5,111.94) ; 144.94,105.44 v2(144.65,105.44)
DMI_RXP3: length 121.8
  TOP w0.089: 173.81,63.36 173.81,63.35 173.83,63.33 173.83,63.28 173.84,63.28 173.84,61.71 PCH.B29
  TOP w0.102: XU1.AC4 127.28,145.75 127.21,145.82 127.01,145.82 126.92,145.73 126.92,143.67 126.16,142.92 126.16,141.31 126.21,141.27 126.21,140.04 126.03,139.87 126.03,133.29 145.39,113.94 145.39,112.04 145.52,111.91 145.7,111.91 v1(145.91,112.12) ; v1(178.13,76.12) 177.67,75.67 177.56,75.67 177.32,75.42 177.32,72.36 175.44,70.48 175.44,65.34 174.67,64.57 174.29,64.57 173.81,64.09 173.81,63.36
  BOTTOM w0.102: v1(145.91,112.12) 146.33,111.69 146.33,111.34 146.43,111.23 146.43,110.44 145.87,109.88 145.87,107.78 146.38,107.27 146.38,106.71 146.93,106.16 146.93,101.6 ; 146.93,101.6 146.93,97.16 150.76,93.32 169.18,93.32 177.57,84.93 177.57,76.06 177.72,75.91 177.91,75.91 v1(178.13,76.12) ; 146.93,101.6 v2(147.22,101.6)
DMI_TXN0: length 125.4
  TOP w0.102: v1(172.13,57.42) 172.13,57.36 172.43,57.06 PCH.L27 ; XU1.AC1 127.28,142.74 127.15,142.88 126.91,142.88 126.82,142.78 126.82,142.24 127.03,142.02 127.03,139.84 126.76,139.57 126.76,133.54 146.81,113.49 146.81,111.61 147.32,111.1 148.16,111.1 148.55,110.71 148.55,109.72 148.26,109.42 148.26,108.94 148.13,108.81 147.9,108.81 v1(147.75,108.97)
  BOTTOM w0.102: 148.6,104.44 148.6,109.16 148.5,109.26 148.04,109.26 v1(147.75,108.97) ; 148.6,104.44 148.6,97.7 151.71,94.59 169.59,94.59 179.02,85.16 179.02,77.65 179.45,77.22 179.45,74.32 173.24,68.11 173.24,61.77 173.08,61.6 173.08,60.76 172.61,60.3 172.61,57.49 172.39,57.28 172.27,57.28 v1(172.13,57.42) ; 148.6,104.44 v2(148.3,104.44)
DMI_TXN1: length 122.7
  TOP w0.102: v1(172.16,59.68) 172.15,59.66 171.92,59.66 PCH.E24 ; v1(148.21,111.94) 147.98,112.17 147.98,113.33 127.48,133.83 127.48,139.32 127.74,139.57 127.74,142.06 127.82,142.15 127.82,143.7 127.99,143.87 128.12,143.87 128.2,143.79 XU1.AD2
  BOTTOM w0.089: v1(172.16,59.68) 172.14,59.68 171.93,59.89 171.93,60.04 172.29,60.4
  BOTTOM w0.102: 147.07,107.52 147.07,108.42 146.96,108.52 146.96,110 147.19,110.23 147.19,110.46 147.75,111.02 147.75,111.35 147.85,111.46 148.34,111.46 148.41,111.53 148.41,111.73 v1(148.21,111.94) ; 147.07,107.52 v2(147.36,107.52) ; 147.07,107.52 147.07,107.02 147.65,106.43 147.65,103.07 148.08,102.64 148.08,97.42 151.4,94.11 169.39,94.11 178.51,84.98 178.51,77.43 178.97,76.97 178.97,74.52 172.39,67.94 172.39,61.8 172.69,61.49 172.69,60.81 172.29,60.4
DMI_TXN2: length 121.2
  TOP w0.102: XU1.AE1 128.99,142.65 128.86,142.65 128.76,142.54 128.76,142.28 128.88,142.15 128.88,141.49 128.52,141.13 128.52,139.24 128.2,138.92 128.2,134.09 150.62,111.67 150.62,110.08 150.32,109.78 150.32,109.37 150.23,109.28 v1(149.87,109.28) ; v1(173.25,59.3) 173.17,59.39 172.62,59.39 PCH.G27
  BOTTOM w0.102: 149.94,104.47 149.94,105.85 149.51,106.28 149.51,109.17 149.62,109.28 v1(149.87,109.28) ; 149.94,104.47 149.94,97.82 152.27,95.48 169.98,95.48 179.91,85.55 179.91,78.04 180.34,77.61 180.34,73.94 174.6,68.2 174.6,65.19 174.01,64.6 174.01,61.57 173.76,61.33 173.76,60.43 173.65,60.31 173.65,59.74 173.25,59.35 v1(173.25,59.3) ; 149.94,104.47 v2(150.23,104.47)
DMI_TXN3: length 126.4
  TOP w0.102: XU1.AF3 129.71,144.04 129.71,144.04 129.46,143.79 129.46,141.5 129.05,141.09 129.05,139.03 128.72,138.71 128.72,134.26 152.15,110.84 152.15,108.61 152.02,108.48 151.7,108.48 151.59,108.59 v1(151.59,108.92) ; PCH.L29 173.45,57.06 v1(173.3,56.92)
  BOTTOM w0.102: 151.33,100.69 151.33,107.49 151.71,107.87 151.71,108.46 151.59,108.59 v1(151.59,108.92) ; 151.33,100.69 151.33,99.63 150.98,99.28 150.98,97.77 152.55,96.19 170.25,96.19 180.59,85.85 180.59,78.33 181.03,77.9 181.03,73.63 175.31,67.91 175.31,63.57 174.8,63.06 174.8,60.7 174.43,60.33 174.33,60.33 174.04,60.04 174.04,57.76 173.3,57.02 v1(173.3,56.92) ; 151.33,100.69 v2(151.63,100.69)
